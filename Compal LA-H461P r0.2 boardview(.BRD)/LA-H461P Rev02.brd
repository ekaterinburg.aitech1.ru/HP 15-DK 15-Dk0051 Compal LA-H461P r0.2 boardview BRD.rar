# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKREQ_PCIE#1: length 130.9
  TOP w0.135: v2(199.86,17.59) 199.86,17.05 v1(200.39,16.52) 200.49,16.42 RH206.2
  IN1 w0.127: v2(306.3,10.92) 306.71,10.92 307.31,10.32 307.31,8.49 304.7,5.88 301.21,5.88 299.96,4.63 282.74,4.63 275.7,11.67 275.7,12.25 274.96,12.99 274.46,12.99 273.57,13.89 265.7,13.89 264.98,13.17 254.2,13.17 253.64,13.72 249.94,13.72 247.48,11.26 243.32,11.26 242.29,12.3 236.76,12.3 236.31,12.75 231.18,12.75 230.4,11.97 228.47,11.97 227.88,12.55 225.63,12.55 224.85,11.77 222.29,11.77 221.05,10.53 218.5,10.53 217.68,11.34 210.08,11.34 204.84,16.57 204.19,16.57 202.98,17.78 200.05,17.78 v2(199.86,17.59)
  BOTTOM w0.102: UH1.BE31 199.54,18.97 199.54,17.9 v2(199.86,17.59)
  BOTTOM w0.135: JWLAN1.45 303.57,11.6 304.07,11.09 306.13,11.09 v2(306.3,10.92)
CLKREQ_PCIE#2: length 218.2
  TOP w0.102: 198.87,21.04 198.87,20.08 198.56,19.77 198.56,17.75
  TOP w0.127: v2(198.67,24.14) 199.04,24.14 199.42,23.76 199.42,21.6 198.87,21.04 ; v2(19.84,8.56) 20.24,8.96 v1(20.88,8.96) 21.07,9.15 34.16,9.15 34.57,9.55 36.13,9.55 37.36,10.78 39.79,10.78 42.59,13.57 45.34,13.57 46.48,14.71 53.1,14.71 53.52,14.29 57.44,14.29 60.3,17.15 61.33,17.15 63.79,19.61 63.79,21.46 65.15,22.82 67.01,22.82 67.3,22.54 v2(67.3,21.57)
  TOP w0.135: RH207.2 198.13,15.31 198.13,17.32 198.56,17.75
  IN2 w0.127: v2(67.3,21.57) 68.84,23.11 72.11,23.11 72.93,22.29 84.25,22.29 87.21,19.33 109.78,19.33 112.4,16.71 114.39,16.71 114.98,16.12 118.24,16.12 118.53,16.41 120.65,16.41 121.08,16.84 122.22,16.84 122.99,17.6 123.63,17.6 124.25,16.98 127.09,16.98 128.06,17.95 134.2,17.95 136.18,15.97 140.44,15.97 143.07,18.61 146.03,18.61 147.25,19.83 151.67,19.83 152.5,20.66 158.39,20.66 158.48,20.74 160.61,20.74 161.32,20.03 167.9,20.03 168.62,20.75 177.1,20.75 181.9,25.54 184.09,25.54 184.65,24.98 187.11,24.98 187.67,25.54 188.67,25.54 189.59,26.46 190.59,26.46 192.07,24.99 193.79,24.99 194.36,24.42 195.35,24.42 195.5,24.57 197.94,24.57 198.37,24.14 v2(198.67,24.14)
  BOTTOM w0.127: v2(198.67,24.14) 199.04,24.14 UH1.AR32 ; JSSD1.52 23.1,4.61 20.22,7.49 20.22,8.17 v2(19.84,8.56)
CLKREQ_PCIE#3: length 180.5
  TOP w0.127: v2(46.96,13.1) 47.08,12.98 v1(47.81,12.98) 49.74,12.98 50.09,13.33 52.63,13.33 52.98,12.98 53.55,12.98 54.37,12.16 57.16,12.16 60.84,15.84 61.87,15.84 65.37,19.34 65.37,19.77 v2(66.61,21.01)
  TOP w0.135: RH208.2 199.73,16.28 199.41,16.59 199.41,18.64 199.73,18.96 199.73,19.6 v2(199.44,19.89)
  IN2 w0.127: v2(199.44,19.89) 198.11,19.89 197.02,18.79 193.51,18.79 193.11,19.19 192.18,19.19 191.92,19.45 191.92,19.63 190.65,20.91 188.75,20.91 187.03,22.63 183.86,22.63 183.11,23.38 181.31,23.38 177.6,19.67 169.06,19.67 167.63,18.24 151.64,18.24 149.21,15.81 143.84,15.81 142.53,14.51 135.9,14.51 134.23,16.17 131.96,16.17 131.68,16.46 131.36,16.46 130.51,15.61 128.26,15.61 128.11,15.76 121.52,15.76 121.1,15.34 119.09,15.34 118.22,14.47 113.08,14.47 110.22,17.33 107.96,17.33 107.66,17.63 101.99,17.63 101.38,18.25 86.76,18.25 83.87,21.15 79.12,21.15 77.83,19.86 66.65,19.86 66.61,19.89 v2(66.61,21.01)
  BOTTOM w0.127: v2(199.44,19.89) 199.6,19.89 UH1.BB30 ; UR1.2 42.61,14.12 43.17,13.56 45.1,13.56 45.56,13.1 v2(46.96,13.1)
CLKREQ_PCIE#5: length 168.3
  TOP w0.102: v2(199.82,21.68) 199.07,20.94 199.07,20 198.84,19.76 198.84,19 199.09,18.74 199.09,18.57
  TOP w0.135: RH205.2 v1(198.96,16.16) 198.96,16.53 199.09,16.66 199.09,18.57
  IN2 w0.127: v2(67.69,21.14) 67.69,21.2 67.94,21.45 67.94,21.68 69.1,22.85 72,22.85 72.82,22.02 84.13,22.02 87.1,19.06 107.37,19.06 108.3,18.14 110.59,18.14 112.29,16.44 114.28,16.44 115.45,15.27 117.88,15.27 118.75,16.14 120.77,16.14 121.19,16.57 122.33,16.57 123.1,17.33 123.52,17.33 124.14,16.71 127.2,16.71 127.54,17.05 130.81,17.05 131.44,17.68 134.09,17.68 136.07,15.7 140.55,15.7 142.49,17.64 149.86,17.64 152.58,20.36 158.47,20.36 158.59,20.47 160.5,20.47 161.21,19.76 168.02,19.76 168.73,20.48 177.21,20.48 181.94,25.21 184.04,25.21 184.54,24.71 187.22,24.71 187.78,25.27 188.78,25.27 189.7,26.2 190.48,26.2 191.95,24.72 193.68,24.72 194.87,23.53 197.93,23.53 198.4,23.06 198.56,23.06 198.81,22.81 198.81,22.35 199.47,21.68 v2(199.82,21.68)
  BOTTOM w0.127: v2(199.82,21.68) 200.15,22.02 200.59,22.02 200.85,22.27 200.85,24.45 UH1.AN29 ; RL6.2 60.23,19.41 60.76,18.88 62.72,18.88 65.14,21.3 65.14,22.16 65.6,22.61 67.02,22.61 67.78,21.85 67.78,21.27 67.69,21.17 v2(67.69,21.14)
CLKREQ_PCIE#5_R: length 2
  BOTTOM w0.127: RL6.1 59.31,19.88 59.04,20.14 UL1.12
CLKREQ_PEG#4: length 107.6
  TOP w0.127: v2(177,66.98) 176.59,67.4 176.59,69.23 183.34,75.99 v1(183.34,78.42) 183.34,81.76 v2(183.78,82.2) ; v2(216.32,18.29) 216.24,18.21 RH209.2
  IN1 w0.127: v2(216.32,18.29) 215.26,18.29 215.14,18.17 213.64,18.17 212.67,17.2 211.17,17.2 209.89,18.48 207.39,18.48 205.97,19.9 205.32,19.9 204.57,20.65 204.57,21.65 203.61,22.61 203.26,22.61 203.02,22.36 203.02,19.35 202.67,19 201.26,19 199.83,20.43 199.3,20.43 199.05,20.68 199.05,23.22 v2(198.73,23.54)
  IN3 w0.102: v2(198.73,23.54) 198.17,24.1 198.17,24.75 198.3,24.87 198.3,25.45 198.08,25.66 195.53,25.66
  IN3 w0.127: 195.53,25.66 195.11,26.09 195.11,26.25 194.71,26.65 192.43,26.65 191.36,27.72 191.36,30.26 192.06,30.97 192.06,35.91 187.14,40.83 187.02,40.83 185.16,42.69 185.16,45.51 181.61,49.05 181.61,51.46 176.44,56.63 176.44,66.4 177,66.95 v2(177,66.98)
  BOTTOM w0.127: v2(183.78,82.2) 183.47,81.89 QG1.6 ; v2(198.73,23.54) 199.33,23.54 199.55,23.33 199.55,22.15 199.39,21.99 199.39,21.57 199.66,21.3 199.95,21.3 200.11,21.15 UH1.BA30
CMSRC: length 38.9
  TOP w0.203: PUB01.29 238.09,13.13 237.32,13.9 237.32,14.37
  TOP w0.381: 237.32,14.37 237.32,15.45 237.69,15.82 241.38,15.82 241.54,15.65 248.51,15.65 v1(251.07,18.21) 251.61,18.74 251.61,20.63 252.01,21.02 v2(252.17,21.02) ; PRB04.2 264.26,30.45 263.28,30.45 262.54,29.71 v2(262.5,29.71)
  IN3 w0.381: v2(262.5,29.71) 262.43,29.64 262.43,28.69 254.8,21.06 252.21,21.06 v2(252.17,21.02)
CNV_BRI_PRX_DTX: length 117
  TOP w0.127: v1(306.73,19.45) 307.15,19.02 v2(307.39,19.02)
  TOP w0.135: RWL13.2 306.91,17.7 RWL18.1 306.91,18.54 v2(307.39,19.02)
  IN1 w0.127: v2(216.92,21.73) 217.05,21.86 217.7,21.86 217.81,21.75 219.41,21.75 219.96,22.3 219.96,23.85 220.48,24.37 220.48,28.03 224.87,32.42 230.4,32.42 231.04,33.06 234.83,33.06 235.68,33.91 247.63,33.91 249.15,32.39 252.63,32.39 252.99,32.03 255.04,32.03 258.36,28.71 264.89,28.71 265.9,27.7 274.26,27.7 275.02,26.94 276.34,26.94 277.02,26.26 278.34,26.26 281.07,23.53 281.45,23.53 288.99,16 295.03,16 296.16,17.13 298.27,17.13 300.98,19.85 302.38,19.85 303.85,21.32 304.75,21.32 305.36,20.7 306.87,20.7 307.78,19.79 307.78,19.41 v2(307.39,19.02)
  BOTTOM w0.102: 215.16,20.99 214.94,21.21 213.79,21.21 UH1.AY2
  BOTTOM w0.127: v2(216.92,21.73) 216.82,21.63 216.82,20.98 216.5,20.66 215.49,20.66 215.16,20.99
CNV_BRI_PRX_DTX_R: length 4.1
  TOP w0.135: RWL18.2 308.23,18.44 308.45,18.22 v1(308.83,18.22) 309.06,18.22 v2(309.38,18.54) 309.48,18.44 RWL32.2
  BOTTOM w0.127: JWLAN1.22 309.65,19.35 309.38,19.08 v2(309.38,18.54)
CNV_BRI_PTX_DRX: length 121.2
  TOP w0.135: v2(308.03,14.6) 307.5,14.6 307.04,15.06 RWL22.1
  IN1 w0.127: v2(219.8,24.28) 219.89,24.28 220.22,24.61 220.22,28.14 224.76,32.68 230.29,32.68 230.93,33.32 234.72,33.32 235.57,34.17 247.74,34.17 249.26,32.65 252.74,32.65 253.1,32.29 255.15,32.29 258.45,28.99 262.74,28.99 263.32,29.56 264.41,29.56 266.01,27.96 274.37,27.96 275.13,27.2 276.45,27.2 277.13,26.52 278.45,26.52 281.18,23.79 281.56,23.79 289.09,16.26 294.92,16.26 296.05,17.39 298.16,17.39 300.88,20.11 302.27,20.11 303.74,21.58 304.86,21.58 305.47,20.96 306.98,20.96 308.06,19.89 308.06,18.39 308.03,18.36 v2(308.03,14.6)
  BOTTOM w0.102: 216.48,22.13 215.92,22.13 215.38,21.59 214.39,21.59 213.79,22.2 213.43,22.2 213.34,22.11 212.92,22.11 UH1.AV4
  BOTTOM w0.127: 216.48,22.13 217.31,22.13 217.68,22.5 RH26.2
  BOTTOM w0.135: RH26.2 218.33,22.73 219.18,22.73 219.8,23.35 v1(219.8,23.67) v2(219.8,24.28)
CNV_BRI_PTX_DRX_R: length 3.3
  TOP w0.127: v1(309.42,14.87) v2(308.95,15.34)
  TOP w0.135: RWL22.2 308.39,15.26 308.47,15.34 v2(308.95,15.34)
  BOTTOM w0.127: v2(308.95,15.34) 309.46,15.85 JWLAN1.28
CNV_CLKREQ: length 124.5
  TOP w0.127: v2(309.28,21.1) 309.29,21.11 RWL2.1
  TOP w0.135: v2(291.71,9.05) 291.71,9.33 294.13,11.75 297.26,11.75 300.28,14.77 300.6,14.77 301.16,15.34 301.16,15.76 301.63,16.22 303.28,16.22 303.52,16.46 304.46,16.46 305.2,17.19 305.2,19.28 v1(306.8,20.88) 307.18,21.26 308.68,21.26 308.84,21.1 v2(309.28,21.1)
  IN1 w0.127: v2(291.71,9.05) 290.94,8.28 281.16,8.28 275.62,13.81 275.62,14.4 274.69,15.33 267.73,15.33 267.33,14.93 264.64,14.93 263.92,14.21 257.34,14.21 256.75,14.8 247.98,14.8 247.3,14.13 234.36,14.13 234.02,13.79 226.34,13.79 226.04,14.08 224.8,14.08 223.54,12.83 221.87,12.83 221.44,12.39 215.89,12.39 215.26,13.02 213.36,13.02 212.98,12.64 212.02,12.64 211.03,13.64 209.55,13.64 206.84,16.35 206.84,16.69 v2(207.14,16.99)
  BOTTOM w0.127: v2(309.28,21.1) 309.54,21.35 JWLAN1.14 ; v2(207.14,16.99) 206.51,16.99 206.09,17.42 206.09,18.02 206.15,18.08 206.15,19.23 205.97,19.41 205.97,20.6 UH1.BA17
CNV_PRX_DTX_N0: length 124.6
  IN1 w0.135: v2(304.71,18.7) 304.5,18.49 304.09,18.49 303.25,17.65 303.25,17.2 303.57,16.89 303.57,16.61 303.25,16.3 303.25,15.54 301.63,13.92 301.01,13.92 300.87,14.05 300.87,14.2 300.57,14.5 299.97,14.5 299.67,14.2 299.67,14.05 298.99,13.36 298.23,13.36 297.69,12.83 293.66,12.83 292.75,11.92 286.46,11.92 285.64,12.75 285.64,13.32 282.23,16.73 282.23,18.59 279.76,21.07 278.94,21.07 277.41,22.6 273.78,22.6 271.76,24.63 264.69,24.63 263.8,25.52 256.18,25.52 255.35,26.34 254.95,26.34 254.87,26.26 254.66,26.26 254.41,26.5 254.41,26.71 254.49,26.8 254.49,27.2 251.64,30.05 248.18,30.05 246.68,31.55 237.82,31.55 237,30.72 232.01,30.72 231.36,30.07 226.81,30.07 222.82,26.08 222.82,21.65 219.71,18.54 219.71,18.12 219.44,17.85 219.14,17.85 218.89,18.1 216.75,18.1 216.5,17.85 215.44,17.85 215.33,17.74 214.88,17.74 214.53,17.39 214.53,16.66 v2(214.42,16.55)
  BOTTOM w0.102: v2(214.42,16.55) 214.32,16.65 214.32,16.74 214.42,16.84 214.74,16.84 214.8,16.91 214.8,17.06 215.22,17.47 215.22,17.99 215.04,18.17 215.04,18.44 215.22,18.62 215.22,19.14 214.99,19.38 214.77,19.38 214.62,19.53 214.62,19.74 214.44,19.92 214.14,19.92 214.08,19.87 214.08,19.8 213.98,19.69 213.91,19.69 UH1.BB3
  BOTTOM w0.127: JWLAN1.15 303.46,21.1 303.62,20.94 303.95,20.94 304.21,20.68 304.21,18.68 304.33,18.57 304.58,18.57 v2(304.71,18.7)
CNV_PRX_DTX_N1: length 125.2
  IN1 w0.135: v2(215.61,16.56) 215.83,16.77 215.83,16.79 216.02,16.98 216.42,16.98 216.57,17.14 218.04,17.14 219.01,16.73 219.33,16.73 220.42,17.83 220.42,18.24 223.54,21.35 223.54,25.79 227.09,29.34 231.64,29.34 232.31,30 237.29,30 238.12,30.83 241.4,30.83 242.48,29.75 245.29,29.75 245.72,29.33 250.57,29.33 255.1,24.8 261.47,24.8 262.36,23.91 271.46,23.91 273.48,21.88 277.11,21.88 278.65,20.35 279.46,20.35 281.51,18.3 281.51,16.34 284.92,12.93 284.92,12.45 286.16,11.2 293.05,11.2 293.96,12.11 297.99,12.11 298.53,12.65 299.39,12.65 299.94,13.2 301.98,13.2 304.22,15.44 305.31,17.93 305.75,18.37 306.05,18.37 v2(306.19,18.51)
  BOTTOM w0.102: UH1.BA3 213.52,20.29 213.95,20.29 213.99,20.33 214.58,20.33 215.75,19.17 215.75,16.7 v2(215.61,16.56)
  BOTTOM w0.127: v2(306.19,18.51) 305.94,18.27 305.75,18.27 305.53,18.48 305.53,21.01 304.19,22.36 303.87,22.36 303.62,22.6 JWLAN1.9
CNV_PRX_DTX_P0: length 124.6
  IN1 w0.135: v2(215,16.55) 215.01,16.55 215.23,16.77 215.23,16.91 215.16,16.98 214.9,16.98 214.81,17.08 214.81,17.27 214.99,17.46 215.44,17.46 215.56,17.57 216.62,17.57 216.86,17.82 217.27,17.82 217.41,17.68 217.82,17.68 217.96,17.82 218.78,17.82 219.03,17.57 219.55,17.57 219.99,18.01 219.99,18.42 223.1,21.54 223.1,25.97 226.93,29.79 231.48,29.79 232.13,30.44 237.11,30.44 237.94,31.27 246.57,31.27 248.07,29.77 251.53,29.77 254.22,27.08 254.22,26.91 254.13,26.83 254.13,26.39 254.54,25.98 254.98,25.98 255.07,26.06 255.23,26.06 256.06,25.24 263.68,25.24 264.57,24.35 271.64,24.35 273.67,22.32 277.3,22.32 278.83,20.79 279.64,20.79 281.95,18.48 281.95,16.61 285.36,13.2 285.36,12.63 286.35,11.64 292.87,11.64 293.77,12.55 297.81,12.55 298.34,13.09 299.1,13.09 299.95,13.93 299.95,14.08 300.09,14.22 300.46,14.22 300.59,14.08 300.59,13.93 300.89,13.64 301.74,13.64 303.53,15.43 303.53,16.19 303.84,16.5 303.84,17.01 303.53,17.32 303.53,17.53 304.21,18.21 304.61,18.21 304.61,18.21 v2(304.71,18.12)
  BOTTOM w0.102: UH1.BB4 213.41,20.06 213.99,20.06 214.05,20.13 214.52,20.13 215.42,19.23 215.42,17.39 215,16.97 v2(215,16.55)
  BOTTOM w0.127: JWLAN1.17 303.58,20.6 303.66,20.68 303.84,20.68 303.95,20.57 303.95,18.58 304.22,18.31 304.51,18.31 v2(304.71,18.12)
CNV_PRX_DTX_P1: length 125.2
  IN1 w0.135: v2(306.19,17.65) 306.19,18.01 306.1,18.09 305.87,18.09 305.54,17.77 304.45,15.28 302.09,12.92 300.06,12.92 299.51,12.37 298.64,12.37 298.11,11.83 294.07,11.83 293.17,10.92 286.05,10.92 284.64,12.33 284.64,12.82 281.24,16.23 281.24,18.18 279.34,20.07 278.53,20.07 277,21.6 273.37,21.6 271.34,23.63 262.24,23.63 261.36,24.52 254.98,24.52 250.45,29.05 245.6,29.05 245.18,29.47 242.36,29.47 241.28,30.55 238.24,30.55 237.41,29.72 232.42,29.72 231.76,29.06 227.21,29.06 223.82,25.67 223.82,21.24 220.7,18.12 220.7,17.71 219.44,16.45 218.95,16.45 217.98,16.86 216.69,16.86 216.62,16.79 216.62,16.46 216.52,16.35 216.41,16.35 v2(216.2,16.56)
  BOTTOM w0.102: v2(216.2,16.56) 216.31,16.67 216.31,16.83 216.21,16.93 216.01,16.93 215.96,16.98 215.96,19.25 214.67,20.54 213.85,20.54 UH1.BA2
  BOTTOM w0.127: v2(306.19,17.65) 306.19,17.77 305.95,18.01 305.64,18.01 305.27,18.38 305.27,20.91 304.08,22.1 JWLAN1.11
CNV_PTX_DRX_N0: length 131.7
  IN1 w0.135: v2(300.4,10.38) 300.24,10.54 300.24,10.83 299.87,11.21 299.12,11.21 298.46,10.54 298.46,10.05 299.67,8.85 299.67,6.58 299.53,6.44 298.97,6.44 298.83,6.58 298.83,8.69 296.85,10.67 294.55,10.67 293.65,9.77 285.57,9.77 284.93,10.4 284.51,10.4 284.2,10.09 284.01,10.09 283.74,10.35 283.74,10.54 284.06,10.86 284.06,11.28 283.48,11.85 283.48,12.2 281.5,14.19 281.07,14.19 280.07,13.19 279.88,13.19 279.62,13.45 279.62,13.64 280.62,14.64 280.62,15.06 280.08,15.61 280.08,17.7 278.86,18.92 278.05,18.92 276.92,20.04 273.29,20.04 270.86,22.47 261.59,22.47 260.7,23.36 254.5,23.36 250.69,27.17 249.06,27.17 248.36,27.87 243.4,27.87 243.08,28.2 241.95,28.2 240.76,29.39 238.72,29.39 237.89,28.57 232.9,28.57 232.24,27.9 227.69,27.9 224.98,25.19 224.98,20.7 221.86,17.59 221.86,17.23 219.96,15.33 219.96,14.62 219.1,13.76 216.34,13.76 215.84,14.26 213.18,14.26 212.92,14.52 212.92,14.71 v2(213.06,14.84)
  BOTTOM w0.102: v2(213.06,14.84) 213,14.84 212.76,15.08 212.76,15.8 211.41,17.16 211.41,18.34 211.48,18.41 211.64,18.41 211.8,18.57 211.8,18.7 211.76,18.74 UH1.BE6
  BOTTOM w0.127: JWLAN1.57 302.21,8.6 301.96,8.36 300.63,8.36 300.24,8.75 300.24,9.86 300.34,9.96 300.52,9.96 300.62,10.06 300.62,10.27 300.51,10.38 v2(300.4,10.38)
CNV_PTX_DRX_N1: length 132.8
  IN1 w0.135: v2(301.43,9.98) 300.96,9.98 300.87,9.89 300.87,9.67 301.09,9.46 301.92,9.46 302.06,9.6 302.06,10.04 303.36,11.34 305.51,11.34 306.19,12.01 306.19,12.61 306.05,12.74 305.51,12.74 305.21,13.04 305.21,13.65 305.51,13.94 306.05,13.94 306.19,14.08 306.19,14.67 305.95,14.9 305.2,14.9 302.68,12.38 302.68,11.89 301.73,10.93 300.78,10.93 300.06,11.65 298.94,11.65 298.4,11.11 294.37,11.11 293.46,10.21 285.75,10.21 283.92,12.03 283.92,12.52 280.52,15.93 280.52,17.88 279.04,19.35 278.23,19.35 276.7,20.89 273.07,20.89 271.05,22.91 261.88,22.91 260.99,23.8 254.69,23.8 250.16,28.32 243.59,28.32 243.25,28.66 242.11,28.66 240.94,29.83 238.53,29.83 237.71,29 232.72,29 232.06,28.34 227.5,28.34 224.54,25.37 224.54,20.88 221.42,17.77 221.42,17.41 219.64,15.63 219.12,15.63 217.76,14.27 216.53,14.27 215.53,15.27 214.37,15.27 214.23,15.13 214.23,15 v2(214.39,14.83)
  BOTTOM w0.102: v2(214.39,14.83) 214.13,15.09 214.13,15.59 213.81,15.92 213.37,15.92 211.94,17.34 211.94,17.45 212.16,17.66 212.16,17.88 212.07,17.97 211.97,17.97 211.9,17.89 UH1.BG6
  BOTTOM w0.127: JWLAN1.51 302.15,10.1 301.77,9.73 301.5,9.73 301.43,9.8 v2(301.43,9.98)
CNV_PTX_DRX_P0: length 131.7
  IN1 w0.135: v2(212.48,14.84) 212.64,14.68 212.64,14.4 213.06,13.98 215.73,13.98 216.23,13.48 219.22,13.48 220.24,14.5 220.24,15.21 222.14,17.11 222.14,17.47 225.26,20.59 225.26,25.07 227.8,27.62 232.35,27.62 233.02,28.29 238.01,28.29 238.83,29.11 240.64,29.11 241.84,27.92 242.97,27.92 243.29,27.59 248.25,27.59 248.95,26.9 250.57,26.9 254.39,23.08 260.59,23.08 261.48,22.19 270.75,22.19 273.18,19.76 276.81,19.76 277.93,18.64 278.74,18.64 279.8,17.58 279.8,15.49 280.34,14.95 280.34,14.76 279.34,13.76 279.34,13.34 279.77,12.91 280.19,12.91 281.19,13.91 281.38,13.91 283.2,12.08 283.2,11.74 283.78,11.16 283.78,10.97 283.46,10.66 283.46,10.24 283.89,9.81 284.31,9.81 284.63,10.12 284.82,10.12 285.45,9.49 293.76,9.49 294.67,10.39 296.73,10.39 298.55,8.57 298.55,6.46 298.85,6.16 299.65,6.16 299.94,6.46 299.94,8.96 298.74,10.17 298.74,10.43 299.24,10.93 299.75,10.93 299.96,10.71 299.96,10.53 v2(299.82,10.38)
  BOTTOM w0.102: UH1.BD7 211.41,18.94 211.28,18.81 211.28,18.51 211.21,18.43 211.21,17.07 212.56,15.72 212.56,14.93 v2(212.48,14.84)
  BOTTOM w0.127: v2(299.82,10.38) 299.98,10.22 299.98,8.64 300.52,8.1 JWLAN1.59
CNV_PTX_DRX_P1: length 132.8
  IN1 w0.135: v2(213.81,14.83) 213.95,14.97 213.95,15.24 214.25,15.55 215.65,15.55 216.64,14.55 217.64,14.55 219,15.91 219.52,15.91 221.14,17.53 221.14,17.89 224.26,21 224.26,25.49 227.39,28.62 231.94,28.62 232.61,29.28 237.59,29.28 238.42,30.11 241.05,30.11 242.22,28.94 243.37,28.94 243.71,28.6 250.28,28.6 254.8,24.08 261.11,24.08 262,23.19 271.16,23.19 273.19,21.17 276.82,21.17 278.35,19.63 279.16,19.63 280.8,18 280.8,16.04 284.2,12.64 284.2,12.15 285.87,10.49 293.35,10.49 294.25,11.39 298.29,11.39 298.82,11.93 300.18,11.93 300.9,11.21 301.61,11.21 302.4,12 302.4,12.5 305.09,15.18 306.07,15.18 306.47,14.78 306.47,13.96 306.17,13.66 305.62,13.66 305.49,13.53 305.49,13.16 305.62,13.02 306.17,13.02 306.47,12.72 306.47,11.9 305.62,11.06 303.48,11.06 302.34,9.92 302.34,9.48 302.04,9.18 301.59,9.18 v2(301.43,9.02)
  BOTTOM w0.102: UH1.BF6 211.61,18.01 211.61,17.39 213.29,15.71 213.72,15.71 213.93,15.5 213.93,14.95 v2(213.81,14.83)
  BOTTOM w0.127: v2(301.43,9.02) 301.43,9.23 301.67,9.47 301.88,9.47 302.01,9.6 JWLAN1.53
CNV_RF_RESET#: length 120.7
  TOP w0.135: v2(290.97,8.97) 294.02,12.02 297.15,12.02 300.17,15.04 300.47,15.04 300.9,15.47 300.9,15.87 301.52,16.49 302.73,16.49 303.77,17.53 303.77,19.41 304.8,20.43 v1(305.24,20.43) 305.7,20.43 306.79,21.53 308.83,21.53 v2(309.16,21.85) 309.17,21.87 RWL1.1
  IN1 w0.127: v2(290.97,8.97) 290.54,8.54 283.14,8.54 278.82,12.86 277.54,12.86 274.8,15.59 267.62,15.59 267.22,15.2 264.53,15.2 263.81,14.47 257.45,14.47 256.86,15.06 247.87,15.06 247.19,14.39 234.25,14.39 233.92,14.06 226.44,14.06 226.15,14.35 224.69,14.35 223.43,13.09 221.76,13.09 221.33,12.66 216,12.66 215.37,13.28 213.25,13.28 212.88,12.91 212.26,12.91 211.78,13.38 211.78,14.66 209.99,16.46 209.41,16.46 207.88,17.99 v2(206.94,17.99)
  BOTTOM w0.127: UH1.BE16 206.84,18.76 206.84,18.09 v2(206.94,17.99) ; v2(309.16,21.85) 309.26,21.85 309.76,22.35 JWLAN1.10
CNV_RGI_PRX_DTX: length 120.7
  TOP w0.135: v2(307.7,20.84) 307.29,20.84 305.64,19.19 v1(305.64,16.91) 305.64,16.85 305.96,16.53 306.76,16.53 RWL12.2 307.01,16.05 RWL21.1
  IN1 w0.127: v2(219.73,24.86) 219.96,25.09 219.96,28.25 224.65,32.94 230.18,32.94 230.82,33.58 234.61,33.58 235.46,34.43 250.51,34.43 250.93,34.01 253.06,34.01 253.46,33.6 254.21,33.6 258.52,29.29 262.67,29.29 263.21,29.83 264.52,29.83 266.12,28.22 274.48,28.22 275.24,27.46 276.56,27.46 277.24,26.78 278.55,26.78 281.29,24.05 281.67,24.05 289.2,16.52 294.81,16.52 295.95,17.65 298.05,17.65 300.77,20.37 302.16,20.37 303.63,21.84 304.96,21.84 305.58,21.22 307.31,21.22 v2(307.7,20.84)
  BOTTOM w0.102: UH1.AV3 213.17,22.39 213.87,22.39 214.47,21.78 215.3,21.78 215.86,22.34 217.15,22.34 217.8,22.98 219.07,22.98 219.41,23.32 219.41,23.69 219.26,23.83 219.26,24.4 219.73,24.86 v2(219.73,24.86)
CNV_RGI_PRX_DTX_R: length 3.1
  TOP w0.127: v2(308.94,16.03) v1(308.94,16.53)
  TOP w0.135: v2(308.94,16.03) RWL21.2
  BOTTOM w0.127: v2(308.94,16.03) 309.27,16.35 JWLAN1.26
CNV_RGI_PTX_DRX: length 123.2
  TOP w0.135: RWL20.1 311.84,16.53 312.06,16.75 312.06,18.35 310.79,19.61 v1(309.1,19.61) v2(307.36,19.61)
  IN1 w0.127: v2(217.41,21.33) 217.57,21.49 219.52,21.49 220.22,22.19 220.22,23.74 220.74,24.27 220.74,26.66 226.24,32.16 230.51,32.16 231.15,32.8 234.93,32.8 235.78,33.65 247.52,33.65 249.05,32.12 252.53,32.12 252.88,31.77 254.93,31.77 258.25,28.45 264.78,28.45 265.79,27.44 274.15,27.44 274.99,26.6 276.31,26.6 276.91,26 278.23,26 280.96,23.27 281.35,23.27 288.88,15.74 295.14,15.74 296.27,16.87 298.38,16.87 301.09,19.58 302.99,19.58 303.84,20.44 306.76,20.44 307.36,19.84 v2(307.36,19.61)
  BOTTOM w0.102: 215.01,20.84 214.82,21.02 214.19,21.02 214.01,20.84 213.01,20.84 UH1.BA4
  BOTTOM w0.127: RH167.1 217.76,19.84 217,19.84 216.71,20.12 215.72,20.12 215.01,20.84
  BOTTOM w0.135: RH168.1 RH167.1 217.76,20.98 v2(217.41,21.33)
CNV_RGI_PTX_DRX_R: length 4
  TOP w0.135: v2(311.31,17.22) 311.14,17.22 310.88,17.49 v1(310.55,17.49) 310.42,17.49 310.06,17.13 RWL20.2 RWL33.2
  BOTTOM w0.127: JWLAN1.24 310.94,16.85 v2(311.31,17.22)
CNV_WT_RCOMP: length 6.6
  BOTTOM w0.127: UH1.BA1 214.71,20.78 215.42,20.08 215.42,20.07 216.47,19.03 216.64,19.03 216.89,18.77 ; RH25.1 218.25,17.82 v1(219.7,17.82)
  BOTTOM w0.305: 216.89,18.77 217.35,18.31 RH25.1
COMP_1PH: length 3.9
  TOP w0.127: 172.47,127.16 v1(172.89,126.74)
  TOP w0.203: PCZ10.2 PCZ11.2 171.91,126.58 172.47,127.14 v2(172.47,127.3)
  BOTTOM w0.203: PUZ1.50 171.84,127.84 172.3,127.38 172.39,127.38 v2(172.47,127.3)
COMP_2PH: length 3.8
  TOP w0.127: v2(168.23,133.75) 168.23,133.44 v1(167.87,133.08)
  TOP w0.203: v2(168.23,133.75) 168.03,133.96 PCZ21.2 168.1,134.47 PCZ22.2
  BOTTOM w0.203: PUZ1.33 v2(168.23,133.75)
COMP_4PH: length 6.8
  TOP w0.203: v2(168.92,124.92) 169.36,124.48 v1(169.84,124.48) 170.49,124.48 170.8,124.8 PCZ16.1 171.5,124.8 172.36,123.94 PRZ38.1
  BOTTOM w0.203: PUZ1.6 168.63,125.23 168.92,124.93 v2(168.92,124.92)
CPU_C10_GATE#: length 3.5
  BOTTOM w0.102: TH135.1 216,21.4 214.04,21.4 213.91,21.53 213.4,21.53 UH1.AY3
CPU_DISPA_BCLK: length 4.6
  BOTTOM w0.127: RH29.2 217.29,23.77 216.78,24.29 214.18,24.29 213.8,24.66 213.65,24.66 UH1.AM3
CPU_DISPA_BCLK_R: length 122.7
  IN1 w0.127: v2(180.91,69.73) 182.41,71.22 182.41,72.93 182.41,78.1 181.51,79 181.51,81.14 180.31,82.34 180.31,83.94 169.3,94.95 169.3,95.16 168.74,95.72 168.09,95.72 167.81,96 167.81,96.45 167.02,97.25 165.27,97.25 164.55,97.97 163.94,97.97 163.78,97.81 163.4,97.81 163.02,98.19 163.02,100.12 v2(164.32,101.42)
  BOTTOM w0.127: v2(180.91,69.73) v1(181.43,69.21) 181.81,69.21 185.05,65.96 185.05,63.62 189.85,58.82 189.89,58.82 190.66,58.05 190.66,56.4 191.37,55.68 192.74,55.68 194,54.43 194,50.56 195.85,48.7 200.79,48.7 201.48,48.01 210.13,48.01 210.6,47.54 217.11,47.54 220.97,43.68 220.97,42.23 223.13,40.07 223.13,34.86 223.82,34.16 223.82,31.95 221.31,29.44 221.31,27.03 218.7,24.42 218.7,23.87 218.6,23.77 RH29.1
  BOTTOM w0.135: UC1.G27 v2(164.32,101.42)
CPU_DISPA_SDI: length 12.5
  TOP w0.127: v2(164.32,102.97) 164.53,103.18 v1(165.83,103.18) 166.35,103.18 166.71,103.54 166.71,104.2 167.14,104.63 167.93,104.63 169.96,102.59 RC2.2
  BOTTOM w0.135: UC1.G29 v2(164.32,102.97)
CPU_DISPA_SDI_R: length 121.2
  TOP w0.127: v2(176.7,101.92) 176.7,102.12 176.22,102.59 RC2.1 ; v2(178.83,68.19) 178.83,68.98 184.03,74.18 186.11,74.18 189.21,77.28 v1(189.21,79.97) v2(188.83,80.35)
  IN2 w0.127: v2(205.36,22.82) 205.36,23.06 206.06,23.76 209.33,23.76 210,24.44 210.96,24.44 211.16,24.64 213.27,24.64 214.01,23.91 v2(214.89,23.91)
  IN3 w0.127: v2(176.7,101.92) 177.74,100.88 177.74,96.12 188.42,85.44 188.42,83.77 189.08,83.11 189.08,80.6 v2(188.83,80.35) ; v2(205.36,22.82) 205.42,22.88 205.42,23.87 203.37,25.92 200.33,25.92 200.16,26.1 200.16,26.56 199.88,26.84 196.65,26.84 196.3,27.19 195.53,27.19 192.33,30.38 192.33,36.71 185.7,43.34 185.7,45.73 182.78,48.65 182.78,50.43 182.15,51.06 182.15,52.48 177.07,57.57 177.07,65.91 178.8,67.64 178.8,68.15 v2(178.83,68.19)
  BOTTOM w0.127: v2(214.89,23.91) 214.25,23.91 213.74,24.42 213.24,24.42 UH1.AN3
CPU_DISPA_SDO: length 4.1
  BOTTOM w0.127: RH28.2 216.84,25.07 v1(216.36,25.07) 215.78,25.07 215.44,24.73 214.12,24.73 UH1.AM2
CPU_DISPA_SDO_R: length 119.5
  IN1 w0.127: v2(164.32,99.84) 164.93,99.24 165.7,99.24 166.24,98.69 167.1,98.69 167.51,98.28 169.01,98.28 169.67,97.61 169.67,96.01 170.17,95.52 170.17,95.3 181.18,84.3 181.18,82.71 182.38,81.5 182.38,79.36 183.29,78.46 183.29,70.76 v2(181,68.47)
  BOTTOM w0.127: v2(181,68.47) 181.79,68.47 v1(183.34,66.93) 184.79,65.48 184.79,63.51 189.74,58.56 189.78,58.56 190.39,57.94 190.39,56.29 191.27,55.42 192.63,55.42 193.73,54.32 193.73,50.21 195.5,48.44 200.68,48.44 201.37,47.75 210.02,47.75 210.49,47.27 217,47.27 220.71,43.57 220.71,42.12 222.86,39.96 222.86,34.75 223.56,34.05 223.56,32.06 221.05,29.55 221.05,27.14 218.44,24.53 RH28.1
  BOTTOM w0.135: UC1.G25 v2(164.32,99.84)
CPU_GPIOB21: length 6
  BOTTOM w0.102: 200.23,16.71 200.23,17.1 200.26,17.12 200.26,18.03 200.23,18.05 200.18,18.11 200.18,18.53 199.9,18.81 199.9,19.18 UH1.BD30
  BOTTOM w0.127: 200.23,16.71 200.23,16.09 200.43,15.89 200.43,15.03 200.21,14.81 RH154.2 RH153.2
CPU_SVID_ALERT#: length 9.8
  IN1 w0.127: v2(124.16,106.83) 124.47,106.52 126.84,106.52 127.14,106.82 129.82,106.82 131.02,105.62 131.15,105.62 v2(131.85,104.92)
  BOTTOM w0.127: UC1.BH31 v2(131.85,104.92) ; RC39.2 v2(124.16,106.83)
CPU_SVID_ALERT#_R: length 72.5
  TOP w0.127: PRZ7.2 v2(174.52,131.79)
  IN3 w0.127: v2(174.52,131.79) 174.99,131.32 174.99,130.6 174.19,129.81 174.19,124.3 171.72,121.84 171.72,121.15 163.44,112.86 149.3,112.86 148.94,113.22 147.84,113.22 147.48,112.85 141,112.85 139.71,111.56 126.37,111.56 122.99,108.18 122.99,107.28 122.53,106.83 v2(122,106.83)
  BOTTOM w0.127: PRZ7.2 v2(174.52,131.79) ; v1(121.51,108.13) 121.51,106.97 RC40.2 v2(122,106.83) RC39.1
CPU_SVID_CLK: length 10.5
  IN1 w0.127: v2(124.16,107.59) 126.95,107.59 127.29,107.25 129.99,107.25 131.18,106.07 131.35,106.07 v2(131.85,105.57)
  BOTTOM w0.127: CC155.1 123.53,107.62 RC37.2 v2(124.16,107.59) ; UC1.BH32 v2(131.85,105.57)
CPU_SVID_CLK_R: length 68.3
  TOP w0.127: PRZ8.2 v2(174.52,131.02)
  IN3 w0.127: v2(174.52,131.02) 174.52,130.87 173.74,130.1 173.74,124.49 171.28,122.02 171.28,121.33 163.25,113.31 149.48,113.31 149.13,113.66 147.66,113.66 147.29,113.3 140.82,113.3 139.56,112.05 126.23,112.05 122,107.82 v2(122,107.59)
  BOTTOM w0.127: v2(174.52,131.02) PRZ8.2 ; RC37.1 v2(122,107.59)
CPU_SVID_DAT: length 11
  IN1 w0.127: v2(124.16,105.94) 124.26,106.04 127.06,106.04 127.42,106.39 129.64,106.39 130.49,105.54 130.49,104.83 130.83,104.49 131.54,104.49 131.94,104.09 v2(131.94,103.49)
  BOTTOM w0.127: UC1.BH29 v2(131.94,103.49) ; RC38.2 v2(124.16,105.94)
CPU_SVID_DAT_R: length 75.3
  TOP w0.127: PRZ6.1 v2(174.52,132.55)
  IN3 w0.127: v2(174.52,132.55) 177.18,129.89 177.18,128.78 176.79,128.39 175.42,128.39 174.63,127.61 174.63,124.12 172.17,121.65 172.17,120.96 163.62,112.41 141.2,112.41 139.89,111.11 126.55,111.11 123.44,107.99 123.44,106.61 122.76,105.94 v2(122,105.94)
  BOTTOM w0.127: PRZ6.1 v2(174.52,132.55) ; RC41.1 v2(122,105.94) RC38.1
CPU_TRIGOUT: length 3.5
  TOP w0.127: RC8.2 165.44,97.79 164.88,97.79 164.22,98.45 v1(164.1,98.45) 163.8,98.45 v2(163.62,98.27)
  BOTTOM w0.127: v2(163.62,98.27) 163.04,98.27 UC1.J23
CPU_TRIGOUT_R: length 168.4
  TOP w0.127: RC8.1 165.79,97.23 v2(169.17,97.23) ; v2(223.84,17.29) 223.84,17.97 v1(222.67,19.14) 222.1,19.71 218.35,19.71 216.13,21.93 216.13,23.27 216.38,23.52 216.38,24.57 215.97,24.98 215.55,24.98 215.07,25.46 215.07,26.59 v2(215.06,26.6)
  IN2 w0.127: v2(235.92,49.64) 235.34,49.64 234.9,50.09 231.97,50.09 230.63,48.74 224.2,48.74 221.29,51.65 195.46,51.65 192.21,54.9 192.21,74.24 190.76,75.69 190.76,76.86 191.27,77.37 191.27,78.71 191.52,78.96 191.52,80.88 190.78,81.61 190.78,82.89 v2(191.16,83.27)
  IN3 w0.127: v2(223.84,17.29) 224.1,17.54 225.19,17.54 225.92,18.28 225.92,19.71 224.42,21.22 224.42,26.97 228.03,30.59 228.03,32.06 234.63,38.65 234.63,39.8 235.82,41 235.82,47.37 236.43,47.98 236.43,48.85 235.92,49.36 v2(235.92,49.64) ; v2(191.16,83.27) 190.52,83.91 189.31,83.91 188.86,84.36 188.86,85.62 184.21,90.27 v2(184.21,93.27)
  BOTTOM w0.102: v2(215.06,26.6) 215.06,26.5 214.64,26.08 214.21,26.08 213.93,26.37 UH1.AK2
  BOTTOM w0.127: v2(184.21,93.27) 181.4,93.27 179.83,94.83 177.09,94.83 176.72,95.2 170.09,95.2 169.17,96.12 v2(169.17,97.23)
CPU_XDP_TCK0: length 231.7
  TOP w0.127: v2(214.35,28.04) 214.11,28.04 v3(213.77,28.38)
  IN2 w0.127: v2(110.43,27.9) 110.43,27.37 113.28,24.53 115.9,24.53 116.44,23.99 120.64,23.99 121.4,24.75 123.86,24.75 123.98,24.62 128.72,24.62 129.14,24.21 131.02,24.21 132.05,25.25 135.61,25.25 135.97,25.61 142.82,25.61 143.18,25.25 150.29,25.25 151.16,26.11 160.2,26.11 161.09,27 166.04,27 166.78,26.26 170.74,26.26 174.65,30.17 174.65,30.78 179.31,35.44 181.64,35.44 183.96,37.76 187.46,37.76 189.42,39.73 189.42,40.06 190.98,41.61 191.63,41.61 191.95,41.29 193.02,41.29 194.21,40.11 199.32,40.11 200.16,40.94 205.55,40.94 206.53,41.93 207.47,41.93 208.95,40.44 211.62,40.44 211.87,40.7 213.27,40.7 214.34,39.62 214.34,38.42 213.73,37.8 213.73,33.01 214.61,32.13 214.61,31.61 214.35,31.35 214.35,28.04 v2(214.35,28.04)
  IN3 w0.127: v2(124.16,101.83) 123.93,101.59 123.93,95.57 122.16,93.8 122.16,89.27 119.76,86.87 118.21,86.87 117.66,86.31 114.54,86.31 114.13,85.9 113.82,85.6 112.56,84.33 arc(111.21,82.31) 110.73,79.92 110.73,78.45 104.86,72.57 104.86,71.9 104.37,71.42 104.37,70.1 102.96,68.68 102.96,67.57 101.24,65.86 99.76,63.16 99.76,60.7 100.1,60.36 100.1,56.2 99.37,55.48 99.37,47.62 100.59,46.4 100.59,45.15 102.58,43.16 102.58,37.64 103.15,37.08 103.15,32.06 103.75,31.46 103.75,30.67 105.22,29.2 107.08,29.2 107.82,28.45 107.82,28.14 108.75,27.21 109.74,27.21 v2(110.43,27.9)
  BOTTOM w0.102: UH1.AH4 213.1,27.57 213.83,27.57 214.1,27.84 214.15,27.84 v2(214.35,28.04) ; v2(124.16,101.83) 124.42,102.09 124.52,102.09 124.88,102.45 125.18,102.45 125.56,102.06 127.64,102.06 UC1.BR28
  BOTTOM w0.127: v2(124.16,101.83) RC390.1
CPU_XDP_TDI: length 243
  TOP w0.127: v3(215.5,28.63) 214.93,28.06 v2(214.93,28.04)
  IN2 w0.127: v2(214.93,28.04) 215.41,28.52 215.41,29.67 215.99,30.25 215.99,31.64 215.77,31.86 215.77,33.58 214.19,35.16 214.19,37.71 214.69,38.21 214.69,39.91 213.97,40.63 213.97,41.28 211.4,43.85 208.06,43.85 205.38,41.17 199.91,41.17 199.16,40.42 194.42,40.42 192.79,42.05 190.8,42.05 188.99,40.24 188.99,39.9 187.28,38.19 183.78,38.19 181.46,35.87 179.13,35.87 172.91,29.65 172.07,29.65 169.11,26.7 166.96,26.7 166.22,27.43 160.91,27.43 160.02,26.54 155.88,26.54 155.33,27.09 150.41,27.09 148.99,25.68 144.4,25.68 143.38,26.7 136.68,26.7 136.01,26.04 135.79,26.04 135.66,25.91 128.78,25.91 128.05,25.18 121.22,25.18 120.47,24.42 119.09,24.42 118.64,24.87 116.65,24.87 114.79,26.73 114.17,26.73 113.9,27 v2(113.04,27.86)
  IN3 w0.127: v2(121.87,101.83) 121.87,101.56 122.63,100.8 122.63,99.23 121.69,98.29 121.69,95.16 120.55,94.03 120.55,92.4 116.08,87.92 114.32,87.92 113.63,87.23 111.45,85.06 arc(109.96,82.83) 109.44,80.2 arc(109.44,80.06) 109.44,79.92 109.44,78.98 103.56,73.11 103.56,72.44 103.08,71.96 103.08,70.65 101.66,69.23 101.66,68.11 100.19,66.64 99.6,65.57 99.19,64.81 98.46,63.49 98.46,60.17 98.8,59.82 98.8,56.74 98.08,56.01 98.08,47.08 99.29,45.86 99.29,44.6 101.28,42.61 101.28,36.9 99.95,35.57 99.95,31.54 101.81,29.68 102.9,29.68 105.37,27.21 106.91,27.21 108.21,25.91 110.28,25.91 111.2,26.83 112.03,26.83 113.04,27.84 v2(113.04,27.86)
  BOTTOM w0.102: v2(121.87,101.83) 122.76,102.71 124.32,102.71 124.63,103.02 125.26,103.02 125.69,103.45 129.27,103.45 129.58,103.76 129.58,104.15 129.76,104.33 130.15,104.33 130.3,104.48 130.3,104.88 UC1.BL32 ; UH1.AH2 213.82,27.29 214.18,27.65 214.54,27.65 v2(214.93,28.04)
  BOTTOM w0.127: v2(121.87,101.83) RC381.1
CPU_XDP_TDO: length 236.8
  TOP w0.127: v3(217.07,27.59) 216.6,27.12 v2(216.24,27.12)
  IN2 w0.127: v2(111.04,27.9) 111.89,28.74 113.38,28.74 114.53,27.59 115.15,27.59 117,25.74 119,25.74 119.45,25.29 120.11,25.29 120.86,26.04 125.4,26.04 126.13,26.77 133.51,26.77 134.3,27.56 149.47,27.56 150.41,28.51 162.99,28.51 163.21,28.29 166.58,28.29 167.31,27.56 168.75,27.56 171.71,30.52 172.55,30.52 178.77,36.74 180.3,36.74 182.62,39.06 186.92,39.06 188.13,40.26 188.13,40.6 190.44,42.91 193.27,42.91 194.46,44.1 195.34,44.1 195.94,44.7 196.47,44.7 196.9,45.13 199.45,45.13 199.94,44.64 211.65,44.64 214.7,41.59 214.7,41.11 215.14,40.68 215.95,40.68 218.43,38.2 218.43,36.96 217.41,35.94 217.41,34.01 217.08,33.67 217.08,27.88 216.32,27.12 v2(216.24,27.12)
  IN3 w0.127: v2(111.04,27.9) 109.92,26.78 108.57,26.78 107.39,27.96 107.39,28.27 106.9,28.76 105.04,28.76 103.31,30.49 103.31,31.28 102.71,31.88 102.71,36.9 102.14,37.47 102.14,42.97 100.16,44.96 100.16,46.22 98.94,47.44 98.94,55.65 99.67,56.38 99.67,60.18 99.32,60.52 99.32,63.27 99.94,64.4 100.89,66.12 102.52,67.75 102.52,68.87 103.94,70.29 103.94,71.6 104.42,72.08 104.42,72.75 110.3,78.63 110.3,79.92 arc(110.81,82.47) 112.25,84.64 113.52,85.9 113.83,86.21 114.36,86.74 116.18,86.74 121.47,92.03 121.47,93.72 123.5,95.75 123.5,101.73 v2(123.4,101.83)
  BOTTOM w0.102: v2(216.24,27.12) 216.2,27.16 214.33,27.16 214.15,26.98 213.53,26.98 UH1.AH3 ; UC1.BT28 127.21,102.28 125.62,102.28 125.26,102.64 124.8,102.64 124.44,102.28 123.85,102.28 v2(123.4,101.83)
  BOTTOM w0.127: RC384.1 v2(123.4,101.83)
CPU_XDP_TMS: length 242.1
  IN2 w0.127: v2(214.49,26.45) 214.49,27.01 214.94,27.46 216.03,27.46 216.43,27.85 216.43,31.95 216.29,32.08 216.29,33.5 216.98,34.19 216.98,36.12 218,37.14 218,38.02 215.77,40.25 214.98,40.25 214.29,40.95 214.29,41.4 211.41,44.28 198.81,44.28 198.25,43.73 198.25,43.48 197.87,43.09 197.28,43.09 196.82,43.56 196.82,44.01 196.43,44.4 195.98,44.4 195.34,43.76 194.73,43.76 193.45,42.48 190.62,42.48 188.56,40.42 188.56,40.08 187.1,38.63 183.6,38.63 181.28,36.3 178.95,36.3 172.73,30.09 171.89,30.09 168.93,27.13 167.13,27.13 166.4,27.86 160.73,27.86 159.84,26.98 156.06,26.98 155.51,27.52 150.23,27.52 149.83,27.13 136.5,27.13 135.84,26.47 135.61,26.47 135.48,26.34 128.6,26.34 127.87,25.61 121.04,25.61 120.29,24.85 119.27,24.85 118.82,25.3 116.83,25.3 114.97,27.16 114.35,27.16 113.91,27.6 113.2,28.31 112.9,28.31 v2(112.45,27.86)
  IN3 w0.127: v2(122.64,101.83) 122.64,101.56 123.06,101.13 123.06,99.05 122.12,98.11 122.12,94.98 121.04,93.9 121.04,92.21 116,87.17 114.18,87.17 113.46,86.45 111.95,84.94 arc(110.41,82.64) 109.87,79.92 109.87,78.8 103.99,72.93 103.99,72.26 103.51,71.78 103.51,70.47 102.09,69.05 102.09,67.93 100.54,66.38 99.98,65.36 99.56,64.61 98.89,63.38 98.89,60.35 99.24,60 99.24,56.56 98.51,55.83 98.51,47.26 99.72,46.04 99.72,44.78 101.71,42.79 101.71,36.72 100.38,35.39 100.38,31.72 101.99,30.11 103.08,30.11 105.55,27.65 107.09,27.65 108.39,26.34 110.1,26.34 111.02,27.26 111.85,27.26 v2(112.45,27.86)
  BOTTOM w0.102: v2(122.64,101.83) 123.3,102.49 124.38,102.49 124.72,102.83 125.34,102.83 125.67,102.49 126.96,102.49 127.18,102.72 128.22,102.72 UC1.BP28 ; v2(214.49,26.45) 214.11,26.45 213.97,26.6 213.47,26.6 213.34,26.47 212.95,26.47 UH1.AJ4
  BOTTOM w0.127: RC380.1 v2(122.64,101.83)
CPU_XDP_TRST#: length 236
  TOP w0.127: v2(211.96,25.54) 211.66,25.83 211.66,26.34 v3(212.04,26.72)
  IN2 w0.127: v2(211.96,25.54) 212.13,25.37 212.91,25.37 213.26,25.72 213.26,28.01 214.08,28.83 214.08,30.97 213.35,31.7 213.35,37.96 214.01,38.62 214.01,39.48 213.17,40.31 212.01,40.31 211.72,40.02 208.63,40.02 207.1,41.55 206.53,41.55 205.61,40.63 200.17,40.63 199.39,39.85 193.91,39.85 192.9,40.86 191.66,40.86 188.13,37.33 184.27,37.33 180.45,33.51 179.16,33.51 178.32,32.67 177.15,32.67 175.08,30.6 175.08,29.99 170.92,25.83 163.45,25.83 163.3,25.68 151.33,25.68 150.47,24.81 143,24.81 142.64,25.17 136.15,25.17 135.79,24.81 132.23,24.81 131.19,23.78 128.96,23.78 128.55,24.19 125.49,24.19 124.86,23.56 113.63,23.56 109.81,27.38 v2(109.81,27.9)
  IN3 w0.127: v2(124.16,103.4) 124.16,103.02 124.67,102.51 124.67,101.47 124.36,101.16 124.36,95.39 122.6,93.62 122.6,88.86 120.17,86.43 118.39,86.43 117.84,85.88 114.72,85.88 114.44,85.6 114.13,85.29 112.87,84.03 arc(111.61,82.14) 111.16,79.92 111.16,78.27 105.29,72.39 105.29,71.72 104.81,71.24 104.81,69.92 103.39,68.5 103.39,67.4 101.84,65.85 101.59,65.59 100.19,63.05 100.19,60.88 100.53,60.54 100.53,56.02 99.81,55.3 99.81,47.79 101.02,46.58 101.02,45.33 103.02,43.33 103.02,37.81 103.58,37.25 103.58,32.24 104.18,31.64 104.18,30.85 105.4,29.63 107.26,29.63 108.26,28.63 108.26,28.31 108.93,27.64 109.55,27.64 v2(109.81,27.9)
  BOTTOM w0.102: v2(124.16,103.4) 124.3,103.4 125.18,104.28 128.24,104.28 UC1.BP30
  BOTTOM w0.127: RC392.1 v2(124.16,103.4) ; v2(211.96,25.54) 211.96,25.27 212.26,24.97 212.7,24.97 UH1.AM4
CR_WAKE#: length 4.4
  BOTTOM w0.127: RR15.1 RR12.2 RR3.2 ; RR15.1 46.93,14.63 47.23,14.32 QR2.3 ; RR15.1 46.33,13.74 v1(46.09,13.5)
CR_WAKE#_R: length 2
  BOTTOM w0.127: RR3.1 45.32,16.15 44.87,15.71 44.49,15.71 44.24,15.46 UR1.32
CS_DDR: length 3
  TOP w0.127: v2(89.13,27.52) v1(88.46,27.52)
  TOP w0.508: v2(89.13,27.52) 89.53,27.11 PRM2.2
  BOTTOM w0.203: PUM1.13 89.49,26.95 89.13,27.31 v2(89.13,27.52)
CSCL: length 3.2
  BOTTOM w0.127: UV2.29 29.48,61.88 29.66,62.06 30.12,62.06 30.32,61.86 RV14.2 30.71,61.89 31.31,62.49 31.31,62.53 31.32,62.55 TPV1.1
CSCOMP_2PH: length 88.9
  TOP w0.127: PCZ28.1 v1(167.16,136.45)
  TOP w0.254: PCZ28.1 PCZ27.1 167.16,133.8 v2(167.21,133.75)
  IN1 w0.254: v2(118.37,103.83) 118.7,104.16 119.08,104.16 119.59,104.67 119.59,110.23 121.52,112.16 121.81,112.16 126.73,117.08 126.73,121.37 123.2,124.9 123.2,132.94 125.13,134.87 131.06,134.87 131.71,134.21 133.93,134.21 134.59,134.87 137.96,134.87 138.41,134.41 141.51,134.41 142.08,134.99 145.82,134.99 146.49,134.31 148.7,134.31 149.31,134.92 155.72,134.92 156.85,136.05 162.6,136.05 163.76,134.89 166.44,134.89 167.21,134.11 v2(167.21,133.75)
  BOTTOM w0.203: PRZ46.1 168.01,135.18 PRZ44.2 167.34,133.89 v2(167.21,133.75) 167.21,133.47 167.43,133.26 PUZ1.31
  BOTTOM w0.254: v2(118.37,103.83) PHZ1.1
CSCOMP_4PH: length 26.7
  TOP w0.203: PCZ25.2 PCZ24.1 168.93,123.54 v2(168.93,123.85)
  IN1 w0.203: v2(156.49,116.71) 156.55,116.76 166.26,116.76 169.56,120.06 169.56,123.21 v2(168.93,123.85)
  BOTTOM w0.127: PRZ45.1 v1(169.42,121.36)
  BOTTOM w0.203: PUZ1.8 167.83,125.04 168.12,124.74 168.12,124.41 168.69,123.85 v2(168.93,123.85) 169.42,123.35 PRZ43.1 PRZ45.1
  BOTTOM w0.254: PHZ3.1 156.42,116.53 156.49,116.6 v2(156.49,116.71)
CSDA: length 2.4
  TOP w0.127: v2(29.76,62.52) 30.46,62.52 TPV2.1
  BOTTOM w0.127: RV16.2 30.27,62.69 30.1,62.52 v2(29.76,62.52) 29.68,62.52 29.44,62.28 UV2.28
CSIN: length 6.1
  TOP w0.127: v1(234.29,16.83) 234.61,16.51 PRB39.2
  TOP w0.203: PUB01.31 237.29,12.95 236.75,13.49 236.51,13.49 236.09,13.91 236.09,14.2 235.52,14.77 PCB04.2 235.48,15.19 235.48,15.19 PCB05.1 234.85,15.6 PRB39.2
CSIN_R: length 42
  TOP w0.254: v2(259.77,34.32) 259.52,34.32 259.3,34.54 PRB03.3 ; PRB39.1 233.69,15.87 233.28,16.28 233.28,16.82 233.72,17.27 236.95,17.27 237.44,16.78 241.78,16.78 241.94,16.62 248.11,16.62 250.33,18.84 v1(250.33,19.54) 250.33,21.32 251.26,22.25 v2(252.17,22.25)
  IN3 w0.254: v2(252.17,22.25) 252.29,22.37 254.38,22.37 257.15,25.14 257.15,32.21 259.27,34.32 v2(259.77,34.32)
CSIP: length 6.3
  TOP w0.127: PCB03.2 234.58,15.06 234.28,15.36 233.33,15.36 233.03,15.67 v1(232.77,15.67)
  TOP w0.203: PUB01.32 236.89,12.87 236.63,13.13 236.39,13.13 235.66,13.86 PCB04.1 235.09,13.86 235.02,13.93 PRB38.2 234.58,13.94 PCB03.2
CSIP_R: length 45.7
  TOP w0.254: v2(252.16,22.83) v1(251.48,22.83) 251.22,22.83 249.89,21.5 249.89,18.94 247.95,17.01 242.11,17.01 241.94,17.17 237.6,17.17 237.11,17.66 233.56,17.66 232.36,16.46 232.36,14.6 233.03,13.93 PRB38.1 ; v2(259.75,34.91) 259.92,34.91 260.28,34.54 PRB03.2
  IN3 w0.254: v2(252.16,22.83) 252.23,22.76 254.21,22.76 256.76,25.31 256.76,32.37 259.3,34.91 v2(259.75,34.91)
CSN_1PH: length 27.2
  IN1 w0.254: v2(160.99,119.03) 161.12,119.16 161.12,120.39 162.13,121.41 164.09,121.41 165.56,122.88 165.56,124.24 167.3,125.98 174.18,125.98 174.53,126.33 175.21,126.33 176.94,128.06 v2(177.25,128.06)
  BOTTOM w0.254: v2(177.25,128.06) 176.97,127.79 PRZ4.1 ; PLA1.3 158.96,118.77 159.22,119.03 v2(160.99,119.03) 161.51,119.56 161.88,119.56 162.39,119.05 PHZ2.1
CSN_1PH_R: length 6.6
  TOP w0.203: PCZ8.1 171.98,129.12 173.16,127.94 v2(173.23,127.94)
  BOTTOM w0.203: PRZ4.2 174.91,127.79 PCZ2.1 PCZ5.1 173.69,127.96 173.26,127.96 v2(173.23,127.94) 173.03,127.94 172.67,128.29 v1(172.55,128.29) 172.35,128.29 172,128.64 PUZ1.48
CSP1_2PH: length 4.5
  BOTTOM w0.127: PRZ66.1 166.02,135.07 v1(166.25,135.3)
  BOTTOM w0.203: PUZ1.28 166.23,132.9 165.97,133.16 165.52,133.16 165.1,133.58 PCZ35.2 165.1,135 PRZ66.1
CSP1_4PH: length 5.3
  BOTTOM w0.203: PRZ59.2 167.71,121.52 PRZ60.2 PCZ34.2 167.71,123.23 166.63,124.31 v1(166.63,125.19) PUZ1.11
CSP2_4PH: length 5
  BOTTOM w0.203: PUZ1.12 166.23,124.4 v1(165.93,124.1) PCZ36.2 PRZ69.2 165.93,121.52 PRZ67.2
CSP3_4PH: length 5.8
  BOTTOM w0.203: PRZ70.2 164.17,122.25 PRZ71.2 PCZ37.2 164.15,123.62 v1(164.6,124.06) 164.85,124.32 165.28,124.32 165.83,124.87 PUZ1.13
CSP4_4PH: length 18.5
  TOP w0.127: v1(162.02,124.89) 162.37,124.53 v2(162.37,123.71)
  IN3 w0.254: v2(162.37,123.71) 162.37,125.23 163.53,126.39 163.53,134.44 v2(163.48,134.49)
  BOTTOM w0.203: PRZ73.2 162.37,121.52 PRZ76.2 PCZ38.2 ; PUZ1.26 164.84,131.84 164.17,132.51 164.17,133.47 163.76,133.88 PRZ72.2
  BOTTOM w0.254: v2(163.48,134.49) PRZ72.2 ; PCZ38.2 v2(162.37,123.71)
CSP_1PH: length 23
  TOP w0.127: v1(160.23,122.17) PRZ3.1
  TOP w0.254: PRZ3.1 160.67,121.12 161.35,121.79 v2(161.35,122.12)
  IN1 w0.254: v2(173.23,128.52) 173.12,128.41 172.85,128.41 171.1,126.67 165.64,126.67 163.83,124.86 163.83,123.09 163.38,122.63 161.85,122.63 v2(161.35,122.12)
  BOTTOM w0.203: PRZ2.2 174.96,128.55 PCZ2.2 PCZ5.2 173.76,128.52 v2(173.23,128.52) 173.08,128.67 172.45,128.67 172.15,128.98 171.93,128.98 171.87,129.04 PUZ1.47
CSREF_2PH: length 92.4
  TOP w0.203: PCZ29.1 166.07,133.32 166.07,133.37 v2(165.82,133.63)
  TOP w0.254: v2(112.73,100.91) 113.16,100.48 PRG3.2 ; v2(165.82,133.63) 163.53,133.63 162.64,134.52 162.64,135.43 162.01,136.07 159.49,136.07 158.62,135.19 124.28,135.19 121.92,132.84 v1(121.92,128.59) 121.92,125.09 v2(121.59,124.76)
  IN3 w0.254: v2(121.59,124.76) 121.4,124.57 121.4,123.98 121.93,123.45 123.51,123.45 125.49,121.47 125.49,117.03 120,111.54 118.39,111.54 117.39,110.55 117.39,109.21 112.69,104.51 112.69,100.95 v2(112.73,100.91)
  BOTTOM w0.203: PUZ1.29 166.63,132.98 165.98,133.63 v2(165.82,133.63)
  BOTTOM w0.254: v2(165.82,133.63) 165.82,134.06 PCZ35.1
CSREF_4PH: length 67.8
  TOP w0.203: v2(163.34,123.72) v1(164.15,123.72) v2(165.07,123.72) v2(166.45,123.72) 167.34,123.72 v2(167.6,123.98) 167.46,123.98 167.09,124.36 PCZ26.2
  IN3 w0.254: v2(132.99,115.49) 132.99,113.75 133.48,113.26 140.06,113.26 140.61,113.8 147.08,113.8 147.53,114.25 147.53,114.65 v2(148.35,115.47) 148.93,114.89 148.93,114.58 149.69,113.82 162.59,113.82 168.03,119.25 168.03,121.13 167.59,121.56 165.5,121.56 v2(163.34,123.72)
  BOTTOM w0.203: PRZ76.1 PCZ38.1 163.29,123.67 v2(163.34,123.72) ; PUZ1.10 167.03,124.41 167.46,123.98 v2(167.6,123.98) 167.61,123.98 167.98,123.98 168.62,123.33 PCZ34.1 PRZ60.1 ; PRZ69.1 PCZ36.1 166.84,123.14 166.45,123.53 v2(166.45,123.72) ; PRZ71.1 PCZ37.1 v2(165.07,123.72)
  BOTTOM w0.254: PRZ87.2 133.42,115.07 133,115.49 v2(132.99,115.49) 132.95,115.49 132.53,115.07 PRZ90.2 ; PRZ81.2 148.76,115.06 v2(148.35,115.47) 148.29,115.47 147.88,115.06 PRZ84.2
CSSUM_2PH: length 8.1
  TOP w0.127: PRZ52.1 164.39,134.58 v1(163.87,135.1)
  TOP w0.203: PRZ52.1 165.37,134.58 166.2,135.41 PCZ28.2 PCZ27.2 166.25,134.01 v2(166.6,133.65)
  BOTTOM w0.203: PUZ1.30 167.03,133.18 166.6,133.6 v2(166.6,133.65) 166.61,133.66 166.61,134.64 PRZ50.2
CSSUM_4PH: length 14.8
  TOP w0.203: PRZ54.2 PRZ53.2 PRZ51.2 PRZ48.2 168.86,120.99 PRZ49.2 169.3,121.35 PCZ25.1 PCZ24.2 169.31,122.26 v1(168.31,123.26) 168.31,124.15 167.85,124.61 v2(167.59,124.61)
  BOTTOM w0.203: PUZ1.9 167.43,124.77 v2(167.59,124.61)
D_MIC_CLK: length 8.2
  BOTTOM w0.127: JEDP1.7 64.05,27.15 64.35,26.85 D506.3 64.35,24.46 v1(64.13,24.25) 63.83,23.94 RV58.2 RV59.2
D_MIC_CLK_CODEC: length 264.8
  TOP w0.127: RA55.2 295.48,15.25 295.71,15.02 295.71,13.76 294.59,12.64 293.86,12.64 290.97,9.74 289.64,9.74 288.36,8.46 288.36,5.39 287.6,4.63 283.07,4.63 282.1,5.6 281.13,5.6 280.21,4.68 279.75,4.68 v2(279.33,5.1) ; v2(179.12,7.05) 179.12,7.06 178.5,7.68 176.74,7.68 174.22,10.2 171.74,10.2 163.23,18.71 163.23,20.62 159.39,24.46 159.39,25.39 155.72,29.06 150.74,29.06 149.28,27.6 134.62,27.6 133.88,26.87 122.24,26.87 120.36,28.75 117.19,28.75 115.89,27.44 114.67,27.44 113,29.11 98.05,29.11 95.71,26.78 95.71,25.34 94,23.63 90,23.63 87.47,26.16 84.72,26.16 83.47,27.4 79.32,27.4 78.87,27.85 70.61,27.85 68.47,25.71 v1(65.74,25.71) 65.68,25.71 v2(65.24,25.27)
  IN1 w0.127: v2(179.12,7.05) 179.12,5.6 179.81,4.9 234.01,4.9 234.74,5.63 241.54,5.63 242.26,4.91 249.05,4.91 249.65,5.51 259.75,5.51 260.35,4.91 279.13,4.91 v2(279.33,5.1)
  BOTTOM w0.127: RV59.1 65.08,22.89 65.08,25.11 v2(65.24,25.27)
D_MIC_CLK_CPU: length 5.4
  TOP w0.127: RH253.1 207.03,15.89 207.52,15.89 207.81,16.18 207.81,16.88 v2(207.73,16.96)
  BOTTOM w0.127: UH1.BD16 207.32,19.15 207.32,18.8 207.14,18.62 207.14,18.33 207.32,18.15 207.32,17.37 v2(207.73,16.96)
D_MIC_CLK_R: length 190.4
  TOP w0.127: RH253.2 206.57,14.57 206.57,11.82 207.68,10.72 209.66,10.72 210.67,9.7 210.67,8.53 211.89,7.31 212.6,7.31 v2(213.03,7.75) ; v2(162.01,26.43) 162.01,22.58 163.75,20.84 163.75,18.93 171.96,10.72 174.44,10.72 176.96,8.2 179.15,8.2 180.29,7.06 v2(180.29,7.05) ; v2(107.03,26.36) 106.42,26.97 97.49,26.97 97.21,26.69 97.21,25.02 96.92,24.74 96.22,24.74 94.33,22.85 89.67,22.85 87.15,25.37 78.8,25.37 78.11,26.06 78.11,26.67 77.71,27.07 70.94,27.07 68.34,24.47 v1(64.34,24.47) 63.7,24.47 v2(63.54,24.63)
  IN1 w0.127: v2(213.03,7.75) 211.35,6.06 201.67,6.06 201.15,6.59 201.15,6.95 200.89,7.21 193.87,7.21 192.3,8.78 185.84,8.78 185.53,8.47 182.16,8.47 181.12,7.44 180.68,7.44 v2(180.29,7.05)
  BOTTOM w0.127: v2(162.01,26.43) 162.01,26.69 161.8,26.9 161.04,26.9 160.25,26.11 151.85,26.11 151.08,26.89 147.46,26.89 146.96,26.39 146.96,25.55 146.36,24.95 131.91,24.95 131.13,25.72 124.16,25.72 123.94,25.51 122.46,25.51 121.76,24.8 118.41,24.8 117.21,26 114.59,26 114.32,25.73 108.34,25.73 107.66,26.42 107.08,26.42 v2(107.03,26.36) ; v2(63.54,24.63) 62.97,24.06 62.97,21.69 CH107.1 63.35,21.56 63.57,21.78 63.57,22.16 RV58.1
D_MIC_DATA: length 8
  BOTTOM w0.127: RV61.2 65.85,24.25 RV60.2 66.64,24.72 66.28,25.08 D506.2 65.22,27.05 64.91,27.05 64.55,27.41 JEDP1.8
D_MIC_DATA_CODEC: length 262.9
  TOP w0.127: RA56.1 295.45,14.91 295.45,13.87 294.48,12.9 293.75,12.9 290.86,10.01 289.53,10.01 288.1,8.57 288.1,5.5 287.49,4.89 283.18,4.89 282.2,5.87 281.02,5.87 280.26,5.1 v2(279.92,5.1) ; v2(178.53,7.05) 178.16,7.42 176.63,7.42 174.12,9.93 171.64,9.93 162.97,18.6 162.97,20.51 159.13,24.35 159.13,25.29 155.61,28.8 150.85,28.8 149.39,27.34 134.73,27.34 133.99,26.61 122.13,26.61 120.25,28.49 117.3,28.49 116,27.18 114.56,27.18 112.89,28.85 98.15,28.85 95.97,26.67 95.97,25.23 94.11,23.37 89.89,23.37 87.36,25.89 84.61,25.89 83.55,26.95 v1(82.15,26.95) 79,26.95 78.36,27.59 70.72,27.59 68.44,25.31 66.1,25.31 v2(65.69,24.89)
  IN1 w0.127: v2(178.53,7.05) 178.53,6.82 178.74,6.62 178.74,5.6 179.7,4.64 234.12,4.64 234.85,5.36 241.44,5.36 242.16,4.64 249.16,4.64 249.76,5.25 259.65,5.25 260.25,4.64 279.46,4.64 v2(279.92,5.1)
  BOTTOM w0.127: RV61.1 65.52,23.33 65.35,23.51 65.35,24.55 v2(65.69,24.89)
D_MIC_DATA_CPU: length 3.6
  TOP w0.127: RH254.1 208.15,16.14 208.15,17.14 207.74,17.55 v2(207.73,17.55)
  BOTTOM w0.127: UH1.BF15 207.73,18.2 v2(207.73,17.55)
D_MIC_DATA_R: length 182
  TOP w0.127: v2(212.45,7.77) 212.26,7.57 212,7.57 210.93,8.64 210.93,9.81 209.77,10.98 207.78,10.98 206.83,11.93 206.83,13.91 RH254.2 ; v2(179.7,7.05) 179.7,7.06 178.82,7.94 176.85,7.94 174.33,10.46 171.85,10.46 163.49,18.82 163.49,20.73 161.43,22.79 v2(161.43,26.47) ; v2(67.44,24.89) v1(68.27,24.89) 68.39,24.89 70.83,27.33 77.82,27.33 78.37,26.78 78.37,26.17 78.91,25.63 87.26,25.63 89.78,23.11 94.22,23.11 96.11,25 96.81,25 96.94,25.13 96.94,26.8 97.38,27.23 106.75,27.23 107.48,26.5 v2(107.48,26)
  IN1 w0.127: v2(179.7,7.05) 179.7,7.09 180.31,7.7 181.01,7.7 182.05,8.74 185.42,8.74 185.73,9.04 192.41,9.04 193.98,7.47 203.75,7.47 204.19,7.03 206.45,7.03 207,7.57 207,7.9 207.32,8.23 208.81,8.23 209.01,8.03 212.19,8.03 v2(212.45,7.77)
  BOTTOM w0.127: RV60.1 66.64,23.34 66.98,23.34 67.44,23.79 v2(67.44,24.89) ; v2(107.48,26) 107.71,26 108.23,25.47 114.43,25.47 114.7,25.74 117.11,25.74 118.3,24.54 121.86,24.54 122.56,25.24 124.04,25.24 124.27,25.46 131.03,25.46 131.8,24.69 146.47,24.69 147.22,25.44 147.22,26.28 147.57,26.63 150.97,26.63 151.75,25.85 160.36,25.85 160.98,26.47 v2(161.43,26.47)
DCC_EN_HDMI: length 2.4
  TOP w0.127: RV24.2 22.07,59.97 v2(21.96,59.85)
  BOTTOM w0.127: v1(21.68,59.24) 21.96,59.52 v2(21.96,59.85) 21.99,59.88 UV2.3
DCHG_I: length 13.4
  TOP w0.127: UK1.73 146.44,22.29 146.75,21.97 149.83,21.97 150.56,22.71 151.53,22.71 153.4,24.57 v1(153.59,24.57) PRB41.1 156.2,25.43 PCB31.1
DCHG_I_R: length 91.7
  TOP w0.127: PRB41.2 158.05,24.57 v1(158.48,24.15) 162.45,20.18 162.45,18.38 171.42,9.41 172.86,9.41 174.01,8.26 175.05,8.26 176.64,6.67 v2(176.76,6.67) ; v2(233.53,8.85) 234.07,9.39 235.52,9.39 235.56,9.43 PUB01.7
  IN3 w0.127: v2(222.99,6.6) 224.29,6.6 228.35,10.66 231.93,10.66 233.53,9.05 v2(233.53,8.85)
  BOTTOM w0.127: v2(222.99,6.6) 222.4,7.19 221.61,7.19 221.11,6.69 202.91,6.69 202.08,7.52 200.8,7.52 199.85,6.57 177.84,6.57 177.63,6.78 176.99,6.78 176.88,6.67 v2(176.76,6.67)
DDR_DRAMRST#_R: length 97.8
  TOP w0.127: v2(172.59,23.49) 169.32,26.76 169.32,27.56 173.31,31.55 173.31,33.37 172.07,34.62 171.59,34.62 v2(171.1,35.11) ; CD10.2 129.37,28.69 v2(129.37,27.96)
  IN3 w0.127: v2(171.1,35.11) 168.97,37.24 168.97,40.64 168.33,41.27 167.77,41.27 167.04,40.54 167.04,38.15 166.39,37.51 135.49,37.51 132.91,40.08 v2(131.76,40.08) 131.38,40.08 128.94,37.64 128.94,28.39 v2(129.37,27.96)
  BOTTOM w0.127: JDIMM2.108 129.28,28.05 v2(129.37,27.96) ; v2(131.76,40.08) 131.75,40.09 131.31,40.09 130.77,40.63 JDIMM1.108 ; RH40.2 183.5,16.34 180.13,19.71 176.37,19.71 v2(172.59,23.49)
