# Allegro board LA-H461P Rev02.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
CK13  0.1U_0402_16V7K  [C_0402]  133.08 16.18 180 top
CK14  0.1U_0402_16V7K  [C_0402]  190.51 21.07 90 top
CK15  100P_0402_50V8J  [C_0402]  147.17 25.51 90 top
CL1  0.01U_0402_16V7K  [C_0402]  46.74 32.54 0 top
CL2  10P_1808_3KV  [C_1808]  41.76 43.3 270 bottom
CL3  120P_0402_50V8J  [C_0402]  34.75 43.69 270 bottom
CL4  0.1U_0402_16V7K  [C_0402]  47.66 26.44 180 top
CL5  0.1U_0201_10V6K  [C_0201]  52.15 22.97 90 bottom
CL8  4.7U_0402_6.3V6M  [C_0402]  51.51 13.39 270 bottom
CL9  0.1U_0201_10V6K  [C_0201]  59.52 20.56 90 bottom
CL10  4.7U_0402_6.3V6M  [C_0402]  54.31 15.59 270 bottom
CL11  0.1U_0201_10V6K  [C_0201]  52.15 21.45 90 bottom
CL12  0.1U_0201_10V6K  [C_0201]  59.01 23.01 0 bottom
CL13  0.1U_0201_10V6K  [C_0201]  55.16 16.03 0 bottom
CL14  0.1U_0201_10V6K  [C_0201]  55.16 14.76 0 bottom
CL15  1U_0201_6.3V6M  [C_0201]  55.16 15.39 0 bottom
CL16  0.1U_0201_10V6K  [C_0201]  54.48 16.41 180 bottom
CL19  4.7U_0402_6.3V6M  [C_0402]  51.37 23.22 180 bottom
CL20  4.7U_0402_6.3V6M  [C_0402]  60.3 20.77 90 bottom
CL23  0.1U_0201_10V6K  [C_0201]  52.27 13.23 270 bottom
CL24  10P_0402_50V8J  [C_0402]  50.88 20.34 270 bottom
CL25  10P_0402_50V8J  [C_0402]  50.88 17.68 90 bottom
CL26  0.1U_0201_10V6K  [C_0201]  55.07 23.35 90 bottom
CL27  1U_0201_6.3V6M  [C_0201]  51.05 21.49 180 bottom
CL28  1500P_0402_50V7K  [C_0402]  61.12 13.84 0 bottom
CL29  4.7U_0402_6.3V6M  [C_0402]  52.55 16.11 180 top
CLRP1  SHORT PADS  [SHORTPADS]  188.8 17.68 90 top
CLRP2  SHORT PADS  [SHORTPADS]  188.55 20.85 0 top
CLRP3  SHORT PADS  [SHORTPADS]  215.63 20.37 180 top
CR1  0.1U_0402_16V7K  [C_0402]  37.17 21.61 0 top
CR2  0.1U_0402_16V7K  [C_0402]  37.8 16.41 180 bottom
CR3  4.7U_0402_6.3V6M  [C_0402]  45.42 18.82 0 bottom
CR4  10U_0402_6.3V6M  [C_0402]  37.17 20.72 0 top
CR6  0.1U_0402_16V7K  [C_0402]  45.42 17.93 0 bottom
CR7  10U_0402_6.3V6M  [C_0402]  37.8 15.52 180 bottom
CR9  4.7U_0402_6.3V6M  [C_0402]  37.8 18.18 180 bottom
CR10  0.1U_0402_16V7K  [C_0402]  37.8 17.3 180 bottom
CR11  0.1U_0402_10V7K  [C_0402]  60.32 16.84 180 bottom
CR12  6.8P_0402_50V8C  [C_0402]  38.56 21.61 270 bottom
CR13  0.1U_0402_10V7K  [C_0402]  60.32 15.95 180 bottom
CR14  0.1U_0402_10V7K  [C_0402]  39.62 12.15 90 bottom
CR15  0.1U_0402_10V7K  [C_0402]  38.73 12.15 90 bottom
CR16  0.1U_0402_16V7K  [C_0402]  39.65 15.79 90 top
CR17  1U_0201_6.3V6M  [C_0201]  40.21 20.72 90 bottom
CS7  0.1U_0402_16V7K  [C_0402]  20.66 76.99 270 bottom
CS8  1U_0201_6.3V6M  [C_0201]  22.34 84.9 0 bottom
CS9  47U_0805_6.3V6M  [C_0805]  21.15 83.76 0 bottom
CS21  .1U_0402_16V7K  [C_0402]  20.74 82.69 90 top
CS22  10U_0402_6.3V6M  [C_0402]  21.7 76.37 270 top
CS29  0.1U_0402_16V7K  [C_0402]  21.03 90.32 0 bottom
CS34  0.1U_0402_16V7K  [C_0402]  21.03 89.43 0 bottom
CS107  0.1U_0402_16V7K  [C_0402]  23.48 76.37 270 top
CS108  0.1U_0402_25V7K  [C_0402]  18.08 82.33 180 top
CS109  1U_0201_6.3V6M  [C_0201]  20.3 82.9 90 bottom
CS110  10U_0402_6.3V6M  [C_0402]  22.59 76.37 270 top
CS111  10U_0402_6.3V6M  [C_0402]  20.82 76.37 270 top
CS113  10U_0402_6.3V6M  [C_0402]  21.63 82.69 90 top
CS114  22U_0603_6.3V6M  [C_0603]  22.69 82.8 90 top
CT3  0.1U_0201_10V6K  [C_0201]  36.15 48.16 180 top
CT5  0.1U_0201_10V6K  [C_0201]  36.45 49.55 180 top
CT17  0.1U_0201_10V6K  [C_0201]  36.15 48.79 180 top
CT19  0.1U_0201_10V6K  [C_0201]  36.45 50.19 180 top
CT20  0.1U_0201_10V6K  [C_0201]  36.33 50.95 180 top
CT21  0.1U_0201_10V6K  [C_0201]  36.33 51.59 180 top
CT22  0.1U_0201_10V6K  [C_0201]  36.33 52.35 180 top
CT24  0.1U_0201_10V6K  [C_0201]  36.33 52.98 180 top
CT270  10U_0402_6.3V6M  [C_0402]  36.27 54.15 0 top
CT271  0.1U_0201_6.3V6K  [C_0201]  27.72 54.76 180 top
CT272  0.1U_0201_6.3V6K  [C_0201]  29.3 48.4 90 bottom
CT273  0.1U_0201_6.3V6K  [C_0201]  29.95 48.4 90 bottom
CT274  0.1U_0201_6.3V6K  [C_0201]  35.53 54.19 270 top
CT279  0.22U_0201_25V6K  [C_0201]  26.73 51.78 0 top
CT280  0.22U_0201_25V6K  [C_0201]  26.73 51.14 0 top
CT281  0.22U_0201_25V6K  [C_0201]  26.73 49.92 0 top
CT282  0.22U_0201_25V6K  [C_0201]  26.73 50.56 0 top
CT283  0.1U_0201_10V6K  [C_0201]  31.72 57.29 90 top
CT284  0.1U_0201_10V6K  [C_0201]  30.83 57.29 90 top
CT285  0.1U_0201_10V6K  [C_0201]  31.91 45.73 270 top
CT286  0.1U_0201_10V6K  [C_0201]  31.32 45.73 270 top
CT287  0.1U_0201_10V6K  [C_0201]  33.89 45.88 270 top
CT288  0.1U_0201_10V6K  [C_0201]  33.29 45.88 270 top
CT319  0.33U_0201_25V6K  [C_0201]  26.27 52.99 0 top
CT320  0.33U_0201_25V6K  [C_0201]  26.27 52.36 0 top
CT321  0.33U_0201_25V6K  [C_0201]  27.06 48.11 0 top
CT322  0.33U_0201_25V6K  [C_0201]  27.06 48.74 0 top
CTT1  0.1U_0402_16V4Z  [C_0402]  119.03 13.99 180 top
CTT2  1U_0201_6.3V6M  [C_0201]  127.8 18.18 0 top
CTT3  0.1U_0402_16V4Z  [C_0402]  119.04 18.19 180 top
CTT4  0.1U_0402_16V4Z  [C_0402]  119.04 19.08 180 top
CTT323  1U_0201_6.3V6M  [C_0201]  123.99 12.98 0 top
CU57  0.47U_0402_25V6K  [C_0402]  11.62 52.71 90 top
CU58  0.47U_0402_25V6K  [C_0402]  10.73 52.71 90 top
CU59  0.47U_0402_25V6K  [C_0402]  11.19 50.95 90 top
CU60  0.47U_0402_25V6K  [C_0402]  12.08 51.84 270 top
CU61  22U_0603_6.3V6K  [C_0603]  39.92 42.83 270 top
CU62  4.7U_0402_6.3V6M  [C_0402]  41.91 41.67 90 top
CU63  1000P_0402_50V7K  [C_0402]  41.11 38.94 270 top
CU64  0.1U_0402_25V6  [C_0402]  42 38.94 270 top
CU65  1U_0603_25V6  [C_0603]  39.97 39.37 270 top
CU66  120P_0402_50V  [C_0402]  50.62 38.15 270 top
CU67  120P_0402_50V  [C_0402]  48.62 37.5 270 top
CU68  22P 50V J NPO 0402  [C_0402]  54.54 46.84 270 top
CU69  4.7U_0402_6.3V6M  [C_0402]  52.74 44.02 0 top
CU70  10U_0402_6.3V6M  [C_0402]  42 46.11 180 top
CU71  10U_0402_6.3V6M  [C_0402]  39.97 47.19 90 top
CU72  0.1U_0402_16V4Z  [C_0402]  60.92 23.31 0 bottom
CU73  4.7U_0402_6.3V6M  [C_0402]  49.7 38.15 270 top
CU74  4.7U_0402_6.3V6M  [C_0402]  55.13 44.68 270 top
CV1  22U_0603_6.3V6M  [C_0603]  73.8 37.11 0 top
CV2  68P_0402_50V8J  [C_0402]  78.01 38.76 180 top
CV3  22U_0603_6.3V6M  [C_0603]  68.48 33.89 180 top
CV4  22U_0603_6.3V6M  [C_0603]  69.66 32.74 0 top
CV5  680P_0402_50V7K  [C_0402]  79.41 30.76 180 top
CV6  68P_0402_50V8J  [C_0402]  79.41 29.87 180 top
CV7  .1U_0402_16V7K  [C_0402]  73.5 27.25 90 bottom
CV8  .1U_0402_16V7K  [C_0402]  72.61 27.25 90 bottom
CV9  .1U_0402_16V7K  [C_0402]  75.32 27.25 90 bottom
CV10  .1U_0402_16V7K  [C_0402]  74.43 27.25 90 bottom
CV11  .1U_0402_16V7K  [C_0402]  77.13 27.25 90 bottom
CV12  .1U_0402_16V7K  [C_0402]  76.24 27.25 90 bottom
CV13  .1U_0402_16V7K  [C_0402]  78.95 27.25 90 bottom
CV14  .1U_0402_16V7K  [C_0402]  78.06 27.25 90 bottom
CV15  .1U_0402_16V7K  [C_0402]  80.85 27.25 90 bottom
CV16  .1U_0402_16V7K  [C_0402]  79.96 27.25 90 bottom
CV17  220P_0402_50V7K  [C_0402]  71.63 24.32 270 bottom
CV18  220P_0402_50V7K  [C_0402]  71.79 26.27 270 bottom
CV19  4.7U_0402_6.3V6M  [C_0402]  28.77 59.03 0 top
CV20  0.1U_0402_10V6K  [C_0402]  25.84 58.82 90 top
CV21  0.1U_0402_10V6K  [C_0402]  27.21 58.84 90 top
CV22  0.01U_0402_16V7K  [C_0402]  24.49 58.8 90 top
CV23  0.1U_0402_10V6K  [C_0402]  23.22 58.24 90 top
CV24  0.1U_0402_10V6K  [C_0402]  22.73 62.62 0 top
CV25  0.01U_0402_16V7K  [C_0402]  25.87 64.01 270 top
CV26  0.1U_0402_10V6K  [C_0402]  28.99 59.96 180 top
CV27  0.1U_0402_10V6K  [C_0402]  22.76 61.28 0 top
CV28  0.01U_0402_16V7K  [C_0402]  24.51 63.99 270 top
CV29  0.1U_0402_10V6K  [C_0402]  27.21 64 270 top
CV30  0.01U_0402_16V7K  [C_0402]  28.76 61.28 180 top
CV31  0.1U_0402_10V6K  [C_0402]  28.07 66.19 90 top
CV32  0.01U_0402_16V7K  [C_0402]  28.15 66.29 90 bottom
CV33  0.1U_0402_10V6K  [C_0402]  20.66 57.33 270 top
CV34  0.1U_0402_10V6K  [C_0402]  31.33 57.34 180 bottom
CV35  0.1U_0402_10V6K  [C_0402]  31.33 56.38 180 bottom
CV36  0.1U_0402_10V6K  [C_0402]  26.88 55.5 90 bottom
CV37  0.1U_0402_10V6K  [C_0402]  25.99 55.5 90 bottom
CV38  0.1U_0402_10V6K  [C_0402]  24.97 55.5 90 bottom
CV39  0.1U_0402_10V6K  [C_0402]  24.08 55.5 90 bottom
CV40  0.1U_0402_10V6K  [C_0402]  23.07 55.5 90 bottom
CV41  0.1U_0402_10V6K  [C_0402]  22.18 55.5 90 bottom
CV43  1U_0201_6.3V6M  [C_0201]  28.28 56.24 90 top
CV44  1U_0201_6.3V6M  [C_0201]  21.39 56.28 90 top
CV45  .1U_0402_16V7K  [C_0402]  15.08 117.23 90 top
CV46  10P_0402_50V8J  [C_0402]  68.15 32.66 180 top
CV47  33P_0402_50V8J  [C_0402]  69.84 31.69 0 top
CV49  680P_0402_50V7K  [C_0402]  69.6 39.52 0 top
CV52  1000P_0402_50V7K  [C_0402]  15.97 118.12 270 top
CV53  1U_0201_6.3V6M  [C_0201]  27.65 56.24 90 top
CV54  10U_0402_6.3V6M  [C_0402]  87.54 33.46 0 top
CV273  2200P_0402_50V7K  [C_0402]  180.37 121.44 180 bottom
CV274  0.1U_0402_16V4Z  [C_0402]  181.31 121.51 270 bottom
CW1  10U_0402_6.3V6M  [C_0402]  304.96 7.05 270 top
CWL1  100P_0402_50V8J  [C_0402]  310.09 22.76 0 top
CWL2  0.1U_0402_25V6  [C_0402]  310.09 24.28 0 top
CWL3  100P_0402_50V8J  [C_0402]  310.09 5.74 0 top
CWL4  22U_0603_6.3V6K  [C_0603]  307.29 6.75 180 top
CWL5  0.1U_0201_10V6K  [C_0201]  310.09 6.5 0 top
CWL7  0.1U_0201_10V6K  [C_0201]  310.09 23.52 0 top
D1  AZ5123-02S.R7G_SOT23-3  [AZ5123-02SPR7G_SOT23-3]  10.42 122.73 90 top
D3  AZ5123-02S.R7G_SOT23-3  [AZ5123-02SPR7G_SOT23-3]  207.98 128.93 0 top
D506  -  [AZC199-02SPR7G_SOT23-3]  65.31 28.08 0 bottom
D507  -  [AZC199-02SPR7G_SOT23-3]  69.27 25.07 180 bottom
D508  LRB751V-40T1G SOD-323  [CH751H-40PT_SOD323-2]  205.95 135.28 270 top
D510  RB751V-40 SOD-323  [CH751H-40PT_SOD323-2]  128.3 9.29 0 top
D511  LRB751V-40T1G_SOD323-2  [CH751H-40PT_SOD323-2]  182.38 48.74 270 top
D513  LRB751V-40T1G_SOD323-2  [CH751H-40PT_SOD323-2]  38.82 2.56 90 bottom
D514  RB751V-40 SOD-323  [CH751H-40PT_SOD323-2]  128.3 7.64 0 top
D516  LRB751V-40T1G_SOD323-2  [CH751H-40PT_SOD323-2]  176.03 45.97 90 top
D517  RB751V-40 SOD-323  [CH751H-40PT_SOD323-2]  111.71 25.17 270 top
DA1  AZ5125-01H.R7G_SOD523-2  [AZ5125-01HPR7G_SOD523-2]  289.01 25.93 180 top
DA3  -  [LRB521S-40T1G_SOD523-2-2]  292.82 12.85 90 top
DA8  -  [L03ESDL5V0CC3-2_SOT23-3]  295.76 37.86 270 top
DA9  -  [L03ESDL5V0CC3-2_SOT23-3]  295.76 41.96 270 top
DG1  -  [RB751S40T1G_SOD523-2]  245.95 39.77 0 bottom
DG2  -  [RB751S40T1G_SOD523-2]  220.49 64.84 90 top
DG3  -  [BAV70W_SOT323-3]  236.53 50.72 45 top
DG4  -  [RB751S40T1G_SOD523-2]  235.29 41.68 0 bottom
DG5  -  [RB751S40T1G_SOD523-2]  238.21 41.55 90 bottom
DG7  -  [RB751S40T1G_SOD523-2]  235.28 42.87 0 bottom
DG243  -  [RB751S40T1G_SOD523-2]  224.15 63.95 90 top
DH1  LBAT54CLT1G_SOT23-3  [BAT54C-7-F_SOT23-3]  179.79 12.52 90 top
DH2  LRB751V-40T1G_SOD323-2  [CH751H-40PT_SOD323-2]  191.22 16.28 0 top
DH3  LRB751V-40T1G_SOD323-2  [CH751H-40PT_SOD323-2]  188.68 14.63 0 top
DK2  LRB751V-40T1G_SOD323-2  [CH751H-40PT_SOD323-2]  131.57 20.97 90 top
DL1  -  [AZC199-02SPR7G_SOT23-3]  38.17 39.11 180 bottom
DM5  AZC099-04S.R7G_SOT23-6  [AZC099-04SPR7G_SOT23-6]  85.51 11.44 270 top
DM12  AZC099-04S.R7G_SOT-23-6-6  [YSUSB2P0-5_SOT-23-6-6]  52.56 27.76 270 bottom
DM13  AZC099-04S.R7G_SOT-23-6-6  [YSUSB2P0-5_SOT-23-6-6]  52.56 34.11 270 bottom
DM16  -  [AZC199-02SPR7G_SOT23-3]  8.13 59.97 270 top
DS5  -  [AZC199-02SPR7G_SOT23-3]  20.52 88.8 90 top
DS6  -  [AZ1045-04F_DFN2510P10E-10-9]  17.73 88.03 90 bottom
DT1  -  [AZC199-02SPR7G_SOT23-3]  95.2 14.53 180 top
DU1  -  [PUSB3FR4_DFN2510A-10-10]  14.08 53.16 270 top
DU2  -  [PUSB3FR4_DFN2510A-10-10]  14.08 51.13 90 bottom
DU3  -  [PUSB3FR4_DFN2510A-10-10]  15.77 47.44 90 top
DU13  -  [L30ESD24VC3-2_SOT23-3]  11.13 44.85 0 top
DU14  -  [AZC199-02SPR7G_SOT23-3]  15.96 48.28 90 bottom
DV1  -  [AZ1045-04F_DFN2510P10E-10-9]  16.09 116.09 270 bottom
DV2  -  [AZ1045-04F_DFN2510P10E-10-9]  16.09 112.02 270 bottom
DV3  -  [AZ1045-04F_DFN2510P10E-10-9]  16.09 108.72 270 bottom
EC11  VARIST_ CK0402101V05 0402  [CK0402101V05_0402-2]  18.37 7.42 270 top
FD1  -  [FIDUCIAL_C40M80]  12.15 126.06 0 top
FD2  -  [FIDUCIAL_C40M80]  290.28 7.14 0 top
FD3  -  [FIDUCIAL_C40M80]  234.29 119.56 180 bottom
FD4  -  [FIDUCIAL_C40M80]  3 3.58 180 bottom
FU1  0.5A_15V_MF-MSMF050-2~D  [F_MF-MSMF050-2]  86.36 29.36 180 top
H1  -  [H_2P3-G]  179 133.9 0 top
H2  -  [H_2P3-G]  229.5 7.9 0 top
H4  -  [H_2P3-G]  93 52.9 0 top
H7  -  [H_2P3-G]  49.05 5.9 0 top
H8  -  [H_2P3-G]  267.5 52.9 0 top
H9  -  [H_2P3-G]  295.7 7.9 0 top
H11  -  [H_2P3-G]  15.94 58.89 0 top
H12  -  [H_4P0]  121.6 119.23 0 top
H13  -  [H_4P0]  175.6 116.08 0 top
H14  -  [H_4P0]  231.87 111.99 0 top
H15  -  [H_4P0]  117.18 79.83 0 top
H16  -  [H_2P3-G]  3.5 125.9 0 top
H17  -  [H_2P3-G]  12 4 0 top
H18  -  [H_4P0]  176.02 75.43 0 top
H19  -  [H_4P0]  180.53 63.65 0 top
H20  -  [H_4P0]  247.76 50.69 0 top
H22  -  [H_2P3X2P8]  3 9 90 top
H23  -  [H_2P3-G]  24 115.28 0 top
H25  -  [H_2P3N]  201.3 135.87 0 top
H33  -  [H_4P0-G]  256 68.9 0 top
JCR2  T-SOL_5-531809001000-6  [T-SOL_5-531809001000-6_15P-T]  34 19.7 90 bottom
JDIMM1  ARGOS_D4AR0-26015-1P40  [ARGOS_D4AR0-26015-1P40_260P]  104.02 50.25 0 bottom
JDIMM2  ARGOS_D4AS0-26010-1P40  [ARGOS_D4AS0-26010-1P40_260P]  102.53 37.5 180 bottom
JEDP1  ACES_50203-0400C-002  [ACES_50203-0400C-002_40P-T]  61.05 30.45 0 bottom
JFAN1  ACES_50224-00401-001  [ACES_50224-00401-001_4P]  274.99 47.38 180 bottom
JFAN2  ACES_50224-00401-001  [ACES_50224-00401-001_4P]  32.68 49.6 270 bottom
JHDD1  HEFEN_AFC02-S12FRA-HF  [HEFEN_AFC02-S12FRA-HF_12P]  251.15 15.98 180 bottom
JHDMI1  -  [ACON_HMRA3-AK120C_19P]  10.75 107.15 90 bottom
JIO1  JXT_FP243A-036G1BM  [JXT_FP243A-036G1BM_36P]  306.68 45.75 270 bottom
JKB1  SDAN_606011-032241  [SDAN_606011-032241_32P]  175.35 12.5 180 bottom
JKBL1  ACES_51575-00401-001  [ACES_51575-00401-001_4P]  216.9 11.42 180 bottom
JL33  -  [JUMP_43X79]  55.3 15.61 180 top
JP3  -  [JUMP_43X79]  181.44 31.77 270 top
JP4  -  [JUMP_43X79]  38.69 13.61 270 top
JPHW8  -  [JUMP_43X118]  38 39.75 180 top
JPWR1  JXT_FP241AH-006GAAM  [JXT_FP241AH-006GAAM_6P]  9.75 123.26 0 bottom
JRJ45  SDAN_601051-008041  [SDAN_601051-008041_8P]  12.84 74.79 90 bottom
JSPK1  ACES_50224-00601-001  [ACES_50224-00601-001_6P]  301.8 46.13 180 bottom
JSSD1  ARGOS_NFSM0-S6715-TPH4  [ARGOS_NFSM0-S6715-TPH4_67P]  35.85 9.33 180 bottom
JTP1  TWVM_FPC1020-08RC-MA0HA  [TWVM_FPC1020-08RC-MA0HA_8P]  92.2 13.5 180 bottom
JUSB3  ACON_TCRAR-9U1391  [ACON_TCRAR-9U1391_9P-T]  14.7 92.35 90 bottom
JUSBC1  SUYIN_020090HB024M51HZL  [SINGA_2UB1688-C00111F_24P-T]  7.5 55.19 270 top
JWLAN1  LOTES_APCI0019-P003H  [LOTES_APCI0019-P003H_67P]  302.82 24.6 270 bottom
L1  DLM0NSN900HY2D_4P  [MURAT_DLM0NSN900HY2D_4P]  68.72 22.77 90 bottom
LA1  SUPPRE_ KC FBMA-10-100505-101T 0402  [R_0402]  289.51 10.69 180 top
LA2  0_0603_5%  [R0603_0OHM]  290.4 24.79 90 top
LA3  0_0402_5%  [R0402_0OHM]  301.33 21.99 0 top
LA4  FBMA-L11-201209601LMA20T_2P  [C_0805]  288.88 16.66 180 top
LA8  BLM15AX601SN1D_2P  [MURAT_BLM15AX601SN1D_2P]  304.12 28.22 180 bottom
LA9  BLM15AX601SN1D_2P  [MURAT_BLM15AX601SN1D_2P]  304.12 29.49 180 bottom
LA10  BLM15AX601SN1D_2P  [MURAT_BLM15AX601SN1D_2P]  304.12 30.63 180 bottom
LED4  HT-110UD_1204  [LED_LTST-S482KFKT-SE_2P]  2.45 62.65 0 bottom
LED5  B2591BS--05P-000132_WHITE  [LED_LTST-S482KFKT-SE_2P]  2.45 60.55 0 top
LG1  CHILISIN PBY160808T-330Y-N  [MURAT_BLM18PG330SN1D_2P]  193.93 80.41 90 top
LG3  CHILISIN PBY160808T-330Y-N  [MURAT_BLM18PG330SN1D_2P]  188.8 95.91 270 bottom
LK1  S SUPPRE_ TAI-TECH HCB1005KF-221T15 0402  [MURAT_BLM15BD601SN1D_2P]  151.73 26.47 270 top
LK2  TAI-TECH HCB1005KF-221T15 0402  [MURAT_BLM15BD601SN1D_2P]  149.36 26.49 270 top
LL2  2.2UH_MHCD252012A-2R2M-A8S_2A_20%  [CHILI_MHCD252012A-2R2M-A8S_2P]  52.28 16.39 270 bottom
LS9  DLM0NSN900HY2D_4P  [MURAT_DLM0NSN900HY2D_4P]  19.96 85.82 90 top
LV1  0_0805_5%  [R_0805]  87.84 36.18 270 top
LV2  3A_Z120_40M_0603_2P  [CHILI_PBY160808T-121Y-N_2P]  73.86 35.77 0 top
LV3  2.2UH_MHCD252012A-2R2M-A8S_2A_20%  [CHILI_MHCD252012A-2R2M-A8S_2P]  70.31 37.47 270 top
ML11  DLM0NSN900HY2D_4P  [MURAT_DLM0NSN900HY2D_4P]  17.85 48.96 180 top
NOREF  -  []  247.76 50.69 0 top
NOREF#2  -  []  12 4 0 top
NOREF#3  -  []  117.18 79.83 0 top
NOREF#4  -  []  176.02 75.43 0 top
NOREF#5  -  []  231.87 111.99 0 top
NOREF#6  -  []  267.5 52.9 0 top
NOREF#7  -  []  175.6 116.08 0 top
NOREF#8  -  []  229.5 7.9 0 top
NOREF#9  -  []  295.7 7.9 0 top
NOREF#10  -  []  206.08 47.65 0 top
NOREF#11  -  []  256 68.9 0 top
NOREF#12  -  []  64.85 -30.38 0 top
NOREF#13  -  []  140.94 -13.55 0 top
NOREF#14  -  []  112.88 62.81 0 top
NOREF#15  -  []  179 133.9 0 top
NOREF#16  -  []  121.6 119.23 0 top
NOREF#17  -  []  223.55 36.83 0 top
NOREF#18  -  []  180.53 63.65 0 top
NOREF#19  -  []  125.63 70.69 0 top
NOREF#20  -  []  93 52.9 0 top
NOREF#21  -  []  156.8 66.57 180 bottom
NOREF#22  -  []  272.88 30.99 180 bottom
NOREF#23  -  []  228.16 34.95 180 bottom
PC1  0.022U_0402_25V7K  [C_0402]  280.5 30.77 270 top
PC2  2200P_0402_50V7K  [C_0402]  281.51 30.77 270 top
PC3  2200P_0402_50V7K  [C_0402]  276.27 36.01 90 top
PC4  1000P_0402_50V7K  [C_0402]  275.38 36.01 90 top
PC5  100P_0402_50V8J  [C_0402]  285.32 40.08 90 top
PC6  1000P_0402_50V7K  [C_0402]  284.43 40.08 90 top
PC8  1000P_0402_50V7K  [C_0402]  274.24 10.23 90 bottom
PC9  0.01U_0402_25V7K  [C_0402]  272.42 10.24 90 bottom
PC10  100P_0402_50V8J  [C_0402]  273.32 10.23 90 bottom
PC11  100P_0402_50V8J  [C_0402]  271.51 10.23 90 bottom
PC301  0.1U_0402_25V6  [C_0402]  246.59 28.86 180 bottom
PC302  0.1U_0402_25V6  [C_0402]  244.91 27.96 180 bottom
PC303  2200P_0402_50V7K  [C_0402]  247.47 34.53 0 bottom
PC305  10U_0603_25V6M  [C_0603-S3]  247.59 33.45 0 bottom
PC306  22U_0603_6.3V6M  [C_0603]  240.81 17.72 180 bottom
PC307  22U_0603_6.3V6M  [C_0603]  240.83 20.16 180 bottom
PC308  22U_0603_6.3V6M  [C_0603]  250.11 19.53 0 bottom
PC309  22U_0603_6.3V6M  [C_0603]  240.83 18.93 180 bottom
PC310  4.7U_0402_6.3V6M  [C_0402]  252.39 27.54 270 bottom
PC311  680P_0402_50V7K  [C_0402]  250.12 20.62 0 bottom
PC312  1000P_0402_50V7K  [C_0402]  252.72 29.83 0 bottom
PC313  0.1U_0402_25V6  [C_0402]  75.75 6.68 180 top
PC314  10U_0603_25V6M  [C_0603-S3]  79.23 5.78 90 bottom
PC316  2200P_0402_50V7K  [C_0402]  80.29 5.76 90 bottom
PC317  0.1U_0402_25V6  [C_0402]  81.22 5.76 90 bottom
PC318  2.2U_0402_6.3V6M  [C_0402]  78.96 9.58 0 bottom
PC319  22U_0603_6.3V6M  [C_0603]  63.45 9.61 180 bottom
PC320  22U_0603_6.3V6M  [C_0603]  63.46 8.32 180 bottom
PC321  22U_0603_6.3V6M  [C_0603]  63.41 10.93 180 top
PC322  22U_0603_6.3V6M  [C_0603]  64.48 5.78 180 top
PC323  22U_0603_6.3V6M  [C_0603]  63.46 8.32 180 top
PC324  22U_0603_6.3V6M  [C_0603]  63.41 7 180 top
PC325  680P_0402_50V7K  [C_0402]  69.98 8.13 0 top
PC326  4.7U_0402_6.3V6M  [C_0402]  78.96 10.55 0 bottom
PC327  1000P_0402_50V7K  [C_0402]  76.96 11.81 90 bottom
PC328  4.7U_0402_6.3V6M  [C_0402]  252.52 30.69 90 bottom
PC329  1U_0402_25V6K  [C_0402]  75.01 11.72 0 bottom
PC330  22U_0603_6.3V6M  [C_0603]  63.42 10.94 180 bottom
PC331  22U_0603_6.3V6M  [C_0603]  64.49 5.76 180 bottom
PC332  22U_0603_6.3V6M  [C_0603]  63.45 9.61 180 top
PC333  22U_0603_6.3V6M  [C_0603]  63.42 6.99 180 bottom
PC1001  0.1U_0402_25V6  [C_0402]  240.73 25.69 0 bottom
PC1002  0.1U_0402_25V6  [C_0402]  234.73 30.15 270 bottom
PC1003  680P_0603_50V7K  [C_0603]  234.57 25.74 270 top
PC1004  22U_0603_6.3V6M  [C_0603]  234.58 19.92 0 bottom
PC1005  22U_0603_6.3V6M  [C_0603]  234.57 18.68 0 bottom
PC1006  22U_0603_6.3V6M  [C_0603]  234.59 21.12 0 bottom
PC1007  22U_0603_6.3V6M  [C_0603]  234.62 22.34 0 bottom
PC1008  330P_0402_50V7K  [C_0402]  237.83 22.08 0 bottom
PC1010  2.2U_0402_6.3V6M  [C_0402]  235.92 24.27 270 bottom
PC1011  2200P_0402_50V7K  [C_0402]  241.28 29.01 270 bottom
PC1012  0.1U_0402_25V6  [C_0402]  237.43 30.01 90 bottom
PC1013  10U_0603_25V6M  [C_0603-S3]  242.35 29.57 270 bottom
PC1014  1U_0402_16V6K  [C_0402]  236.82 24.28 270 bottom
PC1801  22U_0603_6.3V6M  [C_0603]  267.19 19.71 270 bottom
PC1802  22P_0402_50V8J  [C_0402]  265.21 22.47 0 bottom
PC1803  22U_0603_6.3V6M  [C_0603]  259.44 21.54 0 bottom
PC1804  22U_0603_6.3V6M  [C_0603]  259.63 17.57 0 bottom
PC1805  0.1U_0402_16V7K  [C_0402]  262.68 23.39 180 bottom
PC1806  680P_0402_50V7K  [C_0402]  265.14 18.52 0 bottom
PC2501  22U_0603_6.3V6M  [C_0603]  103.67 17.57 0 top
PC2502  0.47U_0402_6.3V6K  [C_0402]  109.49 14.49 270 top
PC2503  680P_0402_50V7K  [C_0402]  109.54 19.91 270 top
PC2504  68P_0402_50V8J  [C_0402]  104.23 14.92 0 top
PC2505  22U_0603_6.3V6M  [C_0603]  110.99 16 270 top
PC2506  22U_0603_6.3V6M  [C_0603]  112.24 16 270 top
PCA1  10U_0603_25V6M  [C_0603-S3]  157.88 127.79 0 top
PCA2  10U_0603_25V6M  [C_0603-S3]  157.88 127.79 0 bottom
PCA3  0.1U_0402_25V6  [C_0402]  158.12 125.75 0 top
PCA4  2200P_0402_50V7K  [C_0402]  158.12 126.64 0 top
PCA5  0.22U_0603_25V7K  [C_0603]  158.07 131.79 270 bottom
PCA6  2.2U_0402_6.3V6M  [C_0402]  160.86 134.82 90 bottom
PCA7  680P_0402_50V7K  [C_0402]  159.97 124.31 270 top
PCA23  1U_0201_6.3V6M  [C_0201]  160.69 101.23 0 top
PCA25  22U_0603_6.3V6M  [C_0603]  159.73 100.31 180 top
PCA26  22U_0603_6.3V6M  [C_0603]  160.04 96.4 180 top
PCA27  22U_0603_6.3V6M  [C_0603]  161.14 95.1 270 top
PCA28  22U_0603_6.3V6M  [C_0603]  161.11 99.87 270 top
PCA29  22U_0603_6.3V6M  [C_0603]  160.04 99.02 180 top
PCA30  22U_0603_6.3V6M  [C_0603]  160.04 95.11 180 top
PCA31  22U_0603_6.3V6M  [C_0603]  161.11 96.08 90 top
PCA32  22U_0603_6.3V6M  [C_0603]  159.71 101.63 180 top
PCA33  22U_0603_6.3V6M  [C_0603]  160.04 97.72 180 top
PCA34  22U_0603_6.3V6M  [C_0603]  159.76 93.86 180 top
PCB01  2200P_0402_50V7K  [C_0402]  267.96 29.45 180 top
PCB02  0.1U_0402_25V6  [C_0402]  266.3 36.29 180 top
PCB03  0.033U_0402_25V7K  [C_0402]  233.67 14.85 0 top
PCB04  0.1U_0402_25V6  [C_0402]  235.48 13.86 90 top
PCB05  0.1U_0402_25V6  [C_0402]  235.48 15.6 90 top
PCB08  1200P_0402_50V7K  [C_0402]  247.71 10.22 270 top
PCB09  1200P_0402_50V7K  [C_0402]  246.81 10.23 270 top
PCB10  10U_0603_25V6M  [C_0603-S3]  250.04 10.36 270 top
PCB11  10U_0603_25V6M  [C_0603-S3]  248.8 10.36 270 top
PCB12  0.1U_0402_25V6  [C_0402]  265.07 12.58 180 bottom
PCB14  1U_0402_25V6K  [C_0402]  240.86 9.81 180 bottom
PCB15  0.22U_0603_25V7K  [C_0603]  238.14 14.76 0 top
PCB16  0.1U_0402_25V6  [C_0402]  236.24 10.55 0 bottom
PCB17  0.47U_0402_25V6K  [C_0402]  243.48 11.53 180 top
PCB18  680P_0603_50V7K  [C_0603]  253.47 6.26 180 top
PCB19  10U_0603_25V6M  [C_0603]  270.17 10.34 90 bottom
PCB20  10U_0603_25V6M  [C_0603]  272.01 10.37 90 top
PCB22  0.1U_0402_25V6  [C_0402]  240.32 6.48 180 top
PCB23  0.1U_0402_25V6  [C_0402]  238.53 6.55 270 top
PCB24  0.1U_0402_25V6  [C_0402]  242.01 6.64 270 top
PCB26  560P_0402_50V7K  [C_0402]  234.55 6.73 180 top
PCB27  0.033U_0402_25V7K  [C_0402]  234.55 5.84 180 top
PCB29  1U_0402_16V6K  [C_0402]  243.14 9.74 90 top
PCB30  1U_0402_16V6K  [C_0402]  244.03 8.24 0 top
PCB31  2200P_0402_50V7K  [C_0402]  156.21 25.44 0 top
PCB32  2200P_0402_50V7K  [C_0402]  154.56 25.6 90 top
PCB33  10U_0603_25V6M  [C_0603]  273.65 10.37 90 top
PCB34  10U_0603_25V6M  [C_0603]  270.21 10.32 90 top
PCF1  22U_0603_6.3V6M  [C_0603]  174.56 99.32 135 bottom
PCF2  68P_0402_50V8J  [C_0402]  177.81 104.26 225 bottom
PCF3  22U_0603_6.3V6M  [C_0603]  180.35 98.03 135 bottom
PCF4  22U_0603_6.3V6M  [C_0603]  181.25 98.93 135 bottom
PCF5  .1U_0402_16V7K  [C_0402]  178.87 101.83 45 bottom
PCF6  680P_0402_50V7K  [C_0402]  174.85 98.05 45 bottom
PCG1  2200P_0402_50V7K  [C_0402]  111.94 92.35 90 top
PCG2  0.1U_0402_25V6  [C_0402]  110.62 92.34 90 top
PCG3  10U_0603_25V6M  [C_0603-S3]  108.54 90.96 90 bottom
PCG4  10U_0603_25V6M  [C_0603-S3]  115.27 92.99 90 bottom
PCG5  0.22U_0402_25V6K  [C_0402]  115.73 93.29 90 top
PCG6  2.2U_0402_6.3V6M  [C_0402]  119.79 96.37 180 top
PCG7  680P_0402_50V7K  [C_0402]  110.65 95.1 270 top
PCG55  330U_D1_2VY_R9M  [C_D2]  120.6 97.2 270 bottom
PCG56  220U_D1_2VY_R9M  [C_D2]  115.78 107.72 45 bottom
PCG57  22U_0603_6.3V6M  [C_0603]  141.88 101.69 180 top
PCG58  22U_0603_6.3V6M  [C_0603]  133.23 100.01 0 top
PCG59  22U_0603_6.3V6M  [C_0603]  138.15 92.42 0 top
PCG60  22U_0603_6.3V6M  [C_0603]  133.2 97.37 0 top
PCG61  22U_0603_6.3V6M  [C_0603]  137.03 93.63 180 top
PCG62  22U_0603_6.3V6M  [C_0603]  141.9 100.39 180 top
PCG63  22U_0603_6.3V6M  [C_0603]  133.21 101.31 0 top
PCG64  22U_0603_6.3V6M  [C_0603]  137.08 92.41 180 top
PCG65  22U_0603_6.3V6M  [C_0603]  133.18 98.67 0 top
PCG66  22U_0603_6.3V6M  [C_0603]  138.16 93.71 0 top
PCG67  22U_0603_6.3V6M  [C_0603]  137.03 100.36 180 top
PCG68  22U_0603_6.3V6M  [C_0603]  137.98 101.59 0 top
PCG69  22U_0603_6.3V6M  [C_0603]  133.16 93.59 0 top
PCG70  22U_0603_6.3V6M  [C_0603]  133.21 96.07 0 top
PCG71  22U_0603_6.3V6M  [C_0603]  137.03 101.58 180 top
PCG72  22U_0603_6.3V6M  [C_0603]  137.98 100.37 0 top
PCG73  22U_0603_6.3V6M  [C_0603]  133.18 92.39 0 top
PCG74  22U_0603_6.3V6M  [C_0603]  133.21 94.86 0 top
PCG75  1U_0201_6.3V6M  [C_0201]  136.42 94.84 90 top
PCG76  1U_0201_6.3V6M  [C_0201]  139.45 99.14 270 top
PCG77  1U_0201_6.3V6M  [C_0201]  137.01 99.11 270 top
PCG78  1U_0201_6.3V6M  [C_0201]  137.62 94.84 90 top
PCG79  1U_0201_6.3V6M  [C_0201]  138.25 99.14 270 top
PCG80  1U_0201_6.3V6M  [C_0201]  135.82 99.11 270 top
PCG81  1U_0201_6.3V6M  [C_0201]  135.81 94.84 90 top
PCG82  1U_0201_6.3V6M  [C_0201]  140.06 99.14 270 top
PCG83  1U_0201_6.3V6M  [C_0201]  137.62 99.11 270 top
PCG84  1U_0201_6.3V6M  [C_0201]  137.01 94.84 90 top
PCG85  1U_0201_6.3V6M  [C_0201]  138.86 99.14 270 top
PCG86  1U_0201_6.3V6M  [C_0201]  136.43 99.11 270 top
PCH1  2200P_0402_50V7K  [C_0402]  187.53 102 0 bottom
PCH2  680P_0402_50V7K  [C_0402]  181.06 111.66 45 top
PCH3  0.1U_0402_25V6  [C_0402]  187.53 103.02 0 bottom
PCH4  0.1U_0402_25V6  [C_0402]  188.36 104.94 180 bottom
PCH5  10U_0603_25V6M  [C_0603-S3]  186.28 99.82 180 bottom
PCH6  330P_0402_50V7K  [C_0402]  180.25 105.29 270 bottom
PCH7  22U_0603_6.3V6M  [C_0603]  179.41 113.82 45 bottom
PCH8  22U_0603_6.3V6M  [C_0603]  179.15 108.99 315 bottom
PCH9  22U_0603_6.3V6M  [C_0603]  177.63 110.77 135 bottom
PCH10  22U_0603_6.3V6M  [C_0603]  178.26 108.1 315 bottom
PCH11  22U_0603_6.3V6M  [C_0603]  176.74 109.88 135 bottom
PCH12  2.2U_0402_6.3V6M  [C_0402]  182.59 105.84 0 bottom
PCH13  0.1U_0402_25V6  [C_0402]  182.55 100 0 bottom
PCH14  1U_0402_16V6K  [C_0402]  181.48 106.16 180 bottom
PCM1  2200P_0402_50V7K  [C_0402]  91.61 39.08 180 top
PCM2  10U_0603_25V6M  [C_0603-S3]  92.18 38 180 top
PCM4  0.1U_0402_25V6  [C_0402]  89.82 30.99 270 bottom
PCM5  10U_0402_6.3V6M  [C_0402]  93.61 30.23 90 bottom
PCM6  10U_0402_6.3V6M  [C_0402]  95.06 27.72 0 bottom
PCM7  1U_0402_16V6K  [C_0402]  88.47 27.72 270 bottom
PCM8  22U_0603_6.3V6M  [C_0603]  88.33 41.42 180 bottom
PCM9  22U_0603_6.3V6M  [C_0603]  95.66 41.52 0 bottom
PCM10  22U_0603_6.3V6M  [C_0603]  95.66 41.52 0 top
PCM11  22U_0603_6.3V6M  [C_0603]  95.66 42.79 0 top
PCM12  22U_0603_6.3V6M  [C_0603]  88.33 40.15 180 bottom
PCM13  22U_0603_6.3V6M  [C_0603]  95.66 42.79 0 bottom
PCM14  680P_0402_50V7K  [C_0402]  94.68 30.69 90 top
PCM15  0.033U_0402_16V7K  [C_0402]  94.87 26.57 0 bottom
PCM16  1U_0402_16V6K  [C_0402]  88.49 25.97 270 bottom
PCM17  0.1U_0402_10V7K  [C_0402]  91.68 23.42 0 bottom
PCM18  0.1U_0402_10V7K  [C_0402]  93.54 23.5 270 bottom
PCP1  0.01U_0402_50V7K  [C_0402]  81.18 43.2 180 top
PCP2  10U_0603_25V6M  [C_0603-S3]  81.17 42.06 180 top
PCP3  1U_0201_6.3V6M  [C_0201]  80.42 36.05 270 top
PCP4  0.1U_0402_10V7K  [C_0402]  80.65 33.68 0 top
PCP5  10U_0603_25V6M  [C_0603-S3]  86.81 30.33 0 bottom
PCP6  10U_0603_25V6M  [C_0603-S3]  86.61 32.15 0 top
PCP7  680P_0402_50V7K  [C_0402]  86.12 34.99 180 top
PCP8  1000P_0402_50V7K  [C_0402]  85.03 32.12 90 top
PCP326  10U_0603_25V6M  [C_0603-S3]  86.65 32.15 0 bottom
PCP327  1U_0201_6.3V6M  [C_0201]  77.48 34.26 0 top
PCP328  1U_0201_6.3V6M  [C_0201]  77.49 34.85 0 top
PCP329  1U_0201_6.3V6M  [C_0201]  77.49 35.46 0 top
PCP330  1U_0201_6.3V6M  [C_0201]  79.24 36.05 270 top
PCP331  1U_0201_6.3V6M  [C_0201]  79.85 36.05 270 top
PCV1  0.1U_0402_25V6  [C_0402]  225.18 51.7 90 bottom
PCV2  0.1U_0402_25V6  [C_0402]  217.2 55.83 90 top
PCV3  2200P_0402_50V7K  [C_0402]  216.25 55.85 90 top
PCV4  10U_0603_25V6M  [C_0603-S3]  217.34 55.6 90 bottom
PCV5  10U_0603_25V6M  [C_0603-S3]  216.11 55.58 90 bottom
PCV6  100U_25V_NC_6.3X6  [C_6P3X6]  230.9 50.21 270 bottom
PCV7  100U_25V_NC_6.3X6  [C_6P3X6]  223.4 50.22 270 bottom
PCV8  680P_0402_50V7K  [C_0402]  204.83 58.82 270 top
PCV9  0.1U_0402_25V6  [C_0402]  225.15 57.91 270 top
PCV10  0.1U_0402_25V6  [C_0402]  230.6 52.68 180 bottom
PCV11  0.1U_0402_25V6  [C_0402]  209.27 55.99 90 top
PCV12  2200P_0402_50V7K  [C_0402]  208.37 55.99 90 top
PCV13  10U_0603_25V6M  [C_0603-S3]  208.24 55.87 90 bottom
PCV14  10U_0603_25V6M  [C_0603-S3]  209.46 55.87 90 bottom
PCV15  0.01U_0402_16V7K  [C_0402]  224.24 57.91 270 top
PCV16  4700P_0402_50V7K  [C_0402]  223.44 61.25 0 bottom
PCV17  0.1U_0402_25V6  [C_0402]  223.31 55.24 180 bottom
PCV18  1U_0603_25V6  [C_0603]  226.24 59.81 90 bottom
PCV19  680P_0402_50V7K  [C_0402]  192.78 56.22 0 bottom
PCV20  47P_0402_50V8J  [C_0402]  229.13 59.66 0 bottom
PCV21  0.1U_0402_25V6  [C_0402]  221.32 55.5 90 bottom
PCV22  0.1U_0402_25V6  [C_0402]  201.45 56.14 90 top
PCV23  2200P_0402_50V7K  [C_0402]  200.48 56.15 90 top
PCV24  10U_0603_25V6M  [C_0603-S3]  200.32 55.83 90 bottom
PCV25  10U_0603_25V6M  [C_0603-S3]  201.53 55.83 90 bottom
PCV26  1U_0201_6.3V6M  [C_0201]  221.25 60.08 270 bottom
PCV27  680P_0402_50V7K  [C_0402]  212.74 58.91 270 top
PCV28  2.2U_0402_16V6K  [C_0402]  227.82 51.41 0 bottom
PCV29  1U_0201_6.3V6M  [C_0201]  201.68 91.82 270 top
PCV30  1U_0201_6.3V6M  [C_0201]  201.68 93.74 270 top
PCV31  1U_0201_6.3V6M  [C_0201]  201.47 88.21 90 top
PCV32  1U_0201_6.3V6M  [C_0201]  206.29 81.07 0 top
PCV33  1U_0201_6.3V6M  [C_0201]  206.29 80.27 0 top
PCV34  1U_0201_6.3V6M  [C_0201]  207.77 77.62 0 top
PCV35  1U_0201_6.3V6M  [C_0201]  205.43 86.91 180 top
PCV36  1U_0201_6.3V6M  [C_0201]  201.62 86.19 270 top
PCV37  1U_0201_6.3V6M  [C_0201]  202.19 86.7 0 top
PCV38  1U_0201_6.3V6M  [C_0201]  209.36 72.97 0 bottom
PCV39  1U_0201_6.3V6M  [C_0201]  203.47 79.81 180 top
PCV40  1U_0201_6.3V6M  [C_0201]  199.24 76.59 90 top
PCV41  1U_0201_6.3V6M  [C_0201]  206.31 79.55 0 top
PCV42  4.7U_0402_6.3V6M  [C_0402]  207.48 86.9 180 top
PCV43  4.7U_0402_6.3V6M  [C_0402]  210.6 86.9 270 top
PCV44  4.7U_0402_6.3V6M  [C_0402]  208.94 85.25 90 top
PCV45  4.7U_0402_6.3V6M  [C_0402]  209.38 81.94 180 top
PCV46  4.7U_0402_6.3V6M  [C_0402]  203.74 80.79 180 top
PCV47  4.7U_0402_6.3V6M  [C_0402]  201.39 83.73 0 top
PCV48  4.7U_0402_6.3V6M  [C_0402]  202.04 77.52 270 top
PCV49  4.7U_0402_6.3V6M  [C_0402]  199.87 84.23 180 top
PCV50  4.7U_0402_6.3V6M  [C_0402]  201.93 78.53 90 top
PCV51  4.7U_0402_6.3V6M  [C_0402]  209.58 82.98 90 top
PCV52  4.7U_0402_6.3V6M  [C_0402]  208.18 82.9 90 top
PCV53  4.7U_0402_6.3V6M  [C_0402]  211.05 83.37 90 top
PCV54  4.7U_0402_6.3V6M  [C_0402]  206.17 82.19 0 top
PCV55  4.7U_0402_6.3V6M  [C_0402]  205.66 83.96 0 top
PCV56  4.7U_0402_6.3V6M  [C_0402]  205.1 85.43 0 top
PCV57  4.7U_0402_6.3V6M  [C_0402]  200.46 78.15 180 top
PCV58  330U_D1_2VM_R6M  [C_X]  199.66 65.89 270 top
PCV59  330U_D1_2VM_R6M  [C_X]  208.36 66.02 270 top
PCV60  330U_D1_2VM_R6M  [C_X]  191.04 67.8 270 bottom
PCV61  330U_D3_2.5VY_R6M  [C_X]  210.89 89.7 180 top
PCV62  4.7U_0402_6.3V6M  [C_0402]  207.16 93.45 90 top
PCV63  22U_0603_6.3V6M  [C_0603]  202.04 73.12 180 bottom
PCV64  22U_0603_6.3V6M  [C_0603]  197.72 71.93 0 bottom
PCV65  22U_0603_6.3V6M  [C_0603]  207.18 76.63 0 top
PCV66  22U_0603_6.3V6M  [C_0603]  203.43 73.12 0 bottom
PCV67  22U_0603_6.3V6M  [C_0603]  207.75 73.12 180 bottom
PCV68  22U_0603_6.3V6M  [C_0603]  197.75 76.44 90 top
PCV69  22U_0603_6.3V6M  [C_0603]  204.04 66 270 top
PCV70  22U_0603_6.3V6M  [C_0603]  209.12 70.71 0 bottom
PCV71  22U_0603_6.3V6M  [C_0603]  196.3 70.72 180 bottom
PCV72  22U_0603_6.3V6M  [C_0603]  205.1 92.9 90 top
PCV73  4.7U_0402_6.3V6M  [C_0402]  209.04 93.51 270 top
PCV74  10U_0402_6.3V6M  [C_0402]  209.56 72.14 0 bottom
PCV75  10U_0402_6.3V6M  [C_0402]  207.24 71.95 180 bottom
PCV76  10U_0402_6.3V6M  [C_0402]  207.24 70.76 180 bottom
PCV77  10U_0402_6.3V6M  [C_0402]  203.98 71.94 0 bottom
PCV78  10U_0402_6.3V6M  [C_0402]  203.98 70.74 0 bottom
PCV79  10U_0402_6.3V6M  [C_0402]  201.58 71.94 180 bottom
PCV80  10U_0402_6.3V6M  [C_0402]  201.58 70.74 180 bottom
PCV81  10U_0402_6.3V6M  [C_0402]  198.28 70.74 0 bottom
PCV82  10U_0402_6.3V6M  [C_0402]  195.86 71.79 180 bottom
PCV83  10U_0402_6.3V6M  [C_0402]  194.88 64.39 270 top
PCV84  10U_0402_6.3V6M  [C_0402]  196.02 76.49 90 top
PCV85  10U_0402_6.3V6M  [C_0402]  202.91 65.52 270 top
PCV86  10U_0402_6.3V6M  [C_0402]  202.61 90.36 270 top
PCV87  10U_0402_6.3V6M  [C_0402]  196.15 64.39 270 top
PCV88  10U_0402_6.3V6M  [C_0402]  214.98 64.65 270 top
PCV89  10U_0402_6.3V6M  [C_0402]  203.32 82.04 90 top
PCV90  10U_0402_6.3V6M  [C_0402]  203.44 93.36 270 top
PCV91  10U_0402_6.3V6M  [C_0402]  203.26 85.17 180 top
PCV92  1U_0201_6.3V6M  [C_0201]  222.39 60.06 270 bottom
PCV93  1U_0201_6.3V6M  [C_0201]  221.82 60.06 270 bottom
PCW1  0.01U_0402_16V7K  [C_0402]  241.44 56.97 180 bottom
PCW2  0.1U_0603_25V7K  [C_0603]  239.99 49.27 0 bottom
PCW3  1U_0201_6.3V6M  [C_0201]  242.51 50.49 270 bottom
PCW4  680P_0402_50V7K  [C_0402]  243.17 57.3 90 bottom
PCW5  0.1U_0402_16V7K  [C_0402]  238.7 53.1 90 bottom
PCW6  680P_0402_50V7K  [C_0402]  261.31 58.72 270 bottom
PCW7  2200P_0402_50V7K  [C_0402]  257.51 46.2 0 top
PCW8  0.1U_0402_25V6  [C_0402]  257.51 44.98 0 top
PCW9  10U_0603_25V6M  [C_0603-S3]  257.26 45 0 bottom
PCW10  10U_0603_25V6M  [C_0603-S3]  257.26 46.21 0 bottom
PCW11  390U_2.5V_ESR10M_6.3X6  [C_6P3X6]  247.9 63.98 270 bottom
PCW12  1U_0201_6.3V6M  [C_0201]  243.08 49.32 0 bottom
PCW13  1U_0201_6.3V6M  [C_0201]  243.09 49.91 0 bottom
PCW14  1U_0201_6.3V6M  [C_0201]  243.09 50.49 0 bottom
PCZ1  2200P_0402_50V7K  [C_0402]  173.64 126.52 180 bottom
PCZ2  0.01UF_0402_25V7K  [C_0402]  174.82 127.77 90 bottom
PCZ3  1U_0201_6.3V6M  [C_0201]  173.73 134.01 180 top
PCZ4  1000P_0402_50V7K  [C_0402]  175.42 125.63 180 bottom
PCZ5  1000P_0402_50V8-J  [C_0402]  173.93 127.77 90 bottom
PCZ6  470P_0402_50V8J  [C_0402]  170.95 130.01 0 top
PCZ7  1000P_0402_50V7K  [C_0402]  173.64 124.86 180 top
PCZ8  3300P_0402_25V7K  [C_0402]  171.86 129.12 180 top
PCZ9  1000P_0402_50V7K  [C_0402]  170.95 128.23 0 top
PCZ10  0.015U_0402_16V7K  [C_0402]  170.95 125.69 0 top
PCZ11  100P_0402_50V8J  [C_0402]  170.95 126.58 0 top
PCZ12  1000P_0402_50V7K  [C_0402]  174.58 123.77 90 bottom
PCZ13  2200P_0402_50V7K  [C_0402]  173.69 123.01 90 bottom
PCZ14  1000P_0402_50V7K  [C_0402]  173.31 134.44 90 bottom
PCZ15  2200P_0402_50V7K  [C_0402]  171.45 134.52 0 bottom
PCZ16  47P_0402_50V8J  [C_0402]  171.39 124.8 270 top
PCZ17  470P_0402_50V8J  [C_0402]  171.98 121.36 90 bottom
PCZ18  470P_0402_50V8J  [C_0402]  169.25 126.59 270 top
PCZ19  2200P_0402_50V7K  [C_0402]  171.53 121.93 90 top
PCZ20  470P_0402_50V8J  [C_0402]  169.83 135.41 180 bottom
PCZ21  47P_0402_50V8J  [C_0402]  168.94 134.39 180 top
PCZ22  2200P_0402_50V7K  [C_0402]  168.1 136.24 270 top
PCZ23  470P_0402_50V8J  [C_0402]  169.69 132.56 270 top
PCZ24  100P_0402_50V8J  [C_0402]  169.31 123.16 270 top
PCZ25  820PF_0402_50V7K  [C_0402]  170.2 122.25 90 top
PCZ26  0.22U_0402_16V7K  [C_0402]  167.09 126.59 270 top
PCZ27  82P_0402_50V8J  [C_0402]  167.16 134.39 180 top
PCZ28  330P_0402_50V7K  [C_0402]  167.16 135.41 180 top
PCZ29  0.22U_0402_16V7K  [C_0402]  166.83 132.56 270 top
PCZ30  0.1U_0402_25V6  [C_0402]  162.97 125.75 180 bottom
PCZ31  0.01U_0402_25V7K  [C_0402]  162.56 126.64 0 bottom
PCZ32  0.1U_0402_25V6  [C_0402]  163.48 132.23 180 bottom
PCZ33  1U_0402_16V6K  [C_0402]  165.1 127.98 0 top
PCZ34  0.022U_0402_25V7K  [C_0402]  168.62 123.09 180 bottom
PCZ35  0.022U_0402_25V7K  [C_0402]  166.02 134.26 180 bottom
PCZ36  0.022U_0402_25V7K  [C_0402]  166.84 123.09 180 bottom
PCZ37  0.022U_0402_25V7K  [C_0402]  165.07 123.09 180 bottom
PCZ38  0.022U_0402_25V7K  [C_0402]  163.29 123.09 180 bottom
PCZ39  2.2U_0402_6.3V6M  [C_0402]  154.13 136.12 270 bottom
PCZ40  2200P_0402_50V7K  [C_0402]  156.16 130.53 270 bottom
PCZ41  0.1U_0402_25V6  [C_0402]  155.28 130.53 270 bottom
PCZ42  10U_0603_25V6M  [C_0603-S3]  154.64 132.8 90 bottom
PCZ43  10U_0603_25V6M  [C_0603-S3]  155.91 132.8 90 bottom
PCZ44  100U_25V_NC_6.3X6  [C_6P3X6]  110.69 86.51 0 bottom
PCZ45  100U_25V_NC_6.3X6  [C_6P3X6]  123.09 130.51 270 bottom
PCZ46  0.22U_0402_25V6K  [C_0402]  150.58 133.7 270 bottom
PCZ47  680P_0402_50V7K  [C_0402]  148.04 125.25 90 top
PCZ48  2200P_0402_50V7K  [C_0402]  148.67 130.53 270 bottom
PCZ49  0.1U_0402_25V6  [C_0402]  147.78 130.53 270 bottom
PCZ50  10U_0603_25V6M  [C_0603-S3]  147.78 132.8 90 bottom
PCZ51  10U_0603_25V6M  [C_0603-S3]  149.05 132.8 90 bottom
PCZ52  0.22U_0402_25V6K  [C_0402]  142.96 133.7 270 bottom
PCZ53  2.2U_0402_6.3V6M  [C_0402]  146.51 136.12 270 bottom
PCZ54  680P_0402_50V7K  [C_0402]  142.83 126.26 135 top
PCZ55  2200P_0402_50V7K  [C_0402]  133.56 130.53 270 bottom
PCZ56  0.1U_0402_25V6  [C_0402]  132.67 130.53 270 bottom
PCZ57  10U_0603_25V6M  [C_0603-S3]  133.81 132.8 90 bottom
PCZ58  10U_0603_25V6M  [C_0603-S3]  132.54 132.8 90 bottom
PCZ59  0.22U_0402_25V6K  [C_0402]  135.34 133.7 270 bottom
PCZ60  2.2U_0402_6.3V6M  [C_0402]  131.53 136.12 270 bottom
PCZ61  680P_0402_50V7K  [C_0402]  140.21 128.67 0 bottom
PCZ62  2200P_0402_50V7K  [C_0402]  141.18 130.53 270 bottom
PCZ63  0.1U_0402_25V6  [C_0402]  140.29 130.53 270 bottom
PCZ64  10U_0603_25V6M  [C_0603-S3]  140.04 132.8 90 bottom
PCZ65  10U_0603_25V6M  [C_0603-S3]  141.31 132.8 90 bottom
PCZ66  0.22U_0402_25V6K  [C_0402]  127.97 133.7 270 bottom
PCZ67  2.2U_0402_6.3V6M  [C_0402]  138.89 136.12 270 bottom
PCZ68  680P_0402_50V7K  [C_0402]  128.17 128.45 270 top
PCZ173  330U_D3_2.5VY_R6M  [C_X]  150.64 97.37 0 top
PCZ174  330U_D1_2VY_R9M  [C_X]  149.94 117.42 90 top
PCZ175  22U_0603_6.3V6M  [C_0603]  155.89 101.66 0 top
PCZ176  22U_0603_6.3V6M  [C_0603]  154.88 100.36 180 top
PCZ177  22U_0603_6.3V6M  [C_0603]  151.04 101.66 0 top
PCZ178  22U_0603_6.3V6M  [C_0603]  155.81 92.39 0 top
PCZ179  22U_0603_6.3V6M  [C_0603]  143.02 92.48 0 top
PCZ180  22U_0603_6.3V6M  [C_0603]  146.16 101.76 0 top
PCZ181  22U_0603_6.3V6M  [C_0603]  149.9 100.47 180 top
PCZ182  22U_0603_6.3V6M  [C_0603]  150.03 92.41 180 top
PCZ183  22U_0603_6.3V6M  [C_0603]  151.04 92.42 0 top
PCZ184  22U_0603_6.3V6M  [C_0603]  145.2 100.52 180 top
PCZ185  22U_0603_6.3V6M  [C_0603]  145.2 101.76 180 top
PCZ186  22U_0603_6.3V6M  [C_0603]  155.89 100.37 0 top
PCZ187  22U_0603_6.3V6M  [C_0603]  154.88 101.66 180 top
PCZ188  22U_0603_6.3V6M  [C_0603]  151.04 100.37 0 top
PCZ189  22U_0603_6.3V6M  [C_0603]  145.81 92.37 0 top
PCZ190  22U_0603_6.3V6M  [C_0603]  146.16 100.49 0 top
PCZ191  22U_0603_6.3V6M  [C_0603]  149.9 101.74 180 top
PCZ192  22U_0603_6.3V6M  [C_0603]  159.73 92.24 180 top
PCZ193  22U_0603_6.3V6M  [C_0603]  154.78 92.41 180 top
PCZ217  1U_0201_6.3V6M  [C_0201]  143.24 94.19 0 top
PCZ218  1U_0201_6.3V6M  [C_0201]  142.16 98.03 180 top
PCZ219  1U_0201_6.3V6M  [C_0201]  143.22 95.36 0 top
PCZ220  1U_0201_6.3V6M  [C_0201]  143.24 97.67 0 top
PCZ221  1U_0201_6.3V6M  [C_0201]  143.22 95.92 0 top
PCZ222  1U_0201_6.3V6M  [C_0201]  143.24 98.23 0 top
PCZ223  1U_0201_6.3V6M  [C_0201]  143.24 93.61 0 top
PCZ224  1U_0201_6.3V6M  [C_0201]  143.23 94.78 0 top
PCZ225  1U_0201_6.3V6M  [C_0201]  142.13 95.01 180 top
PCZ226  1U_0201_6.3V6M  [C_0201]  142.18 93.84 180 top
PCZ227  1U_0201_6.3V6M  [C_0201]  156.58 103.67 180 top
PCZ228  1U_0201_6.3V6M  [C_0201]  154.82 103.06 0 top
PCZ229  1U_0201_6.3V6M  [C_0201]  154.2 103.64 180 top
PCZ230  1U_0201_6.3V6M  [C_0201]  157.24 103.11 0 top
PCZ231  1U_0201_6.3V6M  [C_0201]  142.14 94.42 180 top
PCZ232  1U_0201_6.3V6M  [C_0201]  142.19 93.25 180 top
PCZ233  1U_0201_6.3V6M  [C_0201]  156.58 103.08 180 top
PCZ234  1U_0201_6.3V6M  [C_0201]  154.82 103.64 0 top
PCZ235  1U_0201_6.3V6M  [C_0201]  154.2 103.06 180 top
PCZ236  1U_0201_6.3V6M  [C_0201]  157.24 103.69 0 top
PCZ237  1U_0201_6.3V6M  [C_0201]  143.24 97.09 0 top
PCZ238  1U_0201_6.3V6M  [C_0201]  143.24 99.4 0 top
PCZ239  1U_0201_6.3V6M  [C_0201]  143.24 96.51 0 top
PCZ240  1U_0201_6.3V6M  [C_0201]  143.24 98.82 0 top
PCZ241  1U_0201_6.3V6M  [C_0201]  149.34 103.11 180 top
PCZ242  1U_0201_6.3V6M  [C_0201]  142.16 98.59 180 top
PCZ243  1U_0201_6.3V6M  [C_0201]  144.54 103.67 180 top
PCZ244  1U_0201_6.3V6M  [C_0201]  145.17 103.08 0 top
PCZ245  1U_0201_6.3V6M  [C_0201]  142.75 103.11 0 top
PCZ246  1U_0201_6.3V6M  [C_0201]  144.54 103.11 180 top
PCZ247  1U_0201_6.3V6M  [C_0201]  145.17 103.64 0 top
PCZ248  1U_0201_6.3V6M  [C_0201]  142.15 96.23 180 top
PCZ249  1U_0201_6.3V6M  [C_0201]  149.95 103.08 0 top
PCZ250  1U_0201_6.3V6M  [C_0201]  142.16 97.42 180 top
PCZ251  1U_0201_6.3V6M  [C_0201]  152.31 103.06 0 top
PCZ252  1U_0201_6.3V6M  [C_0201]  146.96 103.67 180 top
PCZ253  1U_0201_6.3V6M  [C_0201]  146.96 103.11 180 top
PCZ254  1U_0201_6.3V6M  [C_0201]  147.56 103.08 0 top
PCZ255  1U_0201_6.3V6M  [C_0201]  151.71 103.08 180 top
PCZ256  1U_0201_6.3V6M  [C_0201]  142.76 103.67 0 top
PCZ257  1U_0201_6.3V6M  [C_0201]  147.56 103.64 0 top
PCZ258  1U_0201_6.3V6M  [C_0201]  149.34 103.67 180 top
PCZ259  1U_0201_6.3V6M  [C_0201]  142.13 99.2 180 top
PCZ260  1U_0201_6.3V6M  [C_0201]  142.15 95.62 180 top
PCZ261  1U_0201_6.3V6M  [C_0201]  149.95 103.67 0 top
PCZ262  1U_0201_6.3V6M  [C_0201]  142.16 96.81 180 top
PCZ263  1U_0201_6.3V6M  [C_0201]  152.31 103.64 0 top
PCZ264  1U_0201_6.3V6M  [C_0201]  151.71 103.67 180 top
PCZ265  10U_0402_6.3V6M  [C_0402]  145.93 97.44 180 top
PCZ266  10U_0402_6.3V6M  [C_0402]  147.19 95.39 0 top
PCZ267  10U_0402_6.3V6M  [C_0402]  155.9 118.7 0 top
PCZ268  10U_0402_6.3V6M  [C_0402]  140.42 119.64 90 top
PCZ269  10U_0402_6.3V6M  [C_0402]  144.86 119.64 90 top
PCZ270  10U_0402_6.3V6M  [C_0402]  142.19 119.64 90 top
PCZ271  10U_0402_6.3V6M  [C_0402]  145.93 93.58 180 top
PCZ272  10U_0402_6.3V6M  [C_0402]  145.93 98.38 180 top
PCZ273  10U_0402_6.3V6M  [C_0402]  147.19 94.45 0 top
PCZ274  10U_0402_6.3V6M  [C_0402]  157.7 90.64 0 top
PCZ275  10U_0402_6.3V6M  [C_0402]  151.71 94.42 0 top
PCZ276  10U_0402_6.3V6M  [C_0402]  146.64 119.64 90 top
PCZ277  10U_0402_6.3V6M  [C_0402]  156.08 94.42 0 top
PCZ278  10U_0402_6.3V6M  [C_0402]  145.95 99.3 180 top
PCZ279  10U_0402_6.3V6M  [C_0402]  147.17 93.53 0 top
PCZ280  10U_0402_6.3V6M  [C_0402]  159.48 103.53 180 top
PCZ281  10U_0402_6.3V6M  [C_0402]  151.69 93.51 0 top
PCZ282  10U_0402_6.3V6M  [C_0402]  145.75 119.64 90 top
PCZ283  10U_0402_6.3V6M  [C_0402]  156.06 93.51 0 top
PCZ284  10U_0402_6.3V6M  [C_0402]  145.88 96.5 180 top
PCZ285  10U_0402_6.3V6M  [C_0402]  147.24 96.33 0 top
PCZ286  10U_0402_6.3V6M  [C_0402]  160.67 91.89 90 top
PCZ287  10U_0402_6.3V6M  [C_0402]  156.29 119.64 90 top
PCZ288  10U_0402_6.3V6M  [C_0402]  150.22 93.51 180 top
PCZ289  10U_0402_6.3V6M  [C_0402]  152.74 119.64 90 top
PCZ290  10U_0402_6.3V6M  [C_0402]  153.62 119.64 90 top
PCZ291  10U_0402_6.3V6M  [C_0402]  154.82 93.58 180 top
PCZ292  10U_0402_6.3V6M  [C_0402]  143.97 119.64 90 top
PCZ293  10U_0402_6.3V6M  [C_0402]  141.76 92.42 180 top
PCZ294  10U_0402_6.3V6M  [C_0402]  145.9 94.52 180 top
PCZ295  10U_0402_6.3V6M  [C_0402]  147.22 98.31 0 top
PCZ296  10U_0402_6.3V6M  [C_0402]  154.79 94.52 180 top
PCZ297  10U_0402_6.3V6M  [C_0402]  156.88 90.64 180 top
PCZ298  10U_0402_6.3V6M  [C_0402]  150.27 94.47 180 top
PCZ299  10U_0402_6.3V6M  [C_0402]  154.51 119.64 90 top
PCZ300  10U_0402_6.3V6M  [C_0402]  147.22 99.25 0 top
PCZ301  10U_0402_6.3V6M  [C_0402]  145.9 95.51 180 top
PCZ302  10U_0402_6.3V6M  [C_0402]  147.22 97.32 0 top
PCZ303  10U_0402_6.3V6M  [C_0402]  143.08 119.64 90 top
PCZ304  10U_0402_6.3V6M  [C_0402]  155.9 117.75 0 top
PCZ305  10U_0402_6.3V6M  [C_0402]  141.31 119.64 90 top
PCZ306  10U_0402_6.3V6M  [C_0402]  155.4 119.64 90 top
PD1  -  [L30ESD24VC3-2_SOT23-3]  281.89 40.82 180 top
PD2  -  [L30ESD24VC3-2_SOT23-3]  285.45 27.05 180 bottom
PD3  LUDZS3.6BT1G_SOD323-2  [LUDZS3P6BT1G_SOD323-2]  285.73 38.76 0 top
PDB01  -  [BAS40CW_SOT323-3]  236.19 9.3 0 bottom
PDB02  -  [BAS40CW_SOT323-3]  229.89 12.56 180 bottom
PDB03  30MA_30V_0.5UA_0.4V_SOD323-2  [D_SOD323-2]  245.37 11.84 270 top
PDM1  -  [RB751V-40_SOD323-2]  94.47 20.94 180 bottom
PDM2  -  [RB751V-40_SOD323-2]  88.96 20.93 0 bottom
PDM3  30MA_30V_0.5UA_0.4V_SOD323-2  [D_SOD323-2]  87.16 27.72 180 bottom
PDP1  -  [SX34_SMA2]  87.33 34.57 90 bottom
PH1  100K_0402_1%_B25/50 4250K  [R_0402]  135.52 97.28 0 top
PHZ1  220K_0402_5%_B25/50 4700K  [R_0402]  117.71 103.83 90 bottom
PHZ2  100K_0402_1%_B25/50 4250K  [R_0402]  162.39 118.97 270 bottom
PHZ3  220K_0402_5%_B25/50 4700K  [R_0402]  156.42 116.05 270 bottom
PHZ4  220K_0402_5%_B25/50 4700K  [R_0402]  156.11 131.85 180 bottom
PHZ5  220K_0402_5%_B25/50 4700K  [R_0402]  115.14 96.67 270 bottom
PJ301  -  [JUMP_43X79]  244.72 31.25 0 bottom
PJ302  -  [JUMP_43X118]  245.86 19.04 90 top
PJ303  -  [JUMP_43X39]  250.82 26.71 270 bottom
PJ304  -  [JUMP_43X79]  82.13 7.53 270 top
PJ305  -  [JUMP_43X118]  68.29 15.39 0 bottom
PJ306  -  [JUMP_43X39]  79.52 11.73 90 bottom
PJ1001  -  [JUMP_43X79]  239.81 31.8 270 bottom
PJ1002  -  [JUMP_43X118]  229.79 21.06 180 top
PJ1801  -  [JUMP_43X79]  270.08 19.85 180 bottom
PJ1802  -  [JUMP_43X79]  260.27 24.96 90 bottom
PJ2501  JUMP_43X39  [JUMP_43X39_0805]  104.42 20.08 0 top
PJ2502  JUMP_43X39  [JUMP_43X39_0805]  113.05 20.36 180 top
PJB1  -  [JUMP_43X118]  251.36 14.46 270 top
PJF1  -  [JUMP_43X79]  172.04 103.02 315 bottom
PJF2  -  [JUMP_43X79]  181.12 95.98 315 bottom
PJH1  -  [JUMP_43X79]  186.19 97.02 90 bottom
PJH2  -  [JUMP_43X118]  175.09 108.35 225 bottom
PJM1  -  [JUMP_43X79]  91.37 41.75 270 top
PJM2  -  [JUMP_43X118]  96.28 38.26 0 top
PJM3  JUMP_43X39  [JUMP_43X39_0805]  95.46 30.3 0 bottom
PJP1  ACES_59012-0120N-005  [ACES_59012-0120N-005_12P-T]  290.95 34.35 0 bottom
PJPB1  ACES_50279-01201-001  [ACES_50279-01201-001_12P-T]  288.25 7.9 90 bottom
PJPP2  -  [JUMP_43X39]  83.34 43.2 180 top
PJV1  -  [JUMP_43X118]  227.77 44.34 90 top
PJW1  -  [JUMP_43X118]  246.99 63.34 45 top
PJW2  -  [JUMP_43X118]  250.74 59.58 45 top
PJW5  -  [JUMP_43X79]  251.22 44.65 270 bottom
PJZ1  -  [JUMP_43X118]  104.73 75.76 270 top
PL11  5A Z80 20M 0805  [TAI-T_HCB2012KF-121T50_2P]  277.85 32.4 180 top
PL12  5A Z80 20M 0805  [TAI-T_HCB2012KF-121T50_2P]  277.85 34.69 180 top
PL13  5A Z80 20M 0805  [TAI-T_HCB2012KF-121T50_2P]  274 6.66 180 bottom
PL14  5A Z80 20M 0805  [TAI-T_HCB2012KF-121T50_2P]  274 8.56 180 bottom
PL301  1.5UH_9A_20%_7X7X3_M  [L_7X7X3_M]  245.82 25.57 270 bottom
PL302  1.5UH_9A_20%_7X7X3_M  [L_7X7X3_M]  71.89 8.99 180 bottom
PL1001  1UH_11A_20%_7X7X3_M  [L_7X7X3_M_2P]  230.26 25.2 270 bottom
PL1801  1UH_MHCD252012A-1R0M-A8S_3A_20%  [CHILI_MHCD252012A-1R0M-A8S_2P]  261.56 19.56 180 bottom
PL2501  1UH_MHCD252012A-1R0M-A8S_3A_20%  [CHILI_MHCD252012A-1R0M-A8S_2P]  110.98 17.9 0 top
PLA1  0.47UH_NA__12.2A_20%  [L_5X5X3_M]  158.96 121.58 270 bottom
PLB02  4.7UH_5.5A _20%_7X7X3_M  [L_7X7X3_M_2P]  256.53 9.19 0 bottom
PLF1  1UH_MHCD252012A-1R0M-A8S_3A_20%  [CHILI_MHCD252012A-1R0M-A8S_2P]  177.63 97.9 315 bottom
PLG1  0.15UH_MMD06BZER15MEM_22A_20%  [MAG_MMD06BZER15MEM_4P]  110.19 100.86 0 bottom
PLH1  1UH_6.6A_20%_5X5X3_M  [L_5X5X3_M_2P]  184.15 108.99 135 bottom
PLM1  1UH_11A_20%_7X7X3_M  [L_7X7X3_M_2P]  92.66 40.13 270 bottom
PLP1  2.2UH_TMPC0412HP-2R2MG-Z03_3.3A_20%  [TAI-T_TMPC0412HP-2R2MG-Z03_2P]  81.04 39.01 0 top
PLV1  0.24UH_22A_+-20%_ 7X7X3_M  [L_7X7X3_M]  204.87 62.16 90 bottom
PLV2  0.24UH_22A_+-20%_ 7X7X3_M  [L_7X7X3_M]  197.17 62.16 90 bottom
PLV3  0.24UH_22A_+-20%_ 7X7X3_M  [L_7X7X3_M]  212.61 62.16 90 bottom
PLW1  0.82UH_PCMC063T-R82MN_13A_20%  [CYNTE_PCMC063T-R82MN_2P]  254.9 56.22 90 bottom
PLZ1  0.15UH_NA__35A_20%  [L_7X7X3_M]  152.1 123.32 270 bottom
PLZ2  0.15UH_NA__35A_20%  [L_7X7X3_M]  144.48 123.32 270 bottom
PLZ3  0.15UH_NA__35A_20%  [L_7X7X3_M]  136.86 123.32 270 bottom
PLZ4  0.15UH_NA__35A_20%  [L_7X7X3_M]  129.24 123.32 270 bottom
PQ1  -  [2N7002KW_SOT323-3]  275.53 11.9 0 top
PQ2  -  [2N7002KDW_SOT363-6]  273.09 16.42 270 top
PQA1  -  [AONH36334_DFN3X3A8-10]  156.73 124.4 90 bottom
PQB01  AONS32304_1N_DFN56-8-5  [Q_N_DFN56-8-5]  267.76 34.85 270 top
PQB02  -  [2N7002KW_SOT323-3]  262.43 37.71 270 top
PQB03  -  [AON7380_DFN3X3-8-5]  265.71 32.83 90 top
PQB04  -  [AON7380_DFN3X3-8-5]  265.48 9.22 90 bottom
PQB05  -  [AONH36334_DFN3X3A8-10]  253.35 11.18 180 top
PQG1  -  [AOE6930_DFN5X6E8-10]  113.87 90.83 180 bottom
PQM1  -  [AONH36334_DFN3X3A8-10]  93.51 33.19 90 top
PQV1  -  [AOE6930_DFN5X6E8-10]  206.75 54.04 180 bottom
PQV2  -  [AOE6930_DFN5X6E8-10]  198.78 54 180 bottom
PQV3  -  [AOE6930_DFN5X6E8-10]  214.68 54.04 180 bottom
PQW1  -  [AON6380_DFN5X6-8-5]  252.68 53.4 0 bottom
PQW2  AON6314_N_DFN56-8-5  [Q_N_DFN56-8-5]  262.54 47.86 180 bottom
PQW3  -  [2N7002KW_SOT323-3]  237.03 55.16 0 bottom
PQZ1  -  [AOE6930_DFN5X6E8-10]  150.2 131.42 0 bottom
PQZ2  -  [AOE6930_DFN5X6E8-10]  142.58 131.42 0 bottom
PQZ3  -  [AOE6930_DFN5X6E8-10]  134.96 131.42 0 bottom
PQZ4  -  [AOE6930_DFN5X6E8-10]  127.59 131.42 0 bottom
PR1  0_0402_5%  [R0402_0OHM]  282.14 28.15 0 bottom
PR2  100K_0402_5%  [R_0402]  281.37 28.16 270 bottom
PR3  10K_0402_1%  [R_0402]  284.43 38.3 90 top
PR4  750_0402_1%  [R_0402]  283.02 28.97 90 bottom
PR5  10K_0402_1%  [R_0402]  286.21 40.08 90 top
PR6  100K_0402_5%  [R_0402]  282.24 28.96 90 bottom
PR9  16.2K_0402_1%  [R_0402]  132.34 17.93 0 top
PR10  5.9K_0402_1%  [R_0402]  132 24.34 180 top
PR13  10K_0402_1%  [R_0402]  131.99 25.24 180 top
PR14  100_0402_5%  [R_0402]  284.18 11.83 180 top
PR15  100_0402_5%  [R_0402]  284.18 12.72 180 top
PR16  100K_0402_5%  [R_0402]  284.18 15.43 180 top
PR17  100_0402_5%  [R_0402]  284.18 14.63 180 top
PR18  470K_0402_5%  [R_0402]  273.44 18.44 0 top
PR19  1.8K_0805_1%  [R_0805]  269.99 15.39 0 top
PR20  1M_0402_5%  [R_0402]  274.35 17.55 180 top
PR21  0_0402_5%  [R0402_0OHM]  284.18 13.49 180 top
PR22  3.6K_0402_1%  [R_0402]  275.05 9.26 90 top
PR24  3.6K_0402_1%  [R_0402]  275.85 9.26 90 top
PR301  0_0402_5%  [R0402_0OHM]  246.62 27.94 180 bottom
PR302  4.7_1206_5%  [R_1206]  250.65 24.41 270 bottom
