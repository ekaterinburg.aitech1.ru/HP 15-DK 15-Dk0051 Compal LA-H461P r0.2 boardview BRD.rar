# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_PME#: length 117.3
  TOP w0.127: v2(146.41,26.18) 146.44,26.15 R5178.2 ; v1(60.77,26.17) 60.23,25.63 v2(60.23,25.62) ; RL15.2 54.64,17.7 v2(55.73,16.61)
  IN1 w0.127: v2(60.23,25.62) 60.43,25.42 60.43,22.72 61.32,21.82 61.32,18.76 59.7,17.13 56.25,17.13 v2(55.73,16.61)
  IN2 w0.127: v2(60.23,25.62) 60.23,28.67 60.72,29.16 66.2,29.16 67.56,27.8 81.79,27.8 82.51,27.08 82.51,26.1 83.95,24.67 87.82,24.67 91.01,21.48 94.47,21.48 95.05,22.06 97.56,22.06 99.19,23.69 99.19,24.72 v2(99.51,25.04)
  BOTTOM w0.127: v2(55.73,16.61) 55.51,16.83 UL1.21 ; v2(99.51,25.04) 99.93,25.04 100.29,24.67 100.78,24.67 103.13,27.03 107.41,27.03 108.45,25.99 114.22,25.99 114.48,26.26 117.32,26.26 118.52,25.07 121.65,25.07 122.35,25.77 123.83,25.77 124.05,25.98 131.24,25.98 132.02,25.21 145.62,25.21 146.41,26 v2(146.41,26.18)
EC_PME#_EC_R: length 1.9
  TOP w0.127: R5178.1 145.85,25.35 145.24,24.73 UK1.76
EC_RST#: length 5.9
  TOP w0.127: UK1.37 152.5,11.42 153.2,10.72 RK7.1 154.19,10.72 v3(155.16,11.7) 155.16,12.43 CK5.2
EC_RTC_RST: length 44.1
  TOP w0.127: v2(179.26,11.41) 179.68,11.82 180.66,11.82 181.02,12.18 181.02,12.89 181.58,13.45 182.3,13.45 182.49,13.25 QC11.2 182.49,12.05 RC393.1 183.29,11.96 184.1,12.77 RH252.2 ; UK1.29 148.44,9.74 v2(148.52,9.83)
  IN2 w0.127: v2(179.26,11.41) 178.56,12.11 173.96,12.11 171.34,14.72 154.84,14.72 150.34,10.23 148.92,10.23 v2(148.52,9.83)
EC_SCI#: length 82.2
  TOP w0.127: RK14.2 144.84,7.36 UK1.20 144.84,9.34 144.56,9.62 144.56,10.91 146.81,13.17 147.49,13.17 147.77,13.45 v2(147.77,13.85)
  IN3 w0.127: v2(202.33,22.19) 202.66,22.19 203.05,22.58 203.05,24.65 202.31,25.39 199.42,25.39 199.15,25.11 199.15,22.03 198.45,21.32 198.45,17.72 197.71,16.97 197.71,16.02 197.03,15.34 194.86,15.34 193.35,13.82 190.39,13.82 190.05,14.17 180.67,14.17 179.79,15.05 179.79,16.02 178.5,17.31 153.85,17.31 151.99,15.45 151.31,15.45 150.23,14.37 148.23,14.37 147.77,13.91 v2(147.77,13.85)
  BOTTOM w0.127: v1(148.19,14.53) 147.77,14.11 v2(147.77,13.85) ; v2(202.33,22.19) 202.24,22.19 UH1.AU26
EC_SMB_CK: length 1.7
  TOP w0.127: PUB01.4 235.1,10.63 235.03,10.7 PRB16.2
EC_SMB_CK1: length 269.1
  TOP w0.127: v2(145.82,26.18) 145.82,26.16 RH232.1 144.84,25.17 UK1.77 ; PR14.2 282.69,11.83 v2(282.68,11.82) 281.85,11.82 280.8,12.87 280.8,16.27 280.92,16.39 280.92,23.57 280,24.5 280,26.46 284.58,31.04 292,31.04 292.87,31.91 292.87,34.76 291.5,36.13 290.51,36.13 290.32,35.95 289.87,35.95 v2(289.44,36.38) ; R5800.1 177.26,42.88 v1(177.59,42.56) 177.83,42.31 179.72,42.31 180.43,41.6 181.09,41.6 v2(181.32,41.37) ; PRB16.1 233.31,10.7 v2(233.05,10.97)
  IN2 w0.127: v2(181.32,41.37) 181.47,41.22 185.07,41.22 190.32,46.47 193.48,46.47 194.47,47.46 213.87,47.46 222.36,38.97 232.03,38.97 232.74,39.69 233.7,39.69 234.41,38.98 236.11,38.98 236.47,39.34 239.41,39.34 239.9,38.85 244.54,38.85 245.7,40.02 250.65,40.02 251.83,38.83 259.77,38.83 259.82,38.89 271.04,38.89 271.52,38.41 276.38,38.41 277.66,39.69 279.71,39.69 280.33,39.06 284.1,39.06 286.5,36.67 289.15,36.67 v2(289.44,36.38)
  IN3 w0.127: v2(145.82,26.18) 145.82,26.35 146.13,26.66 149.43,26.66 150.06,27.29 160.6,27.29 161.18,27.87 166.62,27.87 167.19,27.3 168.87,27.3 169.53,27.96 171.44,27.96 171.84,27.57 173.05,27.57 175.48,29.99 175.48,31.19 177.79,33.51 178.24,33.51 178.51,33.24 180.12,33.24 181,34.12 181.34,34.12 181.79,34.57 181.79,40.9 v2(181.32,41.37) ; v2(282.68,11.82) 281.83,10.97 277.51,10.97 274.72,13.75 274.72,14.56 274.22,15.07 265.4,15.07 264.1,13.76 257.43,13.76 256.59,14.6 246.31,14.6 245.39,13.68 240.71,13.68 240.66,13.73 239.58,13.73 238.33,12.49 234.99,12.49 233.6,11.09 233.18,11.09 v2(233.05,10.97)
EC_SMB_CK2: length 553.6
  TOP w0.127: Q7.6 178.36,121.86 177.58,121.86 177.05,122.38 v2(176.87,122.38) ; RH234.1 143.14,25.58 144.04,24.69 UK1.79 144.04,21.55 v2(144.48,21.11) ; RU54.2 55.25,41.44 57.45,43.65 v2(57.45,46.94) ; QC9.6 226.82,11.87 v2(227.45,11.87)
  IN1 w0.127: v2(57.45,46.94) 57.45,46.83 58.25,46.03 67.73,46.03 68.65,45.12 74.17,45.12 77.37,48.32 80.14,48.32 81.53,49.71 86.08,49.71 87.25,50.87 v2(88.98,50.87) 89.75,50.87 94.09,46.53 94.09,44.02 96.73,41.38 96.73,32.22 101.61,27.33 103.44,27.33 104.57,26.21 104.57,25.51 v2(105.11,24.97) ; v2(283.35,43.55) 283.35,43.58 280.04,46.89 266.06,46.89 264.05,44.87 259.06,44.87 257.76,46.18 251.27,46.18 250.09,47.36 246.31,47.36 245.54,48.13 240.56,48.13 238.68,50.01 238.68,51.75 237.06,53.37 236.8,53.37 235.42,54.75 232.62,54.75 232.11,55.25 232.11,57.14 230.91,58.35 229.73,58.35 229.27,57.89 224.55,57.89 223.77,58.67 223.77,59.02 222.95,59.85 222.5,59.85 221.57,60.78 221.22,60.78 220.12,61.88 219.57,61.88 v2(219.48,61.78) ; v2(128.88,95.65) 128.88,95.53 128.55,95.2 127.08,95.2 126.55,94.66 123.26,94.66 119.85,91.26 118.94,91.26 115.18,87.5 113.98,87.5 112.67,86.19 111.69,85.2 arc(110.09,82.81) 109.53,79.99 109.53,75.73 108.95,75.15 108.95,74.66 v2(108.95,74.24)
  IN2 w0.127: v2(167.72,7.39) 168.53,7.39 171.29,4.63 223.32,4.63 226.92,8.23 226.92,10.48 227.45,11.01 v2(227.45,11.87) 228.12,12.54 239.31,12.54 239.54,12.31 240.86,12.31 241.92,13.37 252.13,13.37 252.49,13 265.32,13 266.2,13.89 273.57,13.89 274.34,13.11 279.11,13.11 280.58,14.58 280.58,18.25 279.86,18.97 279.86,22.31 v2(280.5,22.94) ; v2(88.98,50.87) 89.76,50.09 94.06,50.09 95.61,51.63 95.61,56.83 95.06,57.38 95.06,60.99 95.54,61.65 95.56,61.67 98.09,65.11 99.32,67.55 101.06,70.85 104.45,74.24 v2(108.95,74.24)
  IN3 w0.127: v2(128.88,95.65) 129.37,95.17 131.81,95.17 134.14,97.51 138.66,97.51 140.64,95.53 141.18,95.53 142.04,94.66 142.04,93.52 142.5,93.06 159.13,93.06 160.04,93.97 160.04,95.34 160.58,95.88 160.58,97.31 162.77,99.49 162.77,100.23 163.24,100.7 169.14,100.7 169.65,101.21 169.65,102.29 168.47,103.47 168.47,103.68 167.54,104.61 167.54,105.24 167.02,105.76 164.56,105.76 163.89,106.43 163.89,108.38 164.57,109.07 165.13,109.07 171.61,115.54 171.61,117.71 175.94,122.04 176.52,122.04 v2(176.87,122.38)
  BOTTOM w0.127: v2(219.48,61.78) 220.09,62.39 220.09,63.36 219.63,63.82 QG2.3 ; v2(280.5,22.94) 280.84,23.29 280.84,24.6 280.05,25.39 280.05,28.51 278.45,30.11 278.45,36.78 283.35,41.69 v2(283.35,43.55) ; v2(105.11,24.97) 105.27,24.97 106.25,23.99 109.59,23.99 110.86,22.73 113.48,22.73 114.66,21.56 124.08,21.56 124.96,20.68 132.2,20.68 132.63,20.25 134.07,20.25 134.33,20.51 138.41,20.51 138.67,20.25 140.8,20.25 141.24,20.69 141.95,20.69 142.82,21.55 144.03,21.55 v2(144.48,21.11) 144.48,18.8 141.8,16.12 141.8,10.88 144.25,8.42 149.68,8.42 151.51,10.25 163.85,10.25 164.13,9.97 166.28,9.97 167.72,8.54 v2(167.72,7.39)
EC_SMB_CK2_PD: length 2.3
  TOP w0.127: RU54.1 52.28,41.68 51.29,41.68 50.91,42.06 UU4.32
EC_SMB_DA: length 1.9
  TOP w0.127: PRB15.2 234.83,11.46 235.26,11.03 PUB01.3
EC_SMB_DA1: length 268.6
  TOP w0.127: v2(290.07,36.37) 290.1,36.4 291.61,36.4 293.13,34.87 293.13,31.8 292.11,30.78 284.69,30.78 280.26,26.35 280.26,24.6 281.18,23.68 v1(281.18,16.14) 281.06,16.02 281.06,12.98 281.73,12.31 v2(282.37,12.31) 282.78,12.72 PR15.2 ; PRB15.1 233.53,11.57 v2(233.04,11.57) ; v2(143.28,26.18) 143.88,25.58 RH233.1 144.44,25.06 UK1.78 ; v2(181.72,41.79) 181.72,42.22 180.77,43.18 R5799.1
  IN2 w0.127: v2(181.72,41.79) 182.03,41.49 184.96,41.49 190.21,46.74 193.37,46.74 194.36,47.73 213.98,47.73 222.38,39.33 231.58,39.33 232.61,40.36 237.6,40.36 238.2,39.76 239.36,39.76 240.01,39.12 244.42,39.12 245.59,40.29 250.76,40.29 251.95,39.1 259.65,39.1 259.71,39.16 271.16,39.16 271.64,38.68 276.27,38.68 277.55,39.96 279.82,39.96 280.44,39.33 284.22,39.33 286.61,36.94 289.51,36.94 v2(290.07,36.37)
  IN3 w0.127: v2(282.37,12.31) 281.29,11.23 277.62,11.23 274.99,13.87 274.99,14.67 274.33,15.34 265.29,15.34 263.99,14.03 257.54,14.03 256.7,14.87 246.2,14.87 245.28,13.95 240.82,13.95 240.77,14 239.47,14 238.22,12.76 234.88,12.76 234.51,12.38 233.49,11.36 233.25,11.36 v2(233.04,11.57) ; v2(181.72,41.79) 181.15,41.79 180.85,41.5 180.85,41 181.52,40.34 181.52,34.68 181.23,34.39 180.89,34.39 180.01,33.51 178.62,33.51 178.36,33.78 177.68,33.78 175.21,31.31 175.21,30.1 172.94,27.83 171.95,27.83 171.56,28.23 169.42,28.23 168.76,27.57 167.3,27.57 166.73,28.14 161.07,28.14 160.49,27.56 149.95,27.56 149.31,26.93 144.54,26.93 143.79,26.18 v2(143.28,26.18)
EC_SMB_DA2: length 567.9
  TOP w0.127: Q7.3 181.44,123.62 182,123.07 182,121.73 181.62,121.36 177.42,121.36 177.01,121.77 v2(176.88,121.77) ; RU55.2 53.53,42.21 53.86,41.88 55.07,41.88 56.85,43.66 v2(56.85,46.95) ; v2(229.22,12.97) 229.13,13.07 QC9.3 ; v2(143.85,21.11) 143.64,21.31 UK1.80 143.64,24.76 143.29,25.11 142.27,25.11 141.89,25.49 RH235.1
  IN1 w0.127: v2(219.91,61.39) 220.95,60.35 221.39,60.35 222.32,59.42 222.77,59.42 223.34,58.84 223.34,58.49 224.37,57.45 229.45,57.45 229.91,57.91 230.73,57.91 231.68,56.96 231.68,55.07 232.44,54.31 235.24,54.31 236.63,52.93 236.88,52.93 238.24,51.57 238.24,49.83 240.38,47.69 245.37,47.69 246.13,46.93 249.91,46.93 251.09,45.75 257.58,45.75 258.88,44.44 264.23,44.44 266.24,46.46 279.86,46.46 v2(282.77,43.55) ; v2(108.95,73.66) 108.93,73.66 108.39,74.2 108.39,75.2 109.1,75.91 109.1,79.99 arc(109.69,82.98) 111.38,85.51 113.8,87.93 115,87.93 122.17,95.1 125.67,95.1 126.2,95.63 v2(128.25,95.63) ; v2(104.4,25.06) 104.01,25.45 104.01,26.16 103.26,26.9 101.43,26.9 96.3,32.04 96.3,41.2 93.66,43.84 93.66,46.35 89.58,50.43 v2(88.39,50.43) 87.42,50.43 86.26,49.27 81.72,49.27 80.32,47.88 77.55,47.88 74.35,44.69 68.47,44.69 67.55,45.6 58.07,45.6 56.85,46.82 v2(56.85,46.95)
  IN2 w0.127: v2(155.43,4.86) 155.67,5.1 155.67,8.79 157.36,10.48 167.02,10.48 170.02,7.48 170.02,6.52 171.47,5.07 223.14,5.07 226.48,8.41 226.48,10.66 226.95,11.12 226.95,11.98 227.94,12.97 v2(229.22,12.97) 237.08,12.97 237.9,13.8 252.57,13.8 252.94,13.44 264.97,13.44 266.05,14.52 273.54,14.52 274.52,13.55 278.94,13.55 280.15,14.76 280.15,18.07 279.43,18.79 279.43,22.64 v2(279.9,23.11) ; v2(108.95,73.66) 104.48,73.66 101.41,70.59 99.71,67.35 98.46,64.88 96.25,61.87 95.91,61.41 95.89,61.39 95.49,60.85 95.49,57.55 96.04,57.01 96.04,51.45 94.24,49.66 89.17,49.66 v2(88.39,50.43)
  IN3 w0.127: v2(128.25,95.63) 129.14,94.74 131.98,94.74 134.32,97.08 138.48,97.08 140.47,95.1 141,95.1 141.61,94.48 141.61,93.34 142.32,92.63 159.31,92.63 160.47,93.79 160.47,95.16 161.02,95.7 161.02,97.13 163.2,99.31 163.2,100.05 163.42,100.26 169.32,100.26 170.08,101.03 170.08,102.47 168.9,103.65 168.9,103.86 167.97,104.79 167.97,105.42 167.2,106.19 164.74,106.19 164.32,106.61 164.32,108.2 164.75,108.63 165.31,108.63 172.04,115.36 172.04,117.53 176.03,121.52 176.63,121.52 v2(176.88,121.77)
  BOTTOM w0.127: QG2.6 220.81,62.52 220.52,62.23 220.52,62 v2(219.91,61.39) ; v2(279.9,23.11) 280.4,23.61 280.4,24.43 279.62,25.21 279.62,28.33 278.02,29.93 278.02,36.96 282.77,41.71 v2(282.77,43.55) ; v2(104.4,25.06) 105.36,24.1 105.53,24.1 106.07,23.56 109.41,23.56 110.68,22.3 113.3,22.3 114.48,21.13 123.9,21.13 124.78,20.24 132.02,20.24 132.9,19.37 137.75,19.37 138.19,19.81 140.98,19.81 141.42,20.25 142.13,20.25 142.98,21.11 v2(143.85,21.11) 144.05,20.9 144.05,18.98 141.37,16.3 141.37,10.7 142.45,9.61 144.07,7.99 149.86,7.99 151.61,9.74 154.22,9.74 155.66,8.3 155.66,5.09 v2(155.43,4.86)
EC_SMB_DA2_PD: length 2.3
  TOP w0.127: RU55.1 52.42,42.11 51.34,42.11 50.99,42.46 UU4.33
EC_SPICLK: length 116.7
  TOP w0.127: v2(116.87,24.45) v1(116.87,22.67) 116.87,19.01 115.79,17.93 115.79,13.54 117.34,11.99 123.11,11.99 126.93,8.16 126.93,6.5 127.43,6 129.97,6 131.18,7.21 131.18,8.13 CC144.1 RC369.2
  BOTTOM w0.127: v2(116.87,24.45) 117.86,23.47 125.2,23.47 125.23,23.44 134.85,23.44 135.14,23.15 137.41,23.15 137.87,23.61 147.24,23.61 147.84,24.22 162.83,24.22 164.25,25.64 165.75,25.64 167.36,27.25 169.58,27.25 170.43,28.1 170.43,28.81 172.19,30.57 172.53,30.57 174.49,32.52 174.49,41.42 177.74,44.68 180.22,44.68 180.8,45.26 180.8,46.86 RH243.2
EC_SPICLK_R: length 3.9
  TOP w0.127: RC369.1 134.04,8.46 v1(134.36,8.77) 134.5,8.91 134.5,10.36 134.76,10.62 UK1.126
EC_SPICS#: length 92.4
  TOP w0.127: v2(139.87,18.13) 139.78,18.23 139.78,18.93 139.96,19.11 140.61,19.11 141.26,18.46 141.26,17.29 140.01,16.04 140.01,14.28 137.01,11.28 137.01,10.21 136.62,9.82 136.48,9.82 UK1.128
  IN3 w0.127: v2(139.87,18.13) 139.86,18.12 139.86,18.02 137.98,16.14 136.48,16.14 135.97,16.65 135.97,17.99 135.22,18.74 135.22,23.03 136.5,24.31 149.89,24.31 151.52,25.94 160.71,25.94 161.16,25.49 162.54,25.49 162.78,25.25 163.5,25.25 164.19,25.94 166.9,25.94 167.17,25.67 170.8,25.67 172,26.86 173.69,26.86 177.71,30.88 178.37,30.88 181.18,33.69 181.52,33.69 182.22,34.39 182.22,42.99 181.98,43.23 181.98,44.41 v2(183.22,45.65)
  BOTTOM w0.127: v2(183.22,45.65) 184.6,45.65 RH242.2
EC_VCCST_PG: length 14.7
  IN1 w0.127: v2(163.68,91.16) 164.33,90.51 164.84,90.51 165.55,89.8 167.55,89.8 168.17,89.18 169.75,89.18 174.22,84.71 v2(174.31,84.71)
  BOTTOM w0.127: v2(174.31,84.71) 174.32,84.71 RC21.2 ; UC1.H13 v2(163.68,91.16)
EC_VCCST_PG_R: length 101.2
  TOP w0.127: UK1.68 148.44,23.02 148.59,22.86 v2(148.59,22.42)
  IN2 w0.127: v2(175.56,84.1) 175.56,83.84 175.79,83.62 175.79,81.54 180.08,77.25 180.08,72.9 175.89,68.72 175.89,60.79 176.74,59.95 176.74,50.85 176.42,50.54 v2(176.42,42.75)
  BOTTOM w0.127: v2(148.59,22.42) 149,22.83 163.49,22.83 164.88,24.23 166.3,24.23 167.94,25.86 172.59,25.86 175.68,28.95 175.68,31.21 176.4,31.93 176.4,34.95 176.86,35.42 179.72,35.42 181.89,37.59 181.89,40.21 179.79,42.31 176.86,42.31 v2(176.42,42.75) ; RC20.1 CC156.2 RC21.1 175.56,84.23 v2(175.56,84.1)
EC_VCIN1_AC_BYPASS: length 167.9
  TOP w0.127: DG2.1 220.04,64.84 RG393.1 219.39,64.19 RG200.1 219.59,63.42 219.59,62.92 220.59,61.91 220.59,61.21 222.46,59.35 224.58,59.35 225.12,59.89 229.17,59.89 232.25,56.81 232.25,54.77 232.58,54.44 232.58,52.67 231.57,51.67 231.57,49.62 234.37,46.82 v2(234.37,46.26) ; v2(176.17,6.54) 174.84,7.88 173.75,7.88 172.48,9.15 171.31,9.15 162.18,18.28 162.18,19.97 158.68,23.47 154.94,23.47 154.65,23.77 153.68,23.77 v1(152.8,22.89) 152.14,22.22 UK1.64
  IN3 w0.127: v2(234.37,46.26) 234.08,46.26 233.95,46.13 233.95,41.56 226.32,33.92 226.32,31.3 222.7,27.68 222.7,19.7 v2(223.83,18.57)
  BOTTOM w0.127: v2(176.17,6.54) 176.17,6.91 176.73,7.47 180.58,7.47 180.59,7.47 181.14,7.47 181.36,7.25 200.15,7.25 200.69,7.78 202.19,7.78 203.02,6.95 219.75,6.95 222.04,9.23 222.04,13.45 222.22,13.64 222.22,17.94 222.85,18.57 v2(223.83,18.57) 224.25,18.98 225.28,18.98 226.29,17.97 226.29,15.46 226.94,14.8 231.16,14.8 PRB43.1
ECAGND: length 152.4
  TOP w0.254: PH1.2 v2(136.44,96.64) ; UK1.69 148.04,24.85 148.2,25.02 148.43,25.02 148.58,25.17 148.58,25.58 148.74,25.74 LK2.2 149.43,25.66 150.24,25.66 CK3.2 150.25,25.73 150.02,25.96 150.02,26.83 149.83,27.02 138.34,27.02 v1(138.27,26.95) 137.2,26.95 137.13,27.02 135.57,27.02 v2(135.37,26.81)
  IN1 w0.254: v2(117.93,27.8) 117.93,27.89 117.53,28.29 117.37,28.29 117.01,28.65 102.16,28.65 98.04,32.76 98.04,41.93 95.41,44.56 95.41,46.77 96.54,47.91 96.54,52.33 99.49,55.28 99.49,63.64 105.2,69.34 105.2,73.24 108.6,76.65 108.6,79.99 arc(109.24,83.17) 111.03,85.86 113.6,88.43 114.8,88.43 122.65,96.28 123.07,96.28 124.37,97.58 128.62,97.58 129.22,96.97 132.69,96.97 133.89,95.78 135.39,95.78 136.25,96.64 v2(136.44,96.64)
  BOTTOM w0.254: v2(135.37,26.81) 135.03,27.14 132.18,27.14 131.86,27.47 123.43,27.47 123.22,27.25 118.25,27.25 117.93,27.57 v2(117.93,27.8)
EDP_AUXN: length 197.3
  IN1 w0.135: v2(73.15,26.2) 73.3,26.05 73.3,25.58 73.94,24.94 84.42,24.94 85.77,23.59 88.51,23.59 90.99,21.11 95.07,21.11 95.74,21.79 96.38,21.79 97.18,20.99 100.02,20.99 100.31,21.28 111.41,21.28 112.1,21.97 115.4,21.97 117.59,24.16 122.75,24.16 123.32,24.73 128.53,24.73 129.52,25.71 135.59,25.71 137.2,27.33 151.45,27.33 151.65,27.12 160.22,27.12 160.89,27.8 166.67,27.8 167.25,27.23 168.44,27.23 173.55,32.33 173.55,32.98 175.14,34.57 175.14,34.98 175.49,35.33 175.49,41.34 175.74,41.59 175.74,42.72 176.87,43.85 176.87,47.6 177.63,48.36 178.08,48.36 179.87,50.15 179.87,53.5 183.75,57.38 183.75,59.53 185.64,61.42 185.64,73.76 186.15,74.27 186.15,80.12 185.46,80.81 185.46,83.57 172.72,96.31 172.72,98.91 172.38,99.25 172.38,99.57 170,101.95 169.7,101.95 169.32,102.33 169.01,102.33 v2(168.86,102.47)
  BOTTOM w0.076: UC1.B26 167.21,101.06 166.94,101.06 166.9,101.02 166.9,100.88 167.09,100.68 168.04,100.68 168.25,100.9 168.25,102.09 168.43,102.26 168.65,102.26 v2(168.86,102.47)
  BOTTOM w0.127: CV8.1 73.24,26.63 73.24,26.29 v2(73.15,26.2)
EDP_AUXN_C: length 3.2
  BOTTOM w0.127: CV8.2 72.94,28.5 72.94,28.78 73.31,29.14 73.73,29.14 74.15,29.56 74.15,29.77 74.05,29.87 JEDP1.27
EDP_AUXP: length 197.2
  IN1 w0.135: v2(168.86,101.89) 168.86,102 168.92,102.05 169.21,102.05 169.58,101.67 169.88,101.67 170.17,101.39 170.17,101.18 170.45,100.9 170.66,100.9 170.94,100.61 170.94,100.41 171.23,100.12 171.44,100.12 172.1,99.46 172.1,99.14 172.44,98.79 172.44,98.39 172.3,98.24 172.3,97.84 172.44,97.7 172.44,97.29 172.3,97.15 172.3,96.74 172.44,96.6 172.44,96.2 172.85,95.78 172.85,95.58 173.14,95.29 173.34,95.29 173.63,95.01 173.63,94.8 173.92,94.52 174.12,94.52 174.41,94.23 174.41,94.03 174.69,93.74 174.9,93.74 175.18,93.46 175.18,93.25 175.47,92.97 175.67,92.97 175.96,92.68 175.96,92.48 176.24,92.19 176.45,92.19 176.73,91.9 176.73,91.7 177.02,91.41 177.22,91.41 177.51,91.13 177.51,90.92 177.8,90.64 178,90.64 185.18,83.46 185.18,80.7 185.87,80 185.87,74.38 185.37,73.88 185.37,61.54 183.47,59.64 183.47,57.5 179.59,53.62 179.59,50.26 177.97,48.64 177.51,48.64 176.59,47.71 176.59,43.96 175.46,42.84 175.46,41.7 175.21,41.45 175.21,35.45 174.86,35.1 174.86,34.68 173.27,33.09 173.27,32.45 168.33,27.51 167.36,27.51 166.79,28.08 160.78,28.08 160.1,27.4 151.77,27.4 151.57,27.61 137.09,27.61 135.47,25.99 129.4,25.99 128.42,25.01 123.2,25.01 122.64,24.44 117.48,24.44 115.28,22.25 111.99,22.25 111.3,21.56 100.19,21.56 99.9,21.27 97.3,21.27 96.5,22.06 95.62,22.06 94.95,21.39 91.11,21.39 88.62,23.87 85.88,23.87 84.54,25.22 74.06,25.22 73.58,25.69 73.58,26.05 v2(73.74,26.2)
  BOTTOM w0.076: v2(168.86,101.89) 168.86,102.08 168.83,102.11 168.49,102.11 168.41,102.03 168.41,100.84 168.1,100.53 167.03,100.53 166.74,100.81 166.74,100.88 UC1.C26
  BOTTOM w0.127: CV7.1 73.3,27.05 73.3,26.93 73.49,26.73 73.49,26.45 v2(73.74,26.2)
EDP_AUXP_C: length 3.2
  BOTTOM w0.127: CV7.2 73.2,28.46 73.2,28.67 73.41,28.88 73.84,28.88 74.41,29.45 74.41,29.74 74.55,29.88 JEDP1.28
EDP_DISP_UTIL: length 3.8
  BOTTOM w0.135: TC1.1 170.61,106.97 168.82,106.97 168.03,106.18 UC1.A33
EDP_HPD: length 160.4
  IN2 w0.127: v2(99.05,21.82) 99.35,22.12 108.89,22.12 112.93,18.08 116.92,18.08 117.93,19.1 121.34,19.1 121.46,19.22 123.34,19.22 124.15,20.03 130.31,20.03 130.55,20.27 131.68,20.27 132.66,19.3 137.07,19.3 137.87,20.1 140.85,20.1 141.41,20.66 146.18,20.66 146.69,21.17 151.11,21.17 152.65,22.71 160.54,22.71 161.16,22.09 175.48,22.09 179.68,26.29 180.24,26.29 182.79,28.85 184.83,28.85 186.16,27.52 187.36,27.52 189.47,29.63 194.92,29.63 195.76,28.79 195.76,27.62 196.03,27.35 199.22,27.35 199.26,27.31 200.19,27.31 200.51,27.63 203.92,27.63 204.31,27.24 206.14,27.24 207.49,28.6 209.65,28.6 210.04,28.98 v2(210.04,29)
  BOTTOM w0.102: UH1.AN6 211.63,25.04 211.63,25.36 211.56,25.53 210.76,26.33 209.99,26.33 209.39,26.94 209.39,27.88 210.04,28.53 v2(210.04,29)
  BOTTOM w0.127: v2(99.05,21.82) 96.73,19.5 87.51,19.5 83.99,23.02 77.15,23.02 v1(76.13,24.04) 75.29,24.87 RV7.1 74.7,24.87 73.8,25.78 72.89,25.78 72.27,26.4 72.27,26.63 71.84,27.06 RV6.1
EDP_HPD_PANEL: length 2.4
  BOTTOM w0.127: RV6.2 v1(71.84,29.1) 71.55,29.4 JEDP1.22
EDP_TXN0: length 202.6
  IN1 w0.135: v2(88.17,21.2) 88.17,21.39 88.32,21.53 88.53,21.53 91.05,19.01 111.32,19.01 112.73,20.42 115.89,20.42 118.16,22.7 126.64,22.7 127.13,23.19 131.75,23.19 132.78,24.23 136.26,24.23 137.43,25.4 168.67,25.4 174.99,31.71 174.99,32.38 176.57,33.97 176.57,34.39 176.92,34.74 176.92,39.23 177.74,40.04 177.74,41.91 178.05,42.22 178.05,42.84 182.26,47.05 182.26,49.19 181.91,49.54 181.91,50.32 182.11,50.52 182.11,53.62 185.31,56.82 185.31,59 187.08,60.77 187.08,72.74 187.61,73.27 187.61,84.07 186.54,85.14 185.93,85.14 174.7,96.37 174.7,100.18 171.38,103.5 170.24,103.5 169.12,104.62 165.48,104.62 165.1,104.24 165.1,103.91 v2(164.97,103.78)
  BOTTOM w0.076: UC1.E29 v2(164.97,103.78)
  BOTTOM w0.127: CV10.1 74.67,27 74.67,26.21 77.36,23.52 84.24,23.52 86.83,20.94 87.72,20.94 87.98,21.2 v2(88.17,21.2)
EDP_TXN0_C: length 2.6
  BOTTOM w0.127: CV10.2 74.74,28.47 74.74,28.94 75.17,29.38 75.17,29.74 75.05,29.86 JEDP1.29
EDP_TXN1: length 188.6
  IN1 w0.076: 165.83,101.04 165.77,101.04 165.61,101.2 165.61,102.2 v2(165.62,102.21)
  IN1 w0.135: v2(76.39,26.43) 76.51,26.31 76.51,25.99 76.84,25.66 77.9,25.66 79.2,26.95 84.55,26.95 86.42,25.08 89.05,25.08 90.8,23.33 94.56,23.33 96.07,24.84 96.87,24.84 97.06,25.03 97.73,25.03 99.3,23.46 113.02,23.46 115.24,25.68 119.01,25.68 119.88,26.55 128.26,26.55 128.89,27.18 131.82,27.18 133.13,28.49 134.82,28.49 135.57,29.24 168.39,29.24 170.83,31.68 170.83,32.31 172.8,34.28 172.8,36.7 173.64,37.54 173.64,42.77 175.34,44.47 175.34,48.15 176.06,48.87 176.06,50.25 177.43,51.63 177.43,53.21 182.13,57.9 182.13,60.02 184.21,62.1 184.21,78.66 183.22,79.65 183.22,82.05 181.97,83.3 181.97,84.62 170.96,95.63 170.96,98.63 169.75,99.83 167.04,99.83 165.83,101.04
  BOTTOM w0.076: UC1.E28 v2(165.62,102.21)
  BOTTOM w0.127: CV12.1 76.55,26.94 76.55,26.59 v2(76.39,26.43)
EDP_TXN1_C: length 2.6
  BOTTOM w0.127: JEDP1.31 76.05,29.81 76.17,29.68 76.17,29.14 76.57,28.75 76.57,28.49 CV12.2
EDP_TXN2: length 193.3
  IN1 w0.135: v2(167.57,103.78) 167.7,103.65 169.07,103.65 170,102.73 170.52,102.73 173.59,99.66 173.59,96.46 186.19,83.87 186.19,81.1 186.88,80.41 186.88,73.68 186.36,73.17 186.36,61.07 184.53,59.23 184.53,57.05 181.39,53.92 181.39,50.96 180.73,50.29 180.73,49.6 181.53,48.79 181.53,47.34 177.14,42.95 177.14,42.47 177.01,42.34 177.01,40.33 176.21,39.53 176.21,35.04 175.85,34.69 175.85,34.27 174.27,32.68 174.27,32.03 168.55,26.31 167.14,26.31 166.37,27.08 161.34,27.08 160.61,26.35 151.31,26.35 151.05,26.61 137.57,26.61 135.96,24.99 132.38,24.99 131.34,23.96 126.68,23.96 126.15,23.42 117.87,23.42 115.59,21.14 112.43,21.14 111.02,19.73 91.35,19.73 88.71,22.38 87.52,22.38 v2(87.4,22.26)
  BOTTOM w0.076: UC1.B29 v2(167.57,103.78)
  BOTTOM w0.127: v2(87.4,22.26) 87.24,22.42 86.58,22.42 84.67,24.33 79.77,24.33 78.29,25.8 78.29,27.02 CV14.1
EDP_TXN2_C: length 3.3
  BOTTOM w0.127: CV14.2 78.39,28.49 78.39,28.59 78.28,28.7 77.7,28.7 77.16,29.24 77.16,29.72 77.05,29.82 JEDP1.33
EDP_TXN3: length 184
  IN1 w0.076: v2(167.57,102.21) 167.81,101.97 167.86,101.97 168.83,101 168.91,101 168.92,100.98
  IN1 w0.135: v2(80.12,26.43) 80.27,26.27 80.27,25.97 80.57,25.67 84.76,25.67 86.12,24.31 88.81,24.31 90.6,22.52 94.79,22.52 95.67,23.39 98.02,23.39 98.67,22.74 99.59,22.74 100.3,22.03 111.15,22.03 111.8,22.69 113.26,22.69 115.54,24.96 122.54,24.96 123.02,25.44 128.17,25.44 129.18,26.45 134.13,26.45 136.2,28.52 168.7,28.52 171.6,31.42 171.6,32.05 173.52,33.97 173.52,34.86 174.11,35.46 174.11,37 174.77,37.65 174.77,41.73 175.02,41.98 175.02,43.02 176.09,44.09 176.09,47.87 178.26,50.03 178.26,52.94 182.99,57.67 182.99,59.81 184.93,61.75 184.93,74.56 185.38,75.01 185.38,79.85 184.67,80.55 184.67,83.14 171.84,95.97 171.84,98.76 170.04,100.56 169.34,100.56 168.92,100.98
  BOTTOM w0.076: UC1.B28 v2(167.57,102.21)
  BOTTOM w0.127: CV16.1 80.27,26.94 80.27,26.59 v2(80.12,26.43)
EDP_TXN3_C: length 4.1
  BOTTOM w0.127: JEDP1.35 78.05,29.83 78.17,29.7 78.17,29.54 78.46,29.26 78.86,29.26 79.29,28.83 80.19,28.83 80.27,28.75 80.27,28.47 CV16.2
EDP_TXP0: length 202.7
  IN1 w0.135: v2(87.67,21.7) 87.81,21.55 87.94,21.55 88.2,21.81 88.65,21.81 91.17,19.29 111.2,19.29 112.61,20.7 115.77,20.7 118.05,22.98 126.53,22.98 127.02,23.47 131.63,23.47 132.67,24.51 136.14,24.51 137.31,25.68 168.56,25.68 174.71,31.83 174.71,32.5 176.29,34.09 176.29,34.5 176.64,34.85 176.64,39.35 177.46,40.16 177.46,42.02 177.77,42.33 177.77,42.95 181.98,47.16 181.98,49.08 181.63,49.42 181.63,50.43 181.83,50.63 181.83,53.74 185.03,56.94 185.03,59.11 186.8,60.89 186.8,72.85 187.33,73.38 187.33,83.95 186.43,84.86 185.81,84.86 174.42,96.25 174.42,97.87 174.27,98.02 174.27,98.42 174.42,98.57 174.42,98.97 174.27,99.12 174.27,99.52 174.42,99.66 174.42,100.07 173.59,100.9 173.39,100.9 173.1,101.18 173.1,101.39 172.82,101.67 172.61,101.67 172.32,101.96 172.32,102.16 172.04,102.45 171.83,102.45 171.55,102.73 171.55,102.94 171.26,103.22 170.12,103.22 169.01,104.34 168.41,104.34 168.27,104.2 167.87,104.2 167.72,104.34 166.91,104.34 166.77,104.2 166.36,104.2 166.22,104.34 165.6,104.34 165.38,104.13 165.38,103.88 165.49,103.78 v2(165.62,103.78)
  BOTTOM w0.076: UC1.D29 165.96,103.44 v2(165.62,103.78)
  BOTTOM w0.127: CV9.1 75.01,27.25 74.93,27.17 74.93,26.32 77.47,23.78 v4(81.74,23.78) 84.35,23.78 85.34,22.79 85.55,22.79 85.83,22.5 85.83,22.29 86.12,22.01 86.32,22.01 86.61,21.72 86.61,21.52 86.94,21.19 87.61,21.19 87.79,21.37 87.79,21.58 v2(87.67,21.7)
EDP_TXP0_C: length 2.7
  BOTTOM w0.127: JEDP1.30 75.55,29.88 75.43,29.76 75.43,29.27 74.99,28.83 74.99,28.48 CV9.2
EDP_TXP1: length 188.7
  IN1 w0.076: 165.65,100.85 165.65,100.87 165.64,100.87 165.64,100.94 165.45,101.13 165.45,101.82 165.36,101.91 164.99,101.91 164.88,102.02 164.88,102.11 v2(164.97,102.21)
  IN1 w0.135: 165.65,100.85 165.63,100.84 165.92,100.56 165.92,100.35 166.21,100.07 166.41,100.07 166.93,99.55 167.66,99.55 167.8,99.4 168.2,99.4 168.35,99.55 169.64,99.55 170.68,98.51 170.68,98.11 170.53,97.96 170.53,97.56 170.68,97.41 170.68,97.01 170.53,96.86 170.53,96.46 170.68,96.32 170.68,95.52 181.69,84.51 181.69,83.19 182.94,81.94 182.94,79.54 183.93,78.55 183.93,62.22 181.85,60.14 181.85,58.02 177.15,53.32 177.15,51.74 175.78,50.37 175.78,48.98 175.06,48.27 175.06,44.59 173.36,42.89 173.36,37.66 172.52,36.82 172.52,34.39 170.56,32.43 170.56,31.8 168.28,29.52 135.46,29.52 134.71,28.77 133.02,28.77 131.7,27.46 128.77,27.46 128.14,26.83 119.76,26.83 118.89,25.96 115.13,25.96 112.9,23.74 99.42,23.74 97.85,25.31 96.94,25.31 96.75,25.11 95.95,25.11 94.45,23.61 90.92,23.61 89.17,25.36 86.54,25.36 84.66,27.23 79.08,27.23 77.78,25.93 76.96,25.93 76.79,26.1 76.79,26.24 v2(76.98,26.43)
  BOTTOM w0.076: v2(164.97,102.21) 164.66,102.52 UC1.F28
  BOTTOM w0.127: v2(76.98,26.43) 76.81,26.6 76.81,26.93 CV11.1
EDP_TXP1_C: length 2.6
  BOTTOM w0.127: CV11.2 76.82,28.47 76.82,28.86 76.43,29.25 76.43,29.7 76.55,29.82 JEDP1.32
EDP_TXP2: length 193.3
  IN1 w0.135: v2(167.57,102.99) 167.57,103.26 167.68,103.37 168.96,103.37 169.88,102.45 170.4,102.45 170.69,102.16 170.69,101.96 170.98,101.67 171.18,101.67 171.47,101.38 171.47,101.18 171.75,100.89 171.96,100.89 172.24,100.61 172.24,100.4 172.53,100.12 172.73,100.12 173.31,99.54 173.31,99.14 173.16,98.99 173.16,98.59 173.31,98.44 173.31,96.35 185.91,83.75 185.91,80.99 186.6,80.3 186.6,73.8 186.08,73.28 186.08,61.19 184.25,59.35 184.25,57.17 181.11,54.04 181.11,51.08 180.45,50.41 180.45,49.48 181.25,48.68 181.25,47.46 176.86,43.06 176.86,42.58 176.73,42.45 176.73,40.45 175.93,39.64 175.93,35.15 175.57,34.8 175.57,34.38 173.99,32.8 173.99,32.15 168.43,26.59 167.26,26.59 166.49,27.36 161.23,27.36 160.49,26.63 151.43,26.63 151.17,26.89 137.46,26.89 135.84,25.27 132.26,25.27 131.23,24.24 126.57,24.24 126.03,23.7 117.75,23.7 115.47,21.42 112.31,21.42 110.9,20.01 91.47,20.01 88.82,22.66 87.55,22.66 87.4,22.8 v2(87.4,22.97)
  BOTTOM w0.076: UC1.A29 167.91,103.33 v2(167.57,102.99)
  BOTTOM w0.127: CV13.1 78.65,27.25 78.54,27.15 78.54,25.91 79.87,24.58 84.77,24.58 86.68,22.67 87.3,22.67 87.4,22.78 v2(87.4,22.97)
EDP_TXP2_C: length 3.3
  BOTTOM w0.127: JEDP1.34 77.55,29.84 77.42,29.71 77.42,29.35 77.81,28.96 78.38,28.96 78.64,28.7 78.64,28.47 CV13.2
EDP_TXP3: length 184
  IN1 w0.076: 168.72,100.79 168.71,100.8 168.71,100.88 167.79,101.8 167.41,101.8 167,102.21 v2(166.92,102.21)
  IN1 w0.135: 168.72,100.79 169.22,100.29 169.92,100.29 171.56,98.65 171.56,98.24 171.42,98.1 171.42,97.69 171.56,97.55 171.56,97.15 171.42,97 171.42,96.6 171.56,96.45 171.56,95.85 171.97,95.44 171.97,95.24 172.26,94.95 172.46,94.95 172.75,94.67 172.75,94.46 173.04,94.18 173.24,94.18 173.53,93.89 173.53,93.69 173.81,93.4 174.02,93.4 184.39,83.02 184.39,80.43 185.1,79.73 185.1,75.13 184.65,74.68 184.65,61.86 182.71,59.92 182.71,57.79 177.98,53.06 177.98,50.15 175.81,47.98 175.81,44.21 174.74,43.13 174.74,42.1 174.49,41.85 174.49,37.77 173.83,37.11 173.83,35.57 173.24,34.98 173.24,34.08 171.32,32.16 171.32,31.54 168.58,28.8 136.08,28.8 134.01,26.73 129.06,26.73 128.05,25.72 122.9,25.72 122.42,25.24 115.42,25.24 113.15,22.97 111.69,22.97 111.03,22.31 100.42,22.31 99.7,23.02 98.79,23.02 98.14,23.67 95.55,23.67 94.68,22.8 90.72,22.8 88.92,24.59 86.23,24.59 84.87,25.95 80.68,25.95 80.55,26.08 80.55,26.27 v2(80.7,26.43)
  BOTTOM w0.076: v2(166.92,102.21) 166.61,102.52 UC1.C28
  BOTTOM w0.127: CV15.1 80.53,26.93 80.53,26.6 v2(80.7,26.43)
EDP_TXP3_C: length 4.1
  BOTTOM w0.127: CV15.2 80.53,28.49 80.53,28.85 80.3,29.08 v4(79.79,29.08) 79.4,29.08 78.96,29.52 78.56,29.52 78.43,29.65 78.43,29.73 78.55,29.85 JEDP1.36
EN_1.0V_VCCSTG: length 2.8
  TOP w0.127: RC373.2 179.81,107.81 180.32,108.32 v3(180.32,108.68)
  TOP w0.254: UC5.4 179.19,106.92 RC373.2
EN_1.0V_VCCSTU: length 3
  TOP w0.127: v1(252.09,36.87) RC370.2
  TOP w0.203: UC4.3 253.91,38.05 253.45,37.59 253.45,37.24 RC370.2
EN_1.8V: length 5.1
  BOTTOM w0.127: PR1805.1 263.68,22.49 v1(263.76,22.41)
  BOTTOM w0.254: PU1801.7 262.56,20.82 262.51,20.87 262.51,22.06 262.68,22.24 PR1805.1 262.68,23.39 PC1805.1 PR1804.2
EN_1.8VS: length 3.1
  TOP w0.127: v3(256.21,37.12) 255.9,36.8 RC371.2
  TOP w0.203: UC4.5 254.71,38.11 255.07,37.75 RC371.2
EN_1V05: length 4.9
  BOTTOM w0.254: PU1001.11 238.72,25.22 238.9,25.03 239.63,25.03 v2(240.07,25.47) 240.3,25.69 PC1001.1 240.77,25.66 PR1005.1 240.77,24.12 240.79,24.09 PR1003.2
EN_2.5V: length 6
  TOP w0.127: PR2501.2 106.53,14.02 v1(106.53,12.7)
  TOP w0.254: PR2501.2 107.42,14.51 107.42,14.51 PR2502.2 108.64,14.51 PR2503.1 109.06,14.51 109.08,14.49 PC2502.1 109.49,14.98 109.47,15.01 PU2501.1
EN_3VS_5VS: length 6.7
  TOP w0.203: U10.3 268.08,42.48 268.11,42.45 270.04,42.45 v3(270.2,42.62) 270.2,43.4 269.98,43.62 R5253.2 269.85,43.93 268.81,43.93 268.16,43.28 U10.5
EN_INVPWR: length 4.6
  TOP w0.127: v3(79.38,33.93) 79.38,33.2 PRP2.2 PRP3.1 PCP4.1 80.65,33.89 PUP1.3
EN_VCCIOP: length 4.2
  BOTTOM w0.127: PRH5.2 182.55,98.32 PRH7.1 PCH13.1 182.64,100.09 v2(182.64,101.27) 182.55,101.36 182.55,101.9 182.72,102.07 PUH1.11
ENLDO_3V5V: length 209.1
  IN2 w0.127: v2(77.47,15.82) 77.91,16.25 98.74,16.25 101.91,13.09 103.62,13.09 104.53,13.99 108.69,13.99 110.22,12.47 119.51,12.47 119.62,12.58 125.11,12.58 125.95,13.42 126.97,13.42 127.54,13.99 131.97,13.99 133.07,12.89 135.81,12.89 135.94,12.77 145.2,12.77 145.79,13.36 150.76,13.36 151.87,14.47 152.3,14.47 154.42,16.59 168.27,16.59 169.2,17.52 181.32,17.52 182.63,16.2 182.63,14.74 183.39,13.98 187.18,13.98 187.94,13.22 189.9,13.22 190.5,13.82 192.81,13.82 194.05,15.06 197.57,15.06 197.74,15.23 207.93,15.23 208.73,16.03 208.73,17.47 210.2,18.94 213.67,18.94 215.64,20.91 217.59,20.91 218.13,21.45 220.04,21.45 221.57,22.99 221.57,24.98 229.92,33.32 241.94,33.32 242.79,32.46 246.44,32.46 247.14,31.77 252.26,31.77 253.2,30.83 254.24,30.83 v2(254.6,31.19)
  BOTTOM w0.127: v2(77.47,15.82) 77.01,15.35 76.68,15.35 v1(76.19,14.87) 75.13,13.81 PR306.2 75.13,13.15 74.98,13 PR308.1 ; v2(254.6,31.19) 254.6,31.32 253.87,32.05 251.86,32.05 251.58,31.77 251.58,31.16 251.41,30.99 PU301.11
  BOTTOM w0.254: PU302.5 75.18,10.45 74.86,10.77 74.86,11.31 75.01,11.45 PC329.1 75.01,12.18 74.98,12.21 PR308.1
FAN_SPEED1: length 169.8
  TOP w0.127: v2(273.99,44.94) RE1.2 CE5.1 ; UK1.28 148.04,9.5 147.92,9.62 147.92,9.81 v2(147.93,9.83) ; v2(274.18,24.84) v3(274.18,24.13)
  IN2 w0.127: v2(147.93,9.83) 147.93,10.06 148.5,10.63 150.37,10.63 154.73,14.99 171.45,14.99 174.07,12.38 179,12.38 179.68,11.7 179.68,10.68 179.93,10.43 180,10.43 182.14,8.28 188.92,8.28 189.93,9.3 192.47,9.3 192.48,9.31 197.5,9.31 198.18,9.98 203.27,9.98 203.56,9.69 206.02,9.69 206.39,9.32 210.71,9.32 210.98,9.59 217.26,9.59 218.19,10.53 219.08,10.53 219.82,11.27 221.27,11.27 223.43,13.43 223.43,13.89 226.71,17.17 233.01,17.17 233.22,17.38 236.46,17.38 236.64,17.56 258.25,17.56 258.45,17.36 262.96,17.36 263.25,17.65 270.96,17.65 272.48,19.17 273.2,19.17 274.18,20.15 v2(274.18,24.84)
  BOTTOM w0.127: JFAN1.2 273.99,44.95 v2(273.99,44.94) 273.99,43.99 273.6,43.6 273.6,36.42 274.44,35.58 274.44,26.41 274.6,26.25 274.6,25.27 v2(274.18,24.84)
FAN_SPEED2: length 144.6
  TOP w0.127: v2(129.22,24.82) 129.22,24.94 v3(129.67,25.38) 130,25.71 133.36,25.71 134.54,24.53 134.54,20.73 134.65,20.62 UK1.101
  IN3 w0.127: v2(99.19,28.37) 99.19,28.33 99.04,28.17 99.04,27.86 99.42,27.48 100.89,27.48 103.03,25.34 103.14,25.34 103.94,24.55 111.76,24.55 112.23,25.02 113.74,25.02 115.56,26.83 115.8,26.83 117.22,28.25 118.72,28.25 118.94,28.04 118.94,27.27 119.64,26.57 120.77,26.57 120.98,26.35 127.69,26.35 v2(129.22,24.82)
  BOTTOM w0.127: 43.96,43.74 43.96,40.66 44.47,40.16 RE3.2 46.02,40.16 CE6.1 46.06,39.84 46.26,39.63 49.13,39.63 50.16,40.66 50.16,42.66 50.55,43.05 51.79,43.05 53.07,41.77 55.12,41.77 55.5,42.15 70.49,42.15 71.81,43.48 80.98,43.48 84.22,46.71 97.65,46.71 99.32,45.04 99.32,40.81 98.88,40.38 98.12,40.38 97.36,39.62 97.36,30.42 99.19,28.59 v2(99.19,28.37)
  BOTTOM w0.135: 43.96,43.74 43.18,44.52 40.82,44.52 40.39,44.96 38.79,44.96 38.35,45.4 38.35,47.12 36.8,48.68 33.71,48.68 33.63,48.6 JFAN2.2
FB_1.8V: length 4.3
  BOTTOM w0.127: v1(266.1,24.29) PR1803.2
  BOTTOM w0.254: PR1803.2 266.12,23.33 PC1802.2 266.12,21.8 PR1806.1 266.52,21.32 PU1801.1
FB_1V: length 3.6
  BOTTOM w0.254: PUH1.14 182.34,103.42 181.67,102.74 PRH8.1 PRH6.2 181.46,103.78 181.13,104.12 PRH4.2
FB_1V05: length 3.6
  BOTTOM w0.254: PU1001.14 237.37,24.86 v2(237.65,24.58) 237.93,24.3 PR1006.2 PR1020.2 238.76,23.83 PR1007.1
FB_2.5V: length 4.2
  TOP w0.127: v1(105.01,13.93) 105.15,14.07 PC2504.2
  TOP w0.254: PU2501.6 105.35,15.96 PR2507.1 105.16,15.38 105.15,15.37 PC2504.2 105.61,14.92 105.66,14.87 PR2506.2
FB_2PH: length 6.1
  TOP w0.127: PRZ42.1 170.15,135.33 v1(170.31,135.16)
  TOP w0.203: v2(168.86,133.75) 168.94,133.83 PCZ21.1 168.94,135.28 PRZ42.1
  BOTTOM w0.203: PCZ20.2 168.98,135.34 PRZ41.1 168.95,134.47 168.95,133.84 v2(168.86,133.75) 168.63,133.52 PUZ1.34
FB_3V_LCDVDD: length 4.6
  TOP w0.127: v1(77.09,41.49) RV50.1
  TOP w0.254: UV1.6 76.44,40.34 76.64,40.54 RV50.1 RV49.2 CV2.2
FB_4PH: length 7.1
  TOP w0.203: PCZ19.2 171.53,123.74 PCZ16.2 170.85,123.88 v2(170.77,123.8)
  BOTTOM w0.203: PUZ1.5 169.03,125.46 169.39,125.1 v1(169.39,124.66) 169.94,124.1 170.46,124.1 v2(170.77,123.8) 170.82,123.8 171.07,123.54 PRZ36.1 171.07,122.35 PRZ35.1
FB_+1.0VSDGP: length 5.8
  BOTTOM w0.127: PRF4.2 176.55,104.91 v1(177.56,105.93)
  BOTTOM w0.254: PCF2.2 176.6,104.18 PRF4.2 175.61,104.18 PRF6.1 175.65,103.86 175.65,103.07 PUF1.6
FB_CAL_PD_VDDQ: length 1.5
  TOP w0.356: v2(213.77,96.98) 213.57,97.18 RG47.2
  BOTTOM w0.109: v2(213.77,96.98) 213.64,96.98 UG1.J27
FB_CAL_PU_GND: length 0.6
  BOTTOM w0.356: UG1.H27 v2(213.63,97.76)
FB_CAL_TERM_GND: length 1.3
  TOP w0.457: RG49.2 214.77,96.16 v2(214.48,96.16)
  BOTTOM w0.356: UG1.H25 v2(214.48,96.16)
FB_DDR: length 3.9
  BOTTOM w0.203: PRM9.1 PRM6.1 94.83,24.38 v1(94.04,24.38) 93.69,24.38 93.36,24.71 92.84,24.71 92.45,25.11 PUM1.6
FB_GND_SENSE: length 5.9
  BOTTOM w0.102: UG1.F2 215.68,76.5 215.89,76.29 216.08,76.1 216.08,75.55 216.48,75.15 216.78,75.15 217.42,74.51
  BOTTOM w0.109: 217.83,74.1 217.42,74.51
  BOTTOM w0.132: TG10.1 219.55,72.38 217.83,74.1
FB_VDDQ_SENSE: length 36.7
  TOP w0.127: v2(242.51,61.51) v1(242.51,60.97)
  IN2 w0.254: v2(242.51,61.51) 242.02,62.01 242.02,63.58 241.19,64.41 238.44,64.41 238.43,64.42 234.14,64.42 231.46,67.09 225.13,67.09 222.65,69.57 220.77,69.57 216.48,73.86 v2(216.48,74.68)
  BOTTOM w0.254: PRW15.2 242.69,60.72 RG45.1 242.51,61.23 v2(242.51,61.51) ; v2(216.48,74.68) 216.26,74.9 216.08,75.09 216.08,75.16 215.68,75.55 UG1.F1
FBA0_VREFC: length 4.8
  BOTTOM w0.381: 225.87,127.79 CG89.1 RG52.1 227.78,127.79 227.8,127.76 RG51.2 RG50.2
  BOTTOM w0.406: 225.87,127.79 225.86,127.8 UG4.J14
FBA0_ZQ1: length 4.3
  BOTTOM w0.127: RG58.1 227.01,127.27 226.04,127.27 225.91,127.41 223.79,127.41 UG4.J13
FBA1_VREFC: length 6.1
  BOTTOM w0.127: RG53.2 183.01,127.29 v1(183.47,126.83)
  BOTTOM w0.406: UG5.J14 187.12,127.83 184.81,127.83 CG88.1
  BOTTOM w0.508: RG54.2 182.99,127.81 RG53.2 RG56.1 CG88.1
FBA1_ZQ3: length 4.6
  BOTTOM w0.102: 186.93,127.33 187.03,127.44 187.59,127.44 UG5.J13
  BOTTOM w0.127: RG61.1 v1(185.08,126.83) 186.43,126.83 186.93,127.33
FBA_CLKA0: length 40.2
  TOP w0.132: v2(207.76,100.34) 208.07,100.66 208.07,100.9 208.15,100.97 208.15,101.31 207.94,101.52 207.94,102.24 208.7,103 208.7,104.94 212.31,108.56 215.63,108.56 220.86,113.78 220.86,113.8 221.4,114.34 221.41,114.34 222.06,114.98 222.06,116.44 v2(221.9,116.6)
  IN1 w0.102: 220.5,127 220.72,127.23 220.72,127.55 221.37,128.2 v2(222.2,128.2)
  IN1 w0.152: 220.5,127 220.45,126.96 220.45,119.46 222.11,117.8 222.11,116.81 v2(221.9,116.6)
  BOTTOM w0.102: UG4.J12 v2(222.2,128.2)
  BOTTOM w0.132: v2(221.9,116.6) 222.08,116.41 222.08,115.99 RG63.1 ; UG1.R30 208.16,99.94 v2(207.76,100.34)
FBA_CLKA0#: length 40.1
  TOP w0.132: v2(222.53,116.6) 222.3,116.37 222.3,114.88 v4(221.31,113.89) 215.73,108.31 212.42,108.31 208.95,104.84 208.95,102.9 208.18,102.14 208.18,101.62 208.4,101.41 208.4,100.87 208.32,100.8 208.32,100.6 v2(208.58,100.34)
  IN1 w0.102: 220.74,126.84 220.79,126.88 220.79,127.01 220.92,127.14 220.92,127.46 221.45,127.99 221.85,127.99 222.2,127.64 v2(222.2,127.4)
  IN1 w0.152: 220.74,126.84 220.74,119.58 222.4,117.93 222.4,116.73 v2(222.53,116.6)
  BOTTOM w0.102: v2(222.2,127.4) 221.8,127.8 UG4.J11
  BOTTOM w0.132: v2(208.58,100.34) UG1.R31 ; RG95.1 222.33,115.95 222.33,116.4 v2(222.53,116.6)
FBA_CLKA1: length 36.8
  TOP w0.102: v2(201.91,101.14) 201.79,101.14 201.6,101.33 201.6,101.57 200.99,102.18 200.99,104.67 200.57,105.09 200.57,105.12 200.55,105.13
  TOP w0.132: v2(190.08,115.98) 189.86,115.98 189.69,115.82 189.69,115.59 193.09,112.19 194.45,112.19 200.29,106.35 200.29,105.39 200.55,105.13
  IN1 w0.102: 190.81,126.99 190.81,127.02 190.77,127.06 190.77,127.39 190.05,128.11 189.24,128.11 v2(189.15,128.2)
  IN1 w0.152: v2(190.08,115.98) 190.08,116.2 190.81,116.94 190.81,126.99
  BOTTOM w0.102: UG5.J12 v2(189.15,128.2)
  BOTTOM w0.132: v2(190.08,115.98) 189.77,115.98 189.62,115.83 RG96.1 ; UG1.AB31 202.31,100.74 v2(201.91,101.14)
FBA_CLKA1#: length 36.8
  TOP w0.102: 200.38,104.96 200.4,104.94 200.42,104.94 200.78,104.58 200.78,102.09 201.39,101.48 201.39,101.27 201.27,101.14 v2(201.08,101.14)
  TOP w0.132: v2(189.65,116.41) 189.65,116.12 189.45,115.92 189.45,115.49 192.99,111.95 194.35,111.95 200.05,106.25 200.05,105.29 200.38,104.96
  IN1 w0.102: 190.52,126.99 190.52,127.02 190.57,127.06 190.57,127.32 189.98,127.9 189.41,127.9 189.15,127.64 v2(189.15,127.4)
  IN1 w0.152: v2(189.65,116.41) 189.87,116.41 190.52,117.06 190.52,126.99
  BOTTOM w0.102: UG5.J11 189.55,127.8 v2(189.15,127.4)
  BOTTOM w0.132: RG62.1 189.46,116.01 189.65,116.2 v2(189.65,116.41) ; UG1.AC31 v2(201.08,101.14)
FBA_CMD0: length 36.8
  TOP w0.102: 221.92,119.09 221.92,120.03 220.99,120.96 220.99,125.96 221.25,126.22 221.82,126.22 v2(222.2,126.6) ; v2(206.91,100.34) 207.37,100.81 207.37,101.44 207.57,101.64 207.57,102.39 208.39,103.21
  TOP w0.196: 208.39,103.21 208.39,105.31 209.95,106.87 209.95,107.14 212.24,109.43 215.56,109.43 219.66,113.54 v1(219.66,114.25) 219.66,115.33 221.92,117.59 221.92,119.09
  BOTTOM w0.102: UG4.G12 v2(222.2,126.6)
  BOTTOM w0.196: v2(206.91,100.34) 206.51,99.94 UG1.U30
FBA_CMD1: length 35
  TOP w0.102: v2(206.91,101.14) 206.91,101.36 207.3,101.76 207.3,102.6 207.9,103.2 ; v2(221.35,126.64) 221.3,126.64 220.74,126.07 220.74,120.64 221.3,120.07 221.3,119.03
  TOP w0.196: 221.3,119.03 221.3,117.82 219.06,115.58 219.06,113.79 v1(218.29,113.02) 215.31,110.04 211.98,110.04 209.4,107.45 209.4,107.44 209.35,107.39 209.35,107 207.9,105.55 207.9,103.2
  BOTTOM w0.102: UG4.H10 221,126.99 v2(221.35,126.64)
  BOTTOM w0.196: UG1.T31 207.31,100.74 v2(206.91,101.14)
FBA_CMD2: length 37.4
  TOP w0.102: 207.44,103.18 206.5,102.23 206.5,100.12 206.91,99.71 v2(206.91,99.52) ; v2(221.4,127.4) 220.48,126.48 220.48,120.27 220.7,120.05 220.7,118.78
  TOP w0.196: 207.44,103.18 207.44,105.94 208.75,107.25 208.75,107.64 208.79,107.69 208.79,107.7 211.73,110.64 214.91,110.64 218.46,114.19 v1(218.46,115.16) 218.46,115.83 220.7,118.07 220.7,118.78
  BOTTOM w0.102: UG4.H11 v2(221.4,127.4)
  BOTTOM w0.196: UG1.U29 v2(206.91,99.52)
FBA_CMD3: length 32
  TOP w0.102: v2(220.27,128.22) 219.9,127.84 219.9,126.87 220.09,126.68 220.09,118.78
  TOP w0.196: 220.09,118.78 220.09,118.34 217.79,116.04 217.79,114.37 216.29,112.87 v2(216.17,112.87)
  BOTTOM w0.102: v2(220.27,128.22) 221.44,128.22 221.8,128.57 UG4.K11
  BOTTOM w0.196: UG1.R34 208.18,104.88 v1(214.86,111.56) v2(216.17,112.87)
FBA_CMD4: length 32.5
  TOP w0.102: v2(220.27,128.8) 219.64,128.17 219.64,119.12 219.48,118.96
  TOP w0.196: 219.48,118.96 219.48,118.58 217.19,116.29 v1(217.19,115.83) v2(217.19,114.7)
  BOTTOM w0.102: v2(220.27,128.8) 220.47,128.6 UG4.K10
  BOTTOM w0.196: UG1.R33 208.58,102.74 208.58,104.68 209.57,105.67 209.9,105.67 217.14,112.91 217.14,114.66 v2(217.19,114.7)
FBA_CMD5: length 37.9
  TOP w0.102: 218.92,119.16 219.39,119.63 219.39,128.87 v2(220.02,129.5)
  TOP w0.196: 218.92,119.16 218.92,118.88 216.18,116.13 v2(216.18,114.13)
  BOTTOM w0.102: v2(220.02,129.5) 220.21,129.31 220.49,129.31 220.81,128.99 222.19,128.99 UG4.L12
  BOTTOM w0.196: UG1.U32 206.09,101.93 206.09,102.5 206.32,102.73 206.33,102.73 206.34,102.74 206.63,102.74 206.87,102.98 206.87,105.81 207.44,106.38 207.44,106.93 214.64,114.13 v2(216.18,114.13)
FBA_CMD6: length 33.9
  TOP w0.102: v2(216.6,128.2) 217.01,128.61 217.73,128.61 218.82,127.52 218.82,120.48 217.24,118.9
  TOP w0.196: 217.24,118.9 214.45,116.11 v1(214.45,115.59) 214.45,113.35 v2(214.58,113.22)
  BOTTOM w0.102: UG4.K4 v2(216.6,128.2)
  BOTTOM w0.196: v2(214.58,113.22) 211.97,110.59 208.1,106.71 208.1,106.41 207.33,105.64 207.33,102.97 206.7,102.34 UG1.U33
FBA_CMD7: length 40.5
  TOP w0.102: 218.36,119.34 219.07,120.05 219.07,127.85 217.73,129.19 v2(217.5,129.19) ; v2(206.08,98.67) 206.46,99.05 206.46,99.67 206.18,99.96 205.92,99.96 205.7,100.18 205.7,101.4 206.06,101.77 206.06,102.16 206.91,103
  TOP w0.196: 206.91,103 206.91,106.01 207.76,106.86 207.76,107.52 211.48,111.24 211.76,111.24 211.94,111.24 211.94,111.24 214.28,111.24 215.31,112.28 215.31,116.12 v1(216.54,117.35) 218.36,119.17 218.36,119.34
  BOTTOM w0.102: v2(217.5,129.19) 217.5,129.1 UG4.K5
  BOTTOM w0.196: UG1.U28 206.48,98.27 v2(206.08,98.67)
FBA_CMD8: length 40.1
  TOP w0.102: 215.42,118.78 216.23,119.59 216.96,119.59 218.31,120.94 218.31,127.08 217.67,127.72 217.33,127.72 217.33,127.72 216.92,127.72 v2(216.6,127.4) ; v2(206.08,97.84) 205.7,98.22 205.7,98.94 205.55,99.09 205.08,99.09 204.9,99.27 204.9,101.3 205.18,101.58 205.18,102.21 206.04,103.07
  TOP w0.196: 215.42,118.78 213.01,116.37 v1(213.01,115.19) 213.01,113.01 212.44,112.44 210.98,112.44 206.56,108.02 206.56,106.83 206.04,106.31 206.04,103.07
  BOTTOM w0.102: UG4.J4 v2(216.6,127.4)
  BOTTOM w0.196: UG1.V28 v2(206.08,97.84)
FBA_CMD9: length 37.2
  TOP w0.102: 216.27,118.78 216.7,119.21 217.04,119.21 218.56,120.73 218.56,127.31 217.75,128.12 v2(217.5,128.12) ; v2(206.08,99.52) 205.43,100.16 205.43,101.89 206.45,102.91
  TOP w0.196: 206.45,102.91 206.45,106.16 207.16,106.87 207.16,107.77 211.23,111.84 211.5,111.84 212.69,111.84 213.78,112.93 213.78,116.29 v1(215.03,117.54) 216.27,118.78
  BOTTOM w0.102: v2(217.5,128.12) 217.17,127.8 UG4.J5
  BOTTOM w0.196: v2(206.08,99.52) 205.68,99.11 UG1.V29
FBA_CMD10: length 39.1
  TOP w0.102: 216.42,120.57 216.77,120.57 217.85,121.65 217.85,125.91 217.47,126.3 216.89,126.3 v2(216.6,126.6) ; 205.35,102.85 204.9,102.4 204.9,101.79 204.62,101.51 204.62,99.2 205.13,98.69 v2(205.2,98.69)
  TOP w0.196: 216.42,120.57 215.5,120.57 v1(213.41,118.47) 211.35,116.42 211.35,113.66 205.95,108.27 205.95,106.83 205.47,106.34 205.47,102.97 205.35,102.85
  BOTTOM w0.102: UG4.H4 v2(216.6,126.6)
  BOTTOM w0.196: UG1.V30 205.64,99.98 205.36,99.98 205,100.34 204.67,100.34 204.43,100.11 204.43,99.46 v2(205.2,98.69)
FBA_CMD11: length 30.3
  TOP w0.102: v2(217.5,127.29) 218.06,126.74 218.06,121.39 216.66,120 215.78,120 214.74,118.95
  TOP w0.196: 214.74,118.95 v1(212.7,116.91) 212.41,116.62 212.41,113.7 v2(212.27,113.56)
  BOTTOM w0.102: UG4.H5 217.21,127 v2(217.5,127.29)
  BOTTOM w0.196: v2(212.27,113.56) 212.22,113.56 206.84,108.17 206.84,106.52 206.48,106.16 UG1.U34
FBA_CMD12: length 34.8
  IN1 w0.102: 212.03,127.43 212.82,127.43 212.97,127.28 213.61,127.28 213.87,127.02 215.38,127.02 v2(215.8,126.6)
  IN1 w0.203: v2(206.08,101.14) 206.08,105.31 205.15,106.24 205.15,110.43 207.67,112.95 207.67,115.99 208.73,117.06 208.73,124.14 212.03,127.43
  BOTTOM w0.102: UG4.G3 v2(215.8,126.6)
  BOTTOM w0.196: UG1.U31 v2(206.08,101.14)
FBA_CMD13: length 32.7
  TOP w0.152: RG89.2 212.49,128.21 213.38,128.21 v2(214.2,127.4)
  TOP w0.196: RG89.2 211.54,129.03 209.02,126.5 v1(209.02,119.12) 209.02,114.43 v2(209.39,114.05)
  BOTTOM w0.102: UG4.J2 214.59,127.8 v2(214.2,127.4)
  BOTTOM w0.196: UG1.V34 205.68,106 205.47,106.21 205.47,109.64 208.2,112.37 208.2,112.86 209.39,114.05 v2(209.39,114.05)
FBA_CMD14: length 33.5
  TOP w0.102: v2(215,128.2) 214.58,127.78 214.58,127.25 214.35,127.02 213.81,127.02 213.44,127.38
  TOP w0.152: 213.44,127.38 212.35,127.38 RG87.2
  TOP w0.196: RG87.2 211.54,128.06 209.99,126.52 v1(209.99,117.31) 209.99,113.28 209.55,112.83 v2(209.45,112.83)
  BOTTOM w0.102: UG4.J3 v2(215,128.2)
  BOTTOM w0.196: UG1.V33 205.68,102.54 206.07,102.93 206.07,109.39 209.45,112.77 v2(209.45,112.83)
FBA_CMD15: length 39.3
  IN1 w0.102: 214.34,128.24 214.69,128.59 215.39,128.59 v2(215.8,129)
  IN1 w0.203: 214.34,128.24 211.82,128.24 208.13,124.54 208.13,117.31 207.06,116.25 207.06,113.2 204.54,110.68 204.54,106.16 205.67,105.03 205.67,101.77 205.53,101.63 205.53,100.89 v2(206.08,100.34)
  BOTTOM w0.102: UG4.L3 v2(215.8,129)
  BOTTOM w0.196: UG1.Y32 204.38,101.14 205.03,101.14 205.23,100.94 205.23,100.57 205.46,100.34 v2(206.08,100.34)
FBA_CMD16: length 35.7
  TOP w0.102: 201.54,103.85 202.31,103.08 202.31,100.75 v2(201.91,100.34) ; 189.77,120.24 190.36,120.83 190.36,126.07 190.2,126.23 189.52,126.23 v2(189.15,126.6)
  TOP w0.196: 201.54,103.85 201.54,106.07 195.66,111.95 195.66,112.99 194.92,113.73 193.28,113.73 v1(191.9,115.11) 189.77,117.24 189.77,120.24
  BOTTOM w0.102: UG5.L12 v2(189.15,126.6)
  BOTTOM w0.196: UG1.AA31 202.78,100.34 201.91,100.34 v2(201.91,100.34)
FBA_CMD17: length 36.5
  TOP w0.102: 190.37,120.19 190.37,120.44 190.61,120.68 190.61,126.21 190.18,126.64 v2(189.94,126.64) ; v2(202.76,98.67) 202.76,98.97 202.37,99.36 202.37,100.16 203.14,100.93 203.14,102.11 202.85,102.39 202.85,103.13 202.11,103.86
  TOP w0.196: 202.11,103.86 202.11,106.35 196.26,112.2 196.26,113.45 195.33,114.38 v1(194.09,114.38) 193.49,114.38 190.37,117.49 190.37,120.19
  BOTTOM w0.102: v2(189.94,126.64) 190.29,127 UG5.K10
  BOTTOM w0.196: v2(202.76,98.67) UG1.AA29
FBA_CMD18: length 37.6
  TOP w0.102: 202.67,104.01 203.37,103.32 203.37,100.72 203.17,100.53 203.17,98.26 v2(202.76,97.84) ; 190.97,120.08 190.87,120.19 190.87,126.48 v2(189.95,127.4)
  TOP w0.196: 202.67,104.01 202.67,106.64 196.98,112.33 196.98,113.57 195.58,114.98 193.73,114.98 v1(191.84,116.87) 190.97,117.74 190.97,120.08
  BOTTOM w0.102: UG5.K11 v2(189.95,127.4)
  BOTTOM w0.196: UG1.AA28 202.78,97.84 v2(202.76,97.84)
FBA_CMD19: length 32.1
  TOP w0.102: v2(190.95,127.98) 191.21,127.73 191.21,120.35 191.57,119.99 191.57,119.78
  TOP w0.196: v2(198.63,111.74) 198.42,111.74 197.59,112.58 197.59,113.82 v1(196.27,115.14) 195.83,115.58 193.98,115.58 191.57,117.99 191.57,119.78
  BOTTOM w0.102: UG5.H11 189.71,128.6 190.14,128.16 190.83,128.16 190.95,128.04 v2(190.95,127.98)
  BOTTOM w0.196: v2(198.63,111.74) 198.63,107.59 201.48,104.74 UG1.AC34
FBA_CMD20: length 33.5
  TOP w0.102: v2(190.91,128.6) 190.91,128.6 191.5,128.01 191.5,120.46 192.18,119.78 192.18,119.71
  TOP w0.196: 192.18,119.71 192.18,118.24 v1(193.71,116.7) 194.23,116.18 196.08,116.18 198.94,113.32 v2(199.16,113.32)
  BOTTOM w0.102: UG5.H10 v2(190.91,128.6)
  BOTTOM w0.196: UG1.AC33 201.08,102.74 201.08,104.26 198.02,107.32 198.02,112.38 198.96,113.32 v2(199.16,113.32)
FBA_CMD21: length 37.1
  TOP w0.102: v2(189.15,129) 191.08,129 191.77,128.3 191.77,120.6 192.78,119.6
  TOP w0.196: v2(200.4,111.08) 199.76,111.72 199.76,114.24 199.57,114.43 198.68,114.43 196.33,116.78 194.48,116.78 v1(192.78,118.49) 192.78,119.6
  BOTTOM w0.102: UG5.G12 v2(189.15,129)
  BOTTOM w0.196: v2(200.4,111.08) 200.35,111.08 199.75,110.48 199.75,107.32 202.37,104.7 202.37,102.9 202.78,102.49 202.78,101.94 UG1.AA32
FBA_CMD22: length 34.8
  TOP w0.102: 193.62,119.72 192.53,120.81 192.53,127.32 193.41,128.2 v2(194.75,128.2)
  TOP w0.196: v2(201.01,113.09) 201.32,113.09 201.46,113.23 201.46,114.49 200.31,115.64 199.18,115.64 196.83,117.99 194.98,117.99 v1(194.42,118.55) 193.98,118.99 193.98,119.36 193.62,119.72
  BOTTOM w0.102: UG5.H4 195.15,128.6 v2(194.75,128.2)
  BOTTOM w0.196: UG1.AA33 203.18,102.54 202.77,102.95 202.77,105.23 201.84,106.17 201.01,106.99 v2(201.01,113.09)
FBA_CMD23: length 41
  IN1 w0.102: v2(193.75,128.6) 194.53,127.82 198.25,127.82 198.59,128.16 199.21,128.16
  IN1 w0.203: v2(204.37,98.63) 204.73,98.99 204.73,101.47 205.28,102.01 205.28,103.71 204.91,104.07 204.91,105.21 203.93,106.19 203.93,110.94 205.41,112.41 205.41,119.08 202.92,121.57 202.92,125 199.76,128.16 199.21,128.16
  BOTTOM w0.102: v2(193.75,128.6) 193.75,128.6 UG5.H5
  BOTTOM w0.196: v2(204.37,98.63) UG1.Y28
FBA_CMD24: length 37.6
  IN1 w0.102: 199.21,127.08 199.18,127.08 198.93,127.33 198.57,127.33 198.56,127.31 197.96,127.31 197.67,127.02 195.93,127.02 v2(195.55,127.4)
  IN1 w0.203: v2(203.58,98.67) 204.26,99.35 204.26,100.87 203.88,101.25 203.88,105.41 203.3,106 203.3,111.18 204.8,112.68 204.8,118.83 202.31,121.32 202.31,124.67 199.9,127.08 199.21,127.08
  BOTTOM w0.102: v2(195.55,127.4) 195.15,127.8 UG5.J4
  BOTTOM w0.196: UG1.Y29 203.58,98.69 v2(203.58,98.67)
