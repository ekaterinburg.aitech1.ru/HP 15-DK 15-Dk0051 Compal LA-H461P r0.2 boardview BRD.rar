# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_PRX_C_DTX_N0: length 10.6
  BOTTOM w0.127: C379.2 255.69,18.91 255.69,18.46 254.93,17.69 v4(253.87,17.69) 248.57,17.69 247.81,16.93 247.81,16.74 247.65,16.58 JHDD1.8
SATA_PRX_C_DTX_P0: length 10.5
  BOTTOM w0.127: JHDD1.7 248.15,16.56 248.06,16.65 248.06,16.82 248.68,17.44 255.03,17.44 v4(255.55,17.95) 255.95,18.36 255.95,19.12 C378.2
SATA_PRX_DTX_N0: length 102.2
  IN1 w0.135: v2(259.06,41.32) 259.3,41.56 259.3,41.65 258.85,42.11 256.71,42.11 256.47,42.35 255.03,42.35 253.94,43.44 249.28,43.44 248.51,44.21 242.5,44.21 241.68,43.39 234.54,43.39 233.44,42.28 232.07,42.28 231.33,41.53 228.94,41.53 228.41,41 222.47,41 219.14,44.32 214.77,44.32 214.05,45.04 210.16,45.04 209.62,44.49 200.99,44.49 200.36,43.86 200.36,40.86 199.37,39.88 192.98,39.88 192.7,39.59 192.7,39.47 192.97,39.2 v2(193.02,39.2)
  BOTTOM w0.127: C379.1 255.57,20.54 255.57,23.53 257.27,25.24 257.27,30.59 255.34,32.52 255.34,34.68 254.77,35.25 254.77,38.22 255.62,39.06 257.44,39.06 259.29,40.92 259.29,41.1 v2(259.06,41.32) ; UH1.C45 192.6,39.37 192.85,39.37 v2(193.02,39.2)
SATA_PRX_DTX_P0: length 102.2
  IN1 w0.135: v2(192.45,39.93) 192.64,39.93 192.87,40.16 199.26,40.16 200.08,40.98 200.08,43.98 200.87,44.77 209.5,44.77 210.05,45.32 214.17,45.32 214.88,44.6 219.26,44.6 222.58,41.28 228.29,41.28 228.83,41.81 231.21,41.81 231.96,42.56 233.32,42.56 234.43,43.67 241.56,43.67 242.39,44.49 248.63,44.49 249.4,43.72 254.05,43.72 255.15,42.63 256.59,42.63 256.83,42.39 258.96,42.39 259.59,41.76 259.59,41.51 v2(259.77,41.32)
  BOTTOM w0.127: C378.1 255.82,20.59 255.82,23.43 257.53,25.13 257.53,30.7 255.6,32.63 255.6,34.79 255.03,35.35 255.03,38.11 255.73,38.81 257.33,38.81 257.54,38.81 259.54,40.81 259.54,41.09 v2(259.77,41.32) ; v2(192.45,39.93) UH1.C46
SATA_PTX_C_DRX_N0: length 10.1
  BOTTOM w0.127: JHDD1.10 246.65,16.62 246.53,16.75 246.53,16.98 246.69,17.14 247.39,17.14 248.37,18.13 v4(252.26,18.13) 253.51,18.13 254.04,18.66 254.04,19.06 C380.2
SATA_PTX_C_DRX_P0: length 10.1
  BOTTOM w0.127: C382.2 253.79,19.01 253.79,18.77 253.4,18.38 v4(250.87,18.38) 248.27,18.38 247.28,17.4 246.58,17.4 246.27,17.09 246.27,16.72 246.15,16.6 JHDD1.11
SATA_PTX_DRX_N0: length 100.5
  IN1 w0.135: v2(197.66,44.17) 197.8,44.03 198.16,44.03 199.68,45.55 209.26,45.55 209.75,46.03 214.73,46.03 215.44,45.32 219.63,45.32 222.91,42.04 227.68,42.04 228.33,42.7 231.04,42.7 231.65,43.31 233.05,43.31 234.12,44.39 238.73,44.39 240.24,45.9 242.55,45.9 242.83,45.62 249.37,45.62 250.55,44.44 254.45,44.44 255.11,43.78 257.06,43.78 257.43,43.41 257.43,43.11 v2(257.62,42.92)
  BOTTOM w0.089: UH1.B38 196.24,39.99 195.97,40.25 195.97,40.38 195.61,40.74 195.61,41.07 195.51,41.17 195.51,44.35 195.84,44.68 196.53,44.68 197.23,43.97 197.47,43.97 v2(197.66,44.17)
  BOTTOM w0.127: v2(257.62,42.92) 257.4,42.7 257.4,42.35 255.92,40.87 254.78,40.87 253.65,39.74 253.65,35.67 254.9,34.42 254.9,32.35 256.84,30.41 256.84,25.41 253.97,22.55 253.97,20.63 C380.1
SATA_PTX_DRX_P0: length 100.4
  IN1 w0.135: v2(256.91,42.92) 257.15,43.17 257.15,43.29 256.95,43.5 254.99,43.5 254.33,44.16 250.44,44.16 249.25,45.34 242.71,45.34 242.44,45.62 240.36,45.62 238.84,44.11 234.24,44.11 233.16,43.03 231.77,43.03 231.16,42.42 228.45,42.42 227.79,41.76 222.79,41.76 219.52,45.04 215.33,45.04 214.61,45.76 209.87,45.76 209.38,45.27 199.8,45.27 198.28,43.75 197.83,43.75 v2(197.66,43.58)
  BOTTOM w0.089: v2(197.66,43.58) 197.47,43.78 197.15,43.78 196.45,44.49 195.92,44.49 195.7,44.27 195.7,41.25 195.8,41.15 195.8,40.82 196.16,40.46 196.16,40.33 196.32,40.17 196.36,40.16 196.48,40.03 196.48,39.65 196.24,39.41 UH1.C38
  BOTTOM w0.127: C382.1 253.71,20.53 253.71,22.65 256.58,25.52 256.58,30.31 254.64,32.25 254.64,34.31 253.39,35.56 253.39,39.85 254.67,41.13 255.81,41.13 257.14,42.46 257.14,42.7 v2(256.91,42.92)
SD_CD#: length 18.6
  IN3 w0.127: v2(44.78,16.26) 44.42,16.26 43.9,16.78 43.9,18.03 41.84,20.09 41.84,22.26 41.33,22.76 37.84,22.76 37.31,23.29 36.17,23.29 35.01,24.45 35.01,25.42 JCR2.4
  BOTTOM w0.127: v2(44.78,16.26) 44.78,16.26 UR1.30
SD_CLK: length 2.1
  BOTTOM w0.127: RR6.1 39.45,20.19 v2(39.92,19.71) 40.21,19.43 UR1.17
SD_CLK_R: length 14.1
  BOTTOM w0.127: RR6.2 38.93,21.64 38.91,21.61 CR12.1 v1(37.43,21.61) 37.28,21.61 35.35,23.55 35.35,30.85 JCR2.7
SD_CMD: length 1.8
  BOTTOM w0.127: RR7.1 40.98,19.98 41.01,19.95 UR1.19
SD_CMD_R: length 9.8
  IN3 w0.127: JCR2.3 36.56,22.13 37.52,22.13 37.66,22.27 38.72,22.27 38.85,22.14 38.85,21.72 38.98,21.6 39.36,21.6 39.49,21.72 39.49,22.14 39.61,22.27 v2(40.98,22.27)
  BOTTOM w0.127: RR7.2 v2(40.98,22.27)
SD_D0: length 2.7
  BOTTOM w0.127: RR5.2 38.16,19.5 38.51,19.5 v2(38.68,19.34) 38.99,19.02 38.99,18.4 39.14,18.26 UR1.16
SD_D0_R: length 19.2
  TOP w0.127: v2(35.57,19.93) 35.57,20.13 v1(35.57,20.97) 35.57,21.91 35.36,22.12 35.36,31.85 35.19,32.03 35.19,35.93 JCR2.9
  BOTTOM w0.127: RR5.1 35.66,19.84 v2(35.57,19.93)
SD_D1: length 2.3
  BOTTOM w0.127: RR4.2 38.11,19.07 38.66,18.52 38.66,18.31 39.12,17.86 UR1.15
SD_D1_R: length 21.2
  TOP w0.127: v2(36.3,19.4) 36.17,19.54 36.17,20.43 36,20.6 36,22.09 35.8,22.3 35.8,32.07 35.62,32.24 35.62,36.93 34,38.56 JCR2.10
  BOTTOM w0.127: v2(36.3,19.4) 36.63,19.07 RR4.1
SD_D2: length 2.1
  BOTTOM w0.127: RR9.1 42.5,20.48 41.81,19.79 UR1.21
SD_D2_R: length 11.9
  IN1 w0.127: JCR2.1 34.98,20.68 39.1,20.68 39.6,20.18 43.3,20.18 v2(43.46,20.34)
  BOTTOM w0.127: v2(43.46,20.34) 43.46,20.75 42.58,21.64 RR9.2
SD_D3: length 1.9
  BOTTOM w0.127: RR8.1 41.74,20.35 41.41,20.02 v2(41.41,19.71) UR1.20
SD_D3_R: length 14.8
  IN1 w0.127: JCR2.2 35.08,21.11 39.28,21.11 39.78,20.61 42.72,20.61 42.96,20.85 43.65,20.85 v2(44.13,20.37)
  BOTTOM w0.127: v2(44.13,20.37) 44.13,20.89 v1(43.66,21.37) 42.91,22.12 42.07,22.12 41.74,21.79 RR8.2
SD_RCOMP_1P8: length 3.4
  TOP w0.127: v2(212.49,19.36) 212.49,19.95 213.01,20.47 RH22.1 213.44,20.64 213.29,20.79 v1(212.53,20.79)
  BOTTOM w0.102: v2(212.49,19.36) 212.49,18.91 UH1.BE5
SD_RCOMP_3P3: length 1.5
  TOP w0.127: RH23.1 212.37,18.26 v2(212.34,18.23)
  BOTTOM w0.127: v2(212.34,18.23) 212.72,18.61 UH1.BE4
SD_WP: length 30.6
  TOP w0.127: v2(44.78,16.87) 43.26,18.39 v1(43.26,18.74) 40.76,21.24 40.76,21.89 38.51,24.14 36.65,24.14 36.23,24.57 36.23,32.25 36.05,32.42 36.05,37.11 34.89,38.28 34.89,39.88 JCR2.11
  BOTTOM w0.127: UR1.29 44.57,16.66 v2(44.78,16.87)
SERIRQ: length 80.9
  TOP w0.127: v2(145,18.06) 145,18.03 144.47,17.5 142.88,17.5 141.06,15.69 141.06,13.85 138.04,10.83 UK1.3 ; RH65.2 RH64.2 v2(193.48,11.06)
  IN1 w0.127: v2(193.48,11.06) 192.73,10.32 185.07,10.32 184.76,10.01 181.52,10.01 180.48,8.98 177.39,8.98 175.1,6.69 175.1,6.21 174.74,5.85 169.27,5.85 v2(169.08,6.04)
  BOTTOM w0.127: v2(145,18.06) 145,17.77 142.79,15.56 142.79,12.94 144.58,11.15 144.73,11 150.24,11 152.16,12.91 163.2,12.91 164.72,11.39 166.9,11.39 169.07,9.22 169.07,6.05 v2(169.08,6.04)
SIZE_SEL: length 13.4
  TOP w0.102: 196.13,15.6 196.38,15.85 196.38,19.86 197,20.48 v2(197.32,20.48)
  TOP w0.127: 196.13,15.6 195.94,15.41 195.94,14.99 v1(195.34,14.39) 195.31,14.36 195.31,13.15 195.14,12.99 195.14,11.69 195.01,11.57 RH255.1
  TOP w0.135: RH256.1 RH255.1
  BOTTOM w0.127: UH1.BA33 197.95,20.97 197.47,20.48 v2(197.32,20.48)
SKTOCC#: length 2.8
  BOTTOM w0.127: TC102.1 125.32,105.87 127.57,105.87 UC1.BR33
SLP_LAN#: length 2.9
  BOTTOM w0.127: TH131.1 195.13,15.83 195.13,17.21 195.38,17.45 UH1.BF40
SLP_WLAN#: length 128.3
  TOP w0.135: QWL3.2 302.07,6.21 v3(301.88,6.01) 301.13,5.27 v2(301.13,5.21)
  IN1 w0.127: v2(278.09,5.32) 277.39,6.03 276.44,6.03 275.84,5.43 260.57,5.43 259.97,6.03 249.42,6.03 249.02,6.43 244.28,6.43 243.36,7.35 239.85,7.35 239.62,7.58 234.21,7.58 232.76,9.02 232.76,9.71 231.18,11.29 228.09,11.29 225.64,8.84 225.64,8.5 224.73,7.58 222.21,7.58 221.27,6.64 215.89,6.64 214.25,8.29 209.12,8.29 208.92,8.49 207.22,8.49 206.74,8.01 206.74,7.68 206.41,7.35 205.64,7.35 204.05,8.94 202.47,8.94 200.69,10.72 200.69,13.72 199.24,15.17 v2(193.17,15.17)
  IN2 w0.127: v2(301.13,5.21) 300.62,4.69 282.24,4.69 280.97,5.96 278.73,5.96 v2(278.09,5.32)
  BOTTOM w0.102: 193.6,16.7 193.6,16.81 194.46,17.66 194.46,18.92 UH1.BD42
  BOTTOM w0.127: 193.6,16.7 193.6,16.34 193.17,15.91 v2(193.17,15.17)
SM_INTRUDER#: length 9.4
  TOP w0.127: RH6.2 187.73,17.47 187.77,17.47 187.96,17.65 v2(188.04,17.65) ; v1(193.65,21.32) 193.63,21.32 192.69,20.38 v2(192.69,20.32)
  IN3 w0.127: v2(192.69,20.32) 192.44,20.58 191.95,20.58 191.41,20.04 189.63,20.04 188.04,18.46 v2(188.04,17.65)
  BOTTOM w0.127: UH1.BB44 v2(192.69,20.32)
SM_PG_CTRL: length 153.4
  TOP w0.127: v2(95.79,22.91) v3(95.79,22.32)
  IN2 w0.127: v2(101.8,73.1) 101.8,72.58 100.49,71.27 98.7,67.87 97.49,65.48 95.01,62.1 94.99,62.08 94.36,61.22 94.36,58.76 87.32,51.73 87.32,47.13 84.94,44.75 83.15,44.75 80.78,42.37 78.44,42.37 78.23,42.17 69.1,42.17 67.25,40.32 63.77,40.32 63.36,39.91 63.36,33.98 62.66,33.28 57.02,33.28 56.18,32.43 56.18,29.83 57.11,28.9 58.93,28.9 59.73,29.7 66.42,29.7 67.79,28.33 82.01,28.33 85.15,25.2 88.05,25.2 90.65,22.6 95.48,22.6 v2(95.79,22.91)
  BOTTOM w0.127: PRM12.1 95.46,22.58 v2(95.79,22.91) ; v2(101.8,73.1) 104.67,70.23 107.13,70.23 109.52,72.61 109.52,74.5 109.93,74.91 118.6,74.91 121.77,78.09 121.77,82.26 121.42,82.61 RC43.2 121.25,85.53 UC2.4
SM_RCOMP0: length 5.2
  BOTTOM w0.203: 166.48,80.72 166.4,80.8 165.8,80.8 164.33,82.26 UC1.G1
  BOTTOM w0.381: 166.48,80.72 167.37,79.83 RC3.2
SM_RCOMP1: length 5.7
  BOTTOM w0.127: v1(164.39,78.29) 164.99,78.89 RC4.2
  BOTTOM w0.203: 165.44,79.91 165.44,80.29 163.47,82.25 UC1.H1
  BOTTOM w0.381: 165.44,79.91 RC4.2
SM_RCOMP2: length 5.7
  BOTTOM w0.203: 166.02,80.14 163.86,82.29 163.86,82.64 163.34,83.17 UC1.J2
  BOTTOM w0.381: 166.02,80.14 166.35,79.81 RC5.2
SMB_CK2: length 7.6
  TOP w0.127: v1(181.79,125.26) R5284.1 180.39,124.77 v2(180.16,124.55) 180.16,124.54 180.16,122.89 Q7.1
  BOTTOM w0.127: v2(180.16,124.55) 180.19,124.58 180.19,126.05 180.68,126.54 UC3.8
SMB_DA2: length 6.8
  TOP w0.127: v1(178.33,124.71) 178.87,125.26 R5285.1 179.58,124.52 v2(179.56,124.5) 179.56,123.75 179.43,123.62 Q7.4
  BOTTOM w0.127: v2(179.56,124.5) 179.73,124.68 179.73,126.16 180.03,126.46 UC3.7
SMBALERT#: length 136
  TOP w0.127: R5236.1 93.45,11.58 93.59,11.45 94.48,11.45 94.94,11.9 94.94,13.01 94.48,13.46 93.85,13.46 v2(93.12,14.19) 93.12,14.2 v1(92.59,14.73)
  IN2 w0.127: v2(203.36,16.05) 203.08,15.77 197.52,15.77 197.35,15.6 194.1,15.6 193.53,16.17 192.13,16.17 191.95,16.35 189.96,16.35 188.95,15.34 187.73,15.34 187.1,15.97 184.03,15.97 180.86,19.13 169.29,19.13 167.82,17.67 153.99,17.67 152.73,16.41 150.78,16.41 149.64,15.27 144.06,15.27 142.76,13.97 135.68,13.97 134.58,15.07 133.78,15.07 133.4,15.44 131.91,15.44 131.53,15.07 128.03,15.07 127.88,15.22 125.72,15.22 125.12,14.62 119.13,14.62 117.71,13.19 115.37,13.19 v2(114.84,13.73)
  BOTTOM w0.127: v2(93.12,14.19) 93.12,14.34 93.45,14.66 94.51,14.66 94.77,14.4 94.77,13.08 95.94,11.91 96.36,11.91 97.98,10.29 98.13,10.29 100.06,8.36 113.34,8.36 114.84,9.87 v2(114.84,13.73) ; UH1.BE25 202.78,18.53 202.78,16.82 203.36,16.24 v2(203.36,16.05) 203.36,15.79 203.56,15.59 RH95.2
SMBUS_CLK: length 83.4
  TOP w0.127: v2(172.1,35.81) 174.18,33.73 v1(174.18,32.23) 174.18,31.19 170.58,27.59 170.58,26.96 171,26.54 173.84,26.54 176.2,24.18 176.2,16.02 176.71,15.52 176.71,14.96 176.27,14.51 v2(176.04,14.51) ; v2(203.35,13.51) 203.35,12.84 203.71,12.47 RC377.1 QC8.1
  IN2 w0.127: v2(176.04,14.51) 180.78,14.51 182.45,12.85 186.71,12.85 187.47,12.09 190.37,12.09 190.89,12.61 197.08,12.61 197.35,12.88 200.17,12.88 201.25,13.96 202.9,13.96 v2(203.35,13.51)
  IN3 w0.127: v2(172.1,35.81) 172.1,36.29 173.58,37.77 173.58,43.72 v2(173.19,44.12)
  BOTTOM w0.127: v2(173.19,44.12) 172.24,44.12 170.93,45.43 170.93,47.43 169.03,49.34 JDIMM1.253 ; JDIMM2.253 167.53,36.67 168.08,36.12 169.35,36.12 169.87,35.6 171.89,35.6 v2(172.1,35.81)
SMBUS_DAT: length 85.5
  TOP w0.127: v2(171.95,35.05) 172.25,35.05 173.75,33.55 173.75,31.37 170.15,27.77 170.15,26.78 170.82,26.11 173.66,26.11 175.72,24.05 175.72,15.9 176.2,15.41 v2(176.2,15.18) ; v2(206.14,13.72) 206.14,14.14 205.24,15.03 QC8.4 206.08,16.22 RC376.1
  IN2 w0.127: v2(176.2,15.18) 180.73,15.18 182.63,13.28 186.89,13.28 187.65,12.52 190.19,12.52 190.71,13.04 196.9,13.04 197.2,13.34 197.2,13.76 197.82,14.39 205.47,14.39 v2(206.14,13.72)
  IN3 w0.127: v2(171.95,35.05) 171.65,35.35 171.65,36.45 173.15,37.95 v2(173.15,43.47)
  BOTTOM w0.127: v2(171.95,35.05) 171.63,35.05 170.85,34.26 170.85,34.08 171.18,33.75 171.18,33.04 170.67,32.54 168.93,32.54 168.39,32 168.39,31.35 167.78,30.73 JDIMM2.254 ; JDIMM1.254 169.27,42.98 169.98,43.68 171.77,43.68 171.99,43.47 v2(173.15,43.47)
SNB_1.8V: length 2.3
  BOTTOM w0.127: v1(264.16,17.48) PR1802.2
  BOTTOM w0.508: PR1802.2 264.34,18.52 PC1806.1
SNB_1.35VSDGPUP: length 1
  BOTTOM w0.127: PCW6.1 v1(261.31,59.68)
SNB_2.5V: length 2.7
  TOP w0.127: PR2505.2 110.53,19.66 111.08,20.2 111.42,20.2 111.71,20.5 v1(111.71,20.6)
  TOP w0.508: PC2503.1 109.79,19.66 PR2505.2
SNB_CHG: length 4.4
  TOP w0.127: v1(256.85,8.65) 256.66,8.65 PRB21.2
  TOP w0.508: PRB21.2 254.27,6.26 PCB18.1
SNB_DDR: length 2.6
  TOP w0.127: v1(95.97,30.69) PCM14.1
  TOP w0.508: PCM14.1 94.01,30.69 PRM3.2
SNB_GT: length 3.2
  TOP w0.127: PRG2.2 108.67,96.54 v1(108.45,96.76)
  TOP w0.508: PCG7.1 110.65,95.7 PRG2.2
SNB_INVPWR: length 2.6
  TOP w0.127: v1(86.5,37.44) PRP6.1
  TOP w0.508: PCP7.1 86.12,35.45 86.5,35.83 PRP6.1
SNB_PH2: length 1.5
  TOP w0.508: PCZ54.1 143.34,125.75 PRZ83.2
SNB_PH4: length 1.8
  TOP w0.127: PRZ89.2 v1(124.44,129.21)
SNDW2_CLK: length 3.9
  BOTTOM w0.102: 208.16,17.03 208.15,17.03 208.15,18 208.35,18.19 208.35,18.92 UH1.BD12
  BOTTOM w0.127: 208.16,17.03 208.16,16.05 208.13,16.02 208.13,15.9 TH121.1
SNDW2_DATA: length 4.5
  BOTTOM w0.102: UH1.BE12 208.54,18.53 208.54,18.11 208.34,17.92 208.34,17.66 208.38,17.63 208.38,17.03
  BOTTOM w0.127: TH120.1 208.65,14.9 208.65,14.93 208.38,15.21 208.38,17.03
SNUB_1V05: length 3.9
  TOP w0.127: v1(230.67,25.73) PR1013.2
  TOP w0.508: PC1003.1 232.35,25.74 PR1013.2
SNUB_VCCIOP: length 3.1
  TOP w0.127: v1(180.34,110.35) 181.48,110.35 181.97,110.85
  TOP w0.508: PCH2.1 181.42,111.29 181.53,111.29 181.97,110.85
SPK_DET#: length 128
  TOP w0.127: RH191.1 190.74,27.17 v3(191.41,27.17) v2(193.29,27.17)
  IN2 w0.127: v2(278.29,38.99) 278.29,38.72 276.25,36.69 259.59,36.69 257.15,34.25 253.34,34.25 252.34,35.24 248.28,35.24 247.23,34.19 243.51,34.19 242.65,35.05 228.89,35.05 218.89,25.04 217.95,25.04 216.96,24.05 216.59,24.05 216.02,23.49 214.05,23.49 213.76,23.77 209.72,23.77 209.44,23.49 208.39,23.49 207.14,22.24 205.12,22.24 v2(205,22.36)
  IN3 w0.127: v2(205,22.36) 204.54,22.82 204.54,24.38 203.26,25.66 200.22,25.66 199.95,25.92 196.78,25.92 196.52,26.18 196.52,26.59 196.19,26.92 193.54,26.92 v2(193.29,27.17)
  BOTTOM w0.102: UH1.AM47 192.07,25.38 192.33,25.38 192.79,25.84 192.79,26.66 v2(193.29,27.17)
  BOTTOM w0.127: JSPK1.5 297.8,45.38 297.55,45.13 297.55,44.36 297.18,43.99 292.06,43.99 291.53,44.51 282.38,44.51 278.29,40.42 v2(278.29,38.99)
SPK_L+_CONN: length 4.3
  TOP w1.016: RA33.2 294.02,43.23 296.56,43.23 296.87,42.92 DA9.3
  vias: v2(298.07,44.59) v2(298.66,44.59) v3(298.32,45.13)
SPK_L-_CONN: length 7.2
  TOP w1.016: 299.66,43.99 v3(299.66,42.82) 299.66,42.05 299,41.39 ; RA32.2 294.15,40.78 297.63,40.78 DA9.2
  vias: v2(299.38,44.71) v2(299.95,44.71)
SPK_OUT_L+: length 27.5
  IN3 w1.016: 288.58,21.87 287.83,22.62 287.83,24.89 290.66,27.71 292.94,27.71 295.77,30.54 295.77,38.92 292.41,42.28 292.41,43.05
  vias: v2(290.38,21.38) v2(290.78,43.11) v2(290.94,21.38) v2(291.37,43.11) v3(290.33,42.67)
SPK_OUT_L-: length 25.6
  IN3 w1.016: 292.26,40.38 294.5,38.14 294.5,31.06 292.42,28.98 290.08,28.98 286.51,25.41 286.51,22.05 287.65,20.9
  vias: v2(290.12,20.75) v2(290.68,20.75) v2(290.78,41.15) v2(291.37,41.15) v3(290.31,40.75)
SPK_OUT_R+: length 42.4
  IN3 w1.016: 289.95,40.46 287.47,40.46 286.39,39.38 280.9,39.38 276.61,35.09 276.61,30.37 278.64,28.34 282.34,28.34 283.1,27.58 283.1,20.03 285.19,17.94 288.93,17.94 289.11,18.13
  vias: v2(289.84,19.1) v2(290.4,19.1) v2(290.72,39.36) v2(291.3,39.36) v3(290.76,38.78)
SPK_OUT_R-: length 35.3
  IN3 w1.016: 288.13,19.31 285.79,19.31 284.45,20.65 284.45,28.08 282.87,29.66 279.19,29.66 277.99,30.87 277.99,34.51 281.2,37.72 287.74,37.72 288.64,38.62
  vias: v2(289.04,39.36) v2(289.63,39.36) v2(289.97,19.99) v2(290.53,19.99) v3(290.58,36.98)
SPK_R+_CONN: length 8.8
  TOP w1.016: 300.94,43.77 v3(300.94,41.22) 299.52,39.8 ; DA8.3 297.54,39.13 RA31.2
  vias: v2(300.63,44.71) v2(301.24,44.71)
SPK_R-_CONN: length 11.9
  TOP w1.016: 302.28,43.72 302.28,40.29 v3(301.18,39.2) 299.43,37.45 ; DA8.2 297.59,36.64 294.42,36.64 RA30.2
  vias: v2(301.92,44.71) v2(302.51,44.71)
SPOK: length 322.7
  TOP w0.127: v2(14.2,81.17) 14.52,81.49 v1(16.27,81.49) 17.64,81.49 17.91,81.22 17.91,80.58 18.1,80.4 QS1.5 ; DH3.1 188.19,14.15 v2(188.19,13.64)
  IN2 w0.127: v2(14.2,81.17) 14.6,80.77 14.6,78.85 15.31,78.14 15.31,75.57 16.22,74.66 16.22,69.92 16.52,69.61 16.52,66.7 15.86,66.03 15.86,63.9 12.75,60.79 12.75,57.22 15.37,54.6 18.4,54.6 24.26,48.73 30.03,48.73 31.69,47.06 33.23,47.06 34.44,45.85 35.57,45.85 38.35,43.07 38.35,40.56 39.86,39.05 41.86,39.05 42.38,38.52 46.26,38.52 46.95,37.82 51.56,37.82 52.28,37.11 52.28,36.09 53.47,34.9 53.47,28.66 58.56,23.57 58.56,23.42 58.85,23.14 60.63,23.14 66.06,17.71 74.73,17.71 76.63,15.81 v2(76.85,15.81) 77.56,16.52 98.85,16.52 102.02,13.36 103.51,13.36 104.41,14.26 108.81,14.26 110.22,12.85 117.75,12.85 119.12,14.22 125.31,14.22 125.84,13.69 126.86,13.69 127.43,14.26 132.08,14.26 133.17,13.17 143.09,13.17 144.31,14.4 151.08,14.4 151.5,14.82 152.27,14.82 154.31,16.86 168.16,16.86 169.09,17.79 181.83,17.79 185.36,14.25 187.29,14.25 187.9,13.64 v2(188.19,13.64) 188.19,13.84 188.6,14.25 190.57,14.25 190.73,14.09 192.7,14.09 193.94,15.33 197.46,15.33 197.63,15.5 207.82,15.5 208.46,16.14 208.46,18.37 210.27,20.18 211.07,20.18 211.87,20.98 213.27,20.98 213.68,21.39 215.88,21.39 216.84,22.36 217.79,22.36 218.41,22.97 219.46,22.97 220.65,24.17 220.65,25.48 229.42,34.24 242.32,34.24 243.18,33.38 247.56,33.38 248.62,34.44 251.97,34.44 v2(253.38,33.02)
  BOTTOM w0.127: PR303.2 252.65,34.19 252.65,33.46 PR314.2 252.95,33.46 v2(253.38,33.02) ; v2(76.85,15.81) 76.38,15.81 74.21,13.63 PR309.2
SPOK#: length 1
  TOP w0.127: RS40.2 v1(17.33,77.79)
SPOK_3V: length 4.4
  BOTTOM w0.127: v1(253.59,32.5) 253.54,32.54 PR314.1
  BOTTOM w0.254: PR314.1 252.48,32.38 250.15,32.38 249.9,32.13 PU301.9
SPOK_5V: length 6.3
  BOTTOM w0.127: PU302.4 74.35,9.09 74.07,9.37 74.07,11.73 PR309.1 74.21,11.88 73.73,12.35 73.73,14.04 v1(74.22,14.54)
SRN_R: length 31.8
  TOP w0.254: v2(247.9,5.44) 247.13,6.21 245.84,6.21 v1(244.99,5.36) 244.33,4.7 240.98,4.7 240.32,5.36 PRB22.2
  IN3 w0.254: v2(268.26,7.2) 268.01,7.2 265.96,5.16 260.6,5.16 259.95,5.81 249.18,5.81 249.07,5.92 248.38,5.92 v2(247.9,5.44)
  BOTTOM w0.254: v2(268.26,7.2) 268.59,6.87 PRB08.3
SRP_R: length 30.4
  TOP w0.254: v2(248.58,5.44) v1(247.95,6.07) 247.4,6.62 245.62,6.62 244.09,5.09 241.64,5.09 PRB20.2
  IN3 w0.254: v2(268.17,6.61) 266.26,4.71 260.31,4.71 259.69,5.32 248.7,5.32 v2(248.58,5.44)
  BOTTOM w0.254: v2(268.17,6.61) 267.91,6.87 PRB08.2
SSD1_IF: length 197.3
  TOP w0.127: Q79.1 22.15,6.63 R5219.1 22,7.6 21.63,7.6 21.42,7.81 21.42,8.41 21.62,8.62 v1(22.57,8.62) 22.76,8.81 34.19,8.81 34.68,9.29 39.29,9.29 43.05,13.05 45.56,13.05 46.69,14.19 52.88,14.19 53.31,13.76 53.88,13.76 54.69,12.96 56.85,12.96 60.52,16.63 61.55,16.63 64.32,19.4 64.32,20.43 65.28,21.39 65.28,22.09 65.48,22.29 66.15,22.29 v2(66.3,22.14)
  IN2 w0.127: v2(193.84,27.37) 193.5,27.71 192.82,27.71 192.38,27.27 189.25,27.27 188.33,26.35 187.33,26.35 186.77,25.79 186.28,25.79 185.49,26.58 185.49,27.04 184.5,28.04 183.15,28.04 180.6,25.49 180.02,25.49 175.82,21.29 168.39,21.29 167.68,20.57 161.54,20.57 160.21,21.91 152.98,21.91 151.44,20.37 147.02,20.37 145.8,19.15 142.85,19.15 141.08,17.38 135.54,17.38 134.43,18.49 127.83,18.49 126.87,17.52 124.47,17.52 123.85,18.14 122.76,18.14 121.99,17.37 120.85,17.37 120.43,16.95 118.31,16.95 118.02,16.66 115.2,16.66 114.62,17.25 112.62,17.25 110.01,19.87 87.44,19.87 84.47,22.83 73.22,22.83 72.4,23.65 67.77,23.65 66.3,22.19 v2(66.3,22.14)
  BOTTOM w0.127: v2(193.84,27.37) 193.84,27.37 UH1.AJ43
STRAP0: length 12.6
  BOTTOM w0.102: UG1.J2 212.84,76.2 212.84,75.31
  BOTTOM w0.127: 212.84,75.31 215.3,72.85 216.42,72.85 217.18,72.09 217.18,71.09 v1(218.11,70.17) 218.39,69.88 218.39,68.82 218.8,68.41 RG122.2 219.43,68.03 RG124.1
STRAP1: length 31.9
  TOP w0.102: 219.8,74.52 219.8,74.71 218.71,75.8 218.71,76.23 217.37,77.57 217.37,78.24 217.51,78.38 217.51,79.48 217.14,79.86 216.49,79.86 216.44,79.81 213.94,79.81 v2(213.55,80.2)
  TOP w0.127: v2(231.41,62.91) 231.3,63.02 v1(231.3,64.29) 231.3,66.49 224.17,73.62 220.45,73.62 219.8,74.28 219.8,74.52
  BOTTOM w0.109: UG1.J7 213.18,80.57 v2(213.55,80.2)
  BOTTOM w0.127: v2(231.41,62.91) 231.41,63.18 RG123.2 231.93,63.43 231.93,62.42 RG125.1
STRAP2: length 28.4
  TOP w0.102: v2(213.54,79.35) 214.05,78.84 214.05,78.36 214.85,77.56 214.85,76.77 215.09,76.53 215.89,76.53 217.69,74.74 217.69,74.65 218.13,74.2
  TOP w0.127: 218.13,74.2 218.66,73.68 219.66,73.68 220.24,73.1 223.95,73.1 229.59,67.46 v1(229.59,64.04) 229.59,63.42 v2(229.48,63.31)
  BOTTOM w0.109: v2(213.54,79.35) 213.54,79.43 213.18,79.79 UG1.J6
  BOTTOM w0.127: v2(229.48,63.31) 229.74,63.56 RG118.2 230.1,63.55 230.1,62.42 RG126.1
STRAP3: length 28.1
  TOP w0.102: 217.94,74.02 217.4,74.56 217.4,74.69 215.79,76.3 214.99,76.3 214.61,76.67 214.61,77.29 213.58,78.32 v2(213.58,78.55)
  TOP w0.127: 217.94,74.02 218.55,73.41 219.55,73.41 220.13,72.84 223.84,72.84 229.11,67.57 v2(229.11,65.09)
  BOTTOM w0.102: UG1.J5 v2(213.58,78.55)
  BOTTOM w0.127: v1(229.11,65.67) v2(229.11,65.09) 229.13,65.09 229.59,64.62 229.59,64.14 229.06,63.61 229.06,63.45 RG133.2 228.43,62.98 RG127.1
STRAP4: length 30.6
  TOP w0.102: v2(213.57,76.95) 214.7,75.83 215.6,75.83 216.07,75.35 216.07,74.52 216.31,74.28 216.94,74.28
  TOP w0.127: 216.94,74.28 218.33,72.89 219.34,72.89 219.91,72.32 223.62,72.32 228.43,67.51 228.43,65.24 v2(228.27,65.09)
  BOTTOM w0.109: v2(213.57,76.95) UG1.J3
  BOTTOM w0.127: RG128.1 225.44,63.91 RG134.2 224.53,64.07 224.15,64.45 224.15,65.66 224.88,66.39 v1(225.77,66.39) 226.23,66.39 227.54,65.09 v2(228.27,65.09)
STRAP5: length 10.2
  BOTTOM w0.127: RG129.1 220.51,70.69 RG135.2 217.99,70.69 217.53,71.15 v1(217.53,71.34) 217.53,72.11 216.53,73.11 215.41,73.11 213.18,75.34 UG1.J1
SUS_STAT#: length 2.6
  BOTTOM w0.127: UH1.BF38 196.19,18.24 196.19,15.91 TH4950.1
SUSACK#: length 78.3
  TOP w0.127: v2(145.18,13.92) 145.18,12.97 142.5,10.29 142.5,9.44 142.84,9.1 UK1.15
  IN1 w0.127: v2(198.11,13.71) 196.66,12.26 196.24,12.26 193.28,9.3 185.49,9.3 185.19,9 181.94,9 180.9,7.96 178.62,7.96 178,7.33 178,6.99 178.3,6.69 178.3,5.65 177.28,4.63 168.44,4.63 168.15,4.93 168.15,6.77 168.32,6.95 170.22,6.95 v2(170.46,6.71)
  BOTTOM w0.127: RH177.1 197.64,14.19 ; v2(170.46,6.71) 170.29,6.88 170.29,9.73 167.41,12.61 165.22,12.61 163.7,14.13 151.65,14.13 150.41,12.89 146.21,12.89 v2(145.18,13.92)
  BOTTOM w0.135: 197.64,14.19 v2(198.11,13.71)
SUSACK#_R: length 4.4
  BOTTOM w0.102: 197.52,17.41 197.35,17.59 197.35,18.97 UH1.BE35
  BOTTOM w0.127: RH177.2 197.64,15.79 197.73,15.87 197.73,17.21 197.52,17.41
SUSCLK: length 132.5
  TOP w0.135: v2(306.66,9.01) 307.24,9.6 308.3,9.6 v1(309.29,10.59) 309.64,10.95 310.49,10.95 310.88,11.33 RWL5.2
  IN1 w0.127: v2(306.66,9.01) 306.66,8.21 304.59,6.14 301.1,6.14 299.86,4.89 283.43,4.89 275.07,13.25 274.57,13.25 273.68,14.15 265.41,14.15 264.69,13.43 254.35,13.43 253.8,13.98 248.27,13.98 247.63,13.34 243.9,13.34 243.12,12.56 236.87,12.56 236.42,13.01 231.07,13.01 230.29,12.23 228.57,12.23 227.99,12.81 225.52,12.81 224.74,12.03 222.18,12.03 221.75,11.6 210.18,11.6 204.69,17.09 204.69,17.36 203.77,18.28 194.14,18.28 192.77,19.65 v2(192.35,19.65)
  BOTTOM w0.127: UH1.BE45 192.35,19.07 v2(192.35,19.65)
SUSP#: length 434.6
  TOP w0.127: UC6.4 111.64,86.55 111.01,85.92 111.01,85.32 110.53,84.83 110.53,83.02 109.53,82.02 109.53,74.53 v2(110.19,73.88) ; UK1.116 134.79,14.62 134.35,14.18 134.35,13.96 v2(134.14,13.75) 133.9,13.51 RK27.1 ; v2(184.08,98.3) 182.2,100.18 182.2,101.62 182.75,102.17 182.75,103.99 182.45,104.29 182.45,106.46 181.37,107.54 RC373.1 ; PRP2.1 v2(78.29,32.79) ; v2(271.49,44.79) 271.49,44.39 R5253.1 270.64,43.54 v3(270.64,40.38) 269.55,39.29 267.51,39.29 267.41,39.39 259.11,39.39 255.61,35.89 RC371.1
  IN2 w0.127: v2(271.49,44.79) 271.49,45.48 270.36,46.61 266.17,46.61 264.9,45.34 264.9,43.66 261.45,40.22 258.08,40.22 257.14,41.15 255.62,41.15 253.77,43.01 250.17,43.01 249.29,43.89 240.01,43.89 239.29,44.61 239.29,47.46 236.23,50.52 231.79,50.52 230.45,49.17 224.38,49.17 221.47,52.08 195.69,52.08 192.65,55.12 192.65,70.14 193.52,71.01 193.52,73.54 191.19,75.87 191.19,76.65 v2(191.42,76.88) ; v2(110.19,73.88) 109.39,74.67 104.28,74.67 100.71,71.11 98.94,67.75 97.72,65.34 95.22,61.94 95.2,61.91 94.63,61.13 94.63,58.65 87.59,51.62 87.59,46.93 85.12,44.46 83.24,44.46 80.89,42.1 78.55,42.1 78.35,41.9 77.22,41.9 76.75,41.43 76.75,34.32 v2(78.29,32.79) ; v2(79.09,26.16) 79.45,25.8 81.29,25.8 83.5,23.59 87.38,23.59 90.56,20.4 95.13,20.4 v2(95.3,20.57)
  IN3 w0.127: v2(95.3,20.57) 92.7,17.97 92.7,13.97 95.34,11.33 100.66,11.33 102.73,13.4 102.73,14.29 102.99,14.55 103.75,14.55 104.67,15.47 111.9,15.47 112.55,14.82 114.39,14.82 114.54,14.97 119.61,14.97 120.07,14.52 125.12,14.52 125.82,15.22 127.35,15.22 128.58,13.99 131.58,13.99 132.04,13.52 133.91,13.52 v2(134.14,13.75) ; v2(191.42,76.88) 191.42,77.25 190.74,77.92 190.74,82.32 190.97,82.55 192.66,82.55 192.95,82.84 192.95,83.54 191.71,84.78 v2(189.67,84.78) 189.67,87.31 185.08,91.89 185.08,97.29 v2(184.08,98.3) ; v2(79.09,26.16) 78.8,26.45 78.8,27.28 77.55,28.53 77.55,31.77 78.29,32.51 v2(78.29,32.79)
  BOTTOM w0.127: PRM11.1 94.43,22.24 94.65,22.02 95.09,22.02 95.3,21.8 v2(95.3,20.57) ; v2(110.19,73.88) 110.19,71.38 114.82,66.74 159.15,66.74 174.39,81.98 178.24,81.98 181.1,84.84 189.61,84.84 v2(189.67,84.78) ; PRH5.1 184.05,98.32 v2(184.08,98.3)
SW1_2PH: length 89.3
  TOP w0.127: v2(120.81,124.79) 121.29,125.27 v1(121.29,130.83) 121.29,132.99 123.98,135.68 158.07,135.68 158.93,136.55 162.34,136.55 162.77,136.12 164.24,136.12 v2(164.29,136.17)
  TOP w0.254: PRZ52.2 164.97,135.49 v2(164.29,136.17)
  IN3 w0.127: v2(112.13,100.87) 112.25,100.99 112.25,104.7 116.95,109.4 116.95,110.73 118.2,111.99 119.82,111.99 125.05,117.22 125.05,121.28 123.32,123.01 121.75,123.01 120.96,123.8 120.96,124.64 v2(120.81,124.79)
  BOTTOM w0.127: PLG1.2 111,100.87 v2(112.13,100.87)
  BOTTOM w0.254: v2(164.29,136.17) 164.48,135.99 PRZ66.2
SW1_4PH: length 29.2
  TOP w0.127: v1(167.56,119.33) 167.07,119.81 v2(167.06,119.81)
  TOP w0.254: v2(167.06,119.81) 167.72,120.47 PRZ48.1
  IN3 w0.152: v2(167.06,119.81) 164.67,117.42 149.81,117.42 148.93,118.31 v2(148.93,119.4)
  BOTTOM w0.254: v2(148.93,119.4) 149.69,120.17 151.85,120.17 152.1,120.42 PLZ1.2 ; PRZ59.1 167.72,120.47 v2(167.06,119.81)
SW2_4PH: length 28.8
  TOP w0.127: v2(165.94,119.91) v1(165.94,119.26)
  TOP w0.254: PRZ51.1 v2(165.94,119.91)
  IN3 w0.152: v2(147.78,119.4) 148.28,119.9 149.29,119.9 149.51,119.68 149.51,118.64 150.22,117.93 164.46,117.93 165.94,119.41 v2(165.94,119.91)
  BOTTOM w0.254: PLZ2.2 144.48,120.55 144.86,120.17 147.02,120.17 v2(147.78,119.4) ; PRZ67.1 v2(165.94,119.91)
SW3_4PH: length 44
  TOP w0.127: v2(164.17,119.91) v1(164.17,119.31)
  TOP w0.254: PRZ53.1 v2(164.17,119.91)
  IN3 w0.152: v2(133.43,119.66) 133.23,119.45 131.91,119.45 131.48,119.89 131.48,120.39 132.01,120.93 163.15,120.93 v2(164.17,119.91)
  BOTTOM w0.254: PLZ3.2 136.86,120.42 136.61,120.17 133.94,120.17 v2(133.43,119.66) ; PRZ70.1 v2(164.17,119.91)
SW4_4PH: length 39.9
  TOP w0.127: v1(162.46,119.29) 163.09,119.91 v2(163.28,119.91)
  TOP w0.254: PRZ54.1 163.28,119.97 v2(163.28,119.91)
  IN3 w0.152: v2(132.16,120.17) 132.42,120.42 162.77,120.42 v2(163.28,119.91)
  BOTTOM w0.254: v2(132.16,120.17) 129.62,120.17 129.24,120.55 PLZ4.2 ; PRZ73.1 162.59,120.6 v2(163.28,119.91)
SW_1PH: length 3.4
  TOP w0.127: v2(158.93,119.72) v1(158.93,118.79)
  TOP w0.254: v2(158.93,119.72) PRZ3.2
  BOTTOM w0.254: v2(158.93,119.72) 158.96,119.75 PLA1.2
SWTRAP: length 1.8
  TOP w0.127: UK1.70 147.64,25.12 RK34.2
SYS_PEX_RST_MON#: length 48.5
  TOP w0.102: v2(208.58,81.04) 209,80.62 209,79.98 209.3,79.68 209.3,78.8 210.07,78.03 210.07,77.43 210.2,77.3 210.2,76.63 211.81,75.02 213.49,75.02 213.88,74.64 213.88,74.3 214.22,73.96
  TOP w0.127: v2(223.74,62.54) RG34.2 223.13,62.83 223.33,63.03 224.21,63.03 224.52,62.72 225.25,62.72 226.01,63.47 226.01,66.89 223.19,69.71 223.09,69.71 v1(222.74,70.06) 222.58,70.22 216.64,70.22 214.22,72.64 214.22,73.96
  IN1 w0.127: v2(223.74,62.54) 228.53,62.54 229.91,61.15 231.12,61.15 231.44,60.83 v2(232.29,60.83)
  BOTTOM w0.127: UG1.R8 v2(208.58,81.04) ; v2(232.29,60.83) 232.46,60.67 232.46,60.44 RG15.1 232.96,59.41 233.54,58.82 UG13.1 234.97,58.82 235.51,58.28 RG99.1
SYS_PWROK: length 131.7
  TOP w0.127: v2(222.49,9.99) 222.49,14.24 v3(223.01,14.76) 224.27,16.02 224.27,18.72 222.74,20.25 218.87,20.25 217.87,21.25 217.87,23.51 CH72.2 216.81,23.48 216.81,23.27 v2(216.55,23.01) ; CK15.1 146.69,25.03 146.23,25.03 146.04,24.83 UK1.74 146.04,21.11 v2(146,21.08)
  BOTTOM w0.102: UH1.AU3 213.54,22.58 213.95,22.58 214.55,21.97 215.22,21.97 216.26,23.01 v2(216.55,23.01)
  BOTTOM w0.127: v2(146,21.08) 146.95,20.13 146.95,17.8 146.54,17.39 145.6,17.39 143.48,15.27 143.48,13.23 144.35,12.36 150.63,12.36 151.87,13.6 163.48,13.6 165.01,12.08 167.2,12.08 169.76,9.52 169.76,6.22 170.35,5.64 223.02,5.64 224.02,6.64 224.02,8.18 222.49,9.71 v2(222.49,9.99)
SYS_RESET#: length 5.1
  TOP w0.102: CH71.2 v1(215.6,22.63) 215.32,22.35 v2(215.08,22.35) 215.08,21.91 215.12,21.87 RH213.2 215.12,20.39 CLRP3.2
  BOTTOM w0.102: v2(215.08,22.35) 214.57,22.35 214.08,22.83 UH1.AU2
SYSON: length 253.5
  TOP w0.127: v2(164.38,26.4) 164.38,23.94 164.69,23.63 164.69,23.11 165.48,22.32 165.48,20.57 172.81,13.23 172.97,13.23 173.71,12.49 175.06,12.49 177.66,9.89 184.84,9.89 186.55,8.18 v2(190.19,8.18) ; RC370.1 253.85,35.19 255.28,35.19 259.22,39.13 267.3,39.13 267.4,39.03 v3(272.41,39.03) 273.72,39.03 274.34,39.65 275.13,39.65 v2(275.6,39.18) ; v2(138.45,26.18) 138.45,26.07 137.97,25.59 CK9.1 ; UK1.95 137.64,24.84 137.25,25.23 CK9.1 ; CK9.1 RK23.1 ; v2(113.73,15.4) 113.33,15 113.33,14.08 112.13,12.88 108.13,12.88 107.84,13.18 PR2502.1
  IN2 w0.127: v2(275.45,25.93) 274.6,25.08 274.6,24.38 274.45,24.23 274.45,20.44 276,18.89 276,17.58 275.26,16.84 263.58,16.84 263.3,16.56 258.12,16.56 257.92,16.76 237.58,16.76 236.76,15.93 235.71,15.93 235.28,16.36 227.05,16.36 224.24,13.55 224.24,13.1 221.6,10.46 220.15,10.46 219.28,9.59 219.28,9.04 218.72,8.48 218.04,8.48 217.74,8.78 211.32,8.78 211.05,8.52 206.06,8.52 205.69,8.89 202.19,8.89 201.82,8.52 199.14,8.52 198.36,7.74 190.63,7.74 v2(190.19,8.18)
  IN3 w0.127: v2(164.38,26.4) 164.04,26.4 163.32,25.68 162.96,25.68 162.72,25.92 161.33,25.92 160.88,26.37 151.34,26.37 149.71,24.74 141.09,24.74 139.12,26.71 138.91,26.71 138.45,26.25 v2(138.45,26.18) 138.45,25.77 138.2,25.52 135.98,25.52 134.27,23.81 134.27,18.34 135.01,17.6 135.01,15.58 134.4,14.96 133.22,14.96 132.79,14.53 128.87,14.53 127.34,16.06 124.91,16.06 124.51,15.66 122.34,15.66 121.78,16.22 116.16,16.22 116.12,16.25 115.91,16.04 114.37,16.04 v2(113.73,15.4)
  BOTTOM w0.127: v2(275.45,25.93) 275.45,28.78 276.16,29.49 276.16,38.62 v2(275.6,39.18)
TBT_CIO_PLUG_EVENT#: length 4.8
  BOTTOM w0.102: UH1.AJ47 191.76,26.73 191.7,26.79 190.22,26.79 189.79,27.21 189.79,27.33
  BOTTOM w0.135: TH4964.1 188.97,29.06 188.98,29.06 189.79,28.24 189.79,27.33
TBT_FORCE_PWR: length 6.7
  BOTTOM w0.102: UH1.AJ46 192.08,26.51 191.72,26.51 191.62,26.6 189.86,26.6 189.48,26.98 189.48,27.63
  BOTTOM w0.135: TH4963.1 187.99,29.32 189.48,27.83 189.48,27.63
TBTC_ADCIN1: length 2.7
  TOP w0.203: RU72.1 41.82,44.22 42.23,44.22 42.39,44.06 UU4.6
  TOP w0.508: RU72.1 RU66.2
TBTC_ADCIN2: length 7.1
  TOP w0.127: UU4.10 42.89,42.46 41.81,43.53 38.24,43.53 37.98,43.26 RU73.1 37.97,42.95 RU67.2
TBTC_I2C_IRQ2Z: length 111.5
  TOP w0.127: v2(139.15,21.11) 140.04,21.99 UK1.89 ; v2(54.73,43.12) 54.08,43.12 53.67,43.53 53.08,43.53 RU51.2 51.56,42.97 51.45,42.86 UU4.34
  IN1 w0.127: v2(103,26.03) 102.56,26.47 101.25,26.47 100.84,26.89 99.46,26.89 98.81,27.54 96.28,27.54 94.49,25.74 91.37,25.74 90.03,27.09 87.24,27.09 85.41,28.91 70.62,28.91 68.12,31.41 68.12,41.91 65.35,44.68 57.68,44.68 56.24,43.23 54.84,43.23 v2(54.73,43.12)
  BOTTOM w0.127: v2(103,26.03) 103.74,26.77 106.02,26.77 107.59,25.21 110.1,25.21 111.14,24.17 114.29,24.17 115.94,22.51 124.48,22.51 125.36,21.63 127.57,21.63 128.31,22.37 132.68,22.37 133.84,21.2 139.05,21.2 v2(139.15,21.11)
TESTMODE: length 11
  BOTTOM w0.109: UG1.AK11 195.71,83.91 195.71,83.87 195.93,83.66 195.93,83.01 195.73,82.81 194.62,82.81 194.38,82.56 194.38,82.23 194.11,81.96 192.16,81.96 192,82.12 v2(191.38,82.12) 190.54,81.27 188.45,81.27 187.83,80.66 RG42.1
THERM_C_D+: length 375.3
  TOP w0.127: v2(58.68,18.07) 59.01,18.07 v1(59.55,18.62) 60.19,19.25 60.19,19.44 62.54,21.8 62.54,21.98 64.64,24.08 72.37,24.08 73.92,25.63 75.34,25.63 75.86,25.11 87.04,25.11 89.56,22.59 94.44,22.59 95.5,23.66 96.66,23.66 v2(97.34,22.97)
  IN3 w0.127: v2(180.21,120.57) 180.21,118.55 188.08,110.68 188.08,103.93 187.31,103.16 187.31,94.35 188.95,92.72 188.95,88.79 193.49,84.25 193.49,82.01 192.13,80.66 191.76,80.66 191.28,80.18 191.28,78.15 192.17,77.26 192.17,76.83 192.96,76.04 192.96,71.43 v2(193.08,71.31) ; v2(58.68,18.07) 57.62,19.13 57.62,21.3 57.17,21.75 55.58,21.75 54.1,23.23 50.98,23.23 50.15,24.05 50.15,34.34 49.37,35.12 49.37,35.55 49.01,35.91 45.15,35.91 44.27,36.79 39.01,36.79 38.06,37.74 38.06,43.51 35.01,46.56 34.11,46.56 32.55,48.12 32.55,48.87 31.81,49.62 30,49.62 29.34,50.28 24.78,50.28 20.99,54.07 20.99,61.71 19.34,63.35 18.81,63.35 17.99,64.18 17.99,65.93 18.7,66.64 18.7,69.8 18.24,70.25 18.24,73.3 17.39,74.15 17.39,84.6 18.28,85.49 18.28,115.34 16.52,117.11 16.52,119.44 16.25,119.71 16.25,121.06 v2(16.16,121.15)
  BOTTOM w0.127: v2(16.16,121.15) 15.65,121.66 QC12.1 14.88,121.01 QC12.2 ; v2(180.21,120.57) 180.21,121.27 CV273.1 180.03,121.77 UC3.2 ; v2(97.34,22.97) 98.43,24.06 98.43,24.93 99.67,26.17 99.67,27.06 100.26,27.65 100.26,28.63 98.14,30.75 98.14,35.26 100.11,37.22 100.11,51.7 101.88,53.48 106.07,53.48 114.33,61.74 162.08,61.74 169.42,69.07 178.57,69.07 180.24,70.75 188.6,70.75 189.64,69.72 191.78,69.72 192.24,70.17 192.24,71.03 192.52,71.31 v2(193.08,71.31)
THERM_C_D-: length 378.2
  TOP w0.127: v2(96.63,22.97) 96.2,23.39 95.61,23.39 94.54,22.32 89.45,22.32 86.93,24.85 75.75,24.85 75.23,25.37 74.03,25.37 72.48,23.82 64.74,23.82 62.8,21.88 62.8,20.51 v1(61.65,19.36) 60.43,18.14 59.63,18.14 v2(59.05,17.55)
  IN3 w0.127: v2(192.73,70.82) 192.6,70.95 192.6,74.26 191.56,75.3 191.56,76.35 191.9,76.7 191.9,77.14 191.01,78.04 191.01,80.29 191.64,80.92 192.02,80.92 193.22,82.13 193.22,84.14 188.68,88.68 188.68,92.61 187.04,94.24 187.04,103.28 187.81,104.04 187.81,110.57 179.85,118.53 179.85,120.29 v2(179.6,120.55) ; v2(13.93,123.17) 14,123.1 14,121.35 15.53,119.82 15.76,119.82 16.25,119.33 16.25,117 17.81,115.43 17.81,85.4 17.12,84.71 17.12,74.04 17.98,73.18 17.98,70.14 18.43,69.69 18.43,66.75 17.72,66.05 17.72,64.07 18.7,63.09 19.23,63.09 20.68,61.64 20.68,54 24.67,50.01 29.23,50.01 29.89,49.35 31.69,49.35 32.29,48.76 32.29,48.01 34,46.29 34.9,46.29 37.79,43.4 37.79,37.63 38.9,36.52 44.16,36.52 45.04,35.64 48.9,35.64 49.1,35.44 49.1,35 49.88,34.23 49.88,23.94 50.87,22.96 53.99,22.96 55.47,21.48 57.05,21.48 57.35,21.19 57.35,18.62 58.41,17.55 v2(59.05,17.55)
  BOTTOM w0.127: v2(179.6,120.55) 179.54,120.6 179.54,121.35 CV273.2 179.38,121.51 UC3.3 ; QC12.3 v2(13.93,123.17) ; v2(192.73,70.82) 192.73,70.82 192.73,70.29 191.89,69.45 189.53,69.45 188.5,70.48 180.35,70.48 178.68,68.81 169.52,68.81 162.19,61.48 114.44,61.48 106.18,53.22 101.99,53.22 100.37,51.6 100.37,37.12 98.41,35.15 98.41,30.86 100.53,28.74 100.53,27.55 99.93,26.95 99.93,26.06 98.69,24.82 98.69,23.72 97.47,22.51 97.09,22.51 v2(96.63,22.97)
TMDS_SNK_ML0_N: length 16.9
  BOTTOM w0.102: JHDMI1.9 11.1,110.8 11.24,110.8 11.38,110.94 11.38,116.09 11.86,116.56 12.83,116.56 13.29,116.1 13.29,113.33 14.66,111.97 14.82,111.97 14.87,112.02 DV2.9 DV2.1 16.49,112.02 16.52,111.99 16.98,111.99 RV45.2 17.66,112.06 17.93,112.06 RV15.2
TMDS_SNK_ML0_N_R: length 58
  IN1 w0.102: v2(19.45,112.4) 19.3,112.25 18.94,112.25 17.18,110.49 17.18,105.41 16.64,104.88 16.64,101.21 18.05,99.81 18.05,91.3 18.24,91.1 18.24,83.25 18.95,82.53 18.95,78.38 19.21,78.13 19.21,74 20.6,72.6 20.6,70.8 22.04,69.37 22.04,68.22 22.78,67.47 23.92,67.47 24.44,67.99 24.44,68.57 24.63,68.76 24.78,68.76 v2(24.98,68.56)
  BOTTOM w0.102: RV15.1 18.83,112.21 19.26,112.21 v2(19.45,112.4) ; UV2.16 24.86,64.75 24.91,64.8 24.91,65.95 24.76,66.1 24.76,66.98 v5(25.12,67.34) 25.4,67.62 25.4,68.66 25.3,68.76 25.19,68.76 v2(24.98,68.56)
TMDS_SNK_ML0_P: length 16.9
  BOTTOM w0.102: JHDMI1.7 11.1,110.5 11.37,110.5 11.69,110.82 11.69,115.96 11.99,116.26 12.71,116.26 12.99,115.98 12.99,113.46 12.99,113.46 12.99,113.2 14.53,111.66 14.78,111.66 14.92,111.52 DV2.8 DV2.2 16.43,111.52 16.6,111.69 17.12,111.69 RV45.1 17.65,111.75 17.94,111.75 RV13.2
TMDS_SNK_ML0_P_R: length 58
  IN1 w0.102: v2(24.98,69.27) 24.78,69.07 24.51,69.07 24.13,68.69 24.13,68.11 23.79,67.77 22.91,67.77 22.34,68.34 22.34,69.49 20.91,70.93 20.91,72.73 19.51,74.13 19.51,78.26 19.26,78.51 19.26,82.66 18.55,83.37 18.55,91.23 18.35,91.43 18.35,99.93 16.95,101.34 16.95,104.75 17.48,105.29 17.48,110.36 19.07,111.95 19.32,111.95 v2(19.45,111.82)
  BOTTOM w0.102: RV13.1 18.57,111.71 18.57,111.84 18.63,111.91 19.36,111.91 v2(19.45,111.82) ; UV2.17 25.26,64.78 25.22,64.82 v5(25.22,65.67) 25.22,66.07 25.07,66.22 25.07,66.85 25.71,67.49 25.71,68.79 25.43,69.07 25.19,69.07 v2(24.98,69.27)
TMDS_SNK_ML1_N: length 6.7
  BOTTOM w0.102: RV12.2 17.93,108.76 17.66,108.76 RV44.2 16.98,108.69 16.46,108.69 16.43,108.72 DV3.1 DV3.9 14.92,108.72 14.84,108.64 14.84,108.65 13.71,108.65 13.03,109.33 12.62,109.33 JHDMI1.6
TMDS_SNK_ML1_N_R: length 51.7
  IN1 w0.102: v2(19.83,108.94) 19.76,108.86 19.34,108.86 18.7,108.22 18.7,104.92 18.06,104.29 18.06,101.8 18.46,101.4 21.26,98.61 21.26,91.69 20.98,91.41 20.98,84.34 21.38,83.95 21.38,79.59 20.86,79.07 20.86,75.69 21.91,74.64 21.91,73.75 22.99,72.67 22.99,71.35 23.82,70.52 24.31,70.52 v2(24.51,70.32)
  BOTTOM w0.102: UV2.19 26.06,64.73 26.11,64.78 v5(26.11,68.36) 26.11,69.47 25.06,70.52 24.72,70.52 v2(24.51,70.32) ; v2(19.83,108.94) 19.77,108.88 19.76,108.88 19.75,108.87 18.87,108.87 RV12.1
TMDS_SNK_ML1_P: length 6.7
  BOTTOM w0.102: RV10.2 17.94,108.45 17.65,108.45 RV44.1 17.12,108.39 16.55,108.39 16.38,108.22 DV3.2 DV3.8 14.84,108.22 14.71,108.34 13.59,108.34 12.91,109.02 12.67,109.02 JHDMI1.4
TMDS_SNK_ML1_P_R: length 51.7
  IN1 w0.102: v2(19.83,108.36) 19.63,108.56 19.47,108.56 19,108.09 19,104.8 18.37,104.16 18.37,101.93 18.59,101.71 18.59,101.71 21.56,98.73 21.56,91.56 21.29,91.28 21.29,84.47 21.68,84.07 21.68,79.47 21.16,78.95 21.16,75.81 22.21,74.77 22.21,73.88 23.3,72.79 23.3,71.48 23.95,70.83 24.31,70.83 v2(24.51,71.03)
  BOTTOM w0.102: RV10.1 18.64,108.34 18.64,108.49 18.71,108.56 19.63,108.56 v2(19.83,108.36) ; UV2.20 26.46,64.77 26.42,64.81 v5(26.42,66.93) 26.42,69.59 25.18,70.83 24.72,70.83 v2(24.51,71.03)
TMDS_SNK_ML2_N: length 8.4
  BOTTOM w0.102: JHDMI1.3 11.12,107.78 11.33,107.78 12.14,106.96 13.57,106.96 13.74,107.13 14.83,107.13 14.92,107.22 DV3.7 DV3.4 16.43,107.22 16.55,107.11 17.05,107.11 RV43.2 17.65,107.11 17.94,107.11 RV9.2
TMDS_SNK_ML2_N_R: length 49.9
  IN1 w0.102: v2(20.3,107.23) 20.27,107.19 19.78,107.19 19.41,106.83 19.41,101.93 21.97,99.37 21.97,91.38 21.72,91.13 21.72,89.28 22.16,88.84 22.16,79.36 21.57,78.78 21.57,75.98 22.62,74.93 22.62,74.04 23.7,72.96 23.7,72.16 24.04,71.82 24.36,71.82 v2(24.5,71.68)
  BOTTOM w0.102: UV2.22 27.26,64.75 27.31,64.8 27.31,67.87 26.97,68.21 v5(26.97,69.42) 26.97,69.96 25.15,71.78 24.61,71.78 v2(24.5,71.68) ; RV9.1 18.95,107.14 20.21,107.14 v2(20.3,107.23)
TMDS_SNK_ML2_P: length 8.4
  BOTTOM w0.102: JHDMI1.1 11.07,107.47 11.2,107.47 12.02,106.66 13.69,106.66 13.86,106.83 14.81,106.83 14.92,106.72 DV3.6 DV3.5 16.43,106.72 16.52,106.8 17.05,106.8 RV43.1 17.66,106.81 17.93,106.81 RV8.2
TMDS_SNK_ML2_P_R: length 49.9
  IN1 w0.102: v2(24.5,72.39) 24.5,72.26 24.37,72.13 24.17,72.13 24.01,72.29 24.01,73.09 22.92,74.17 22.92,75.06 21.87,76.11 21.87,78.65 22.46,79.24 22.46,88.96 22.02,89.4 22.02,91 22.28,91.25 22.28,99.49 19.72,102.05 19.72,106.7 19.91,106.89 20.06,106.89 v2(20.3,106.65)
  BOTTOM w0.102: RV8.1 19.01,106.83 20.12,106.83 v2(20.3,106.65) ; v2(24.5,72.39) 24.5,72.13 24.55,72.09 25.27,72.09 v5(26.7,70.66) 27.27,70.08 27.27,68.33 27.62,67.99 27.62,64.8 27.66,64.76 UV2.23
TMDS_SNK_ML3_N: length 7.7
  BOTTOM w0.102: JHDMI1.12 12.65,112.3 13.15,112.3 13.67,111.78 13.67,111.02 14.27,110.42 14.8,110.42 14.9,110.52 DV2.7 DV2.4 16.42,110.52 16.51,110.43 17.07,110.43 RV46.2 17.64,110.43 17.83,110.43 RV20.2
TMDS_SNK_ML3_N_R: length 53.4
  IN1 w0.102: v2(23.63,68.77) 23.53,68.87 23.17,68.87 22.75,69.29 22.75,69.66 21.47,70.95 21.47,72.75 19.97,74.25 19.97,79.19 20.67,79.89 20.67,83.65 20.27,84.05 20.27,90.08 18.76,91.59 18.76,99.77 18.76,99.77 18.76,100.1 17.35,101.51 17.35,104.58 17.99,105.22 17.99,109.24 19.3,110.55 19.69,110.55 v2(19.78,110.64)
  BOTTOM w0.102: RV20.1 19.02,110.49 19.64,110.49 v2(19.78,110.64) ; v2(23.63,68.77) 23.63,68.95 23.71,69.03 24,69.03 24.05,68.98 24.05,67.92 23.88,67.75 23.88,67.4 24.05,67.23 24.05,66.82 23.88,66.65 23.88,66.3 24.05,66.13 24.05,65.73 23.76,65.43 23.76,65.04 23.66,64.94 UV2.13
TMDS_SNK_ML3_P: length 7.7
  BOTTOM w0.102: JHDMI1.10 12.65,112 13.02,112 13.37,111.66 13.37,110.89 14.14,110.12 14.85,110.12 14.95,110.02 DV2.6 DV2.5 16.34,110.02 16.45,110.12 17.03,110.12 RV46.1 17.68,110.13 17.92,110.13 RV17.2
TMDS_SNK_ML3_P_R: length 53.5
  IN1 w0.102: v2(19.78,110.06) 19.78,110.13 19.67,110.24 19.43,110.24 18.29,109.11 18.29,105.09 17.66,104.46 17.66,101.63 18.3,100.99 19.06,100.23 19.06,99.64 19.06,91.72 20.58,90.21 20.58,84.18 20.97,83.78 20.97,79.76 20.27,79.06 20.27,77.66 20.42,77.52 20.42,77.11 20.27,76.97 20.27,76.57 20.42,76.42 20.42,76.02 20.27,75.87 20.27,75.47 20.42,75.32 20.42,74.92 20.27,74.78 20.27,74.37 20.99,73.65 21.2,73.65 21.48,73.37 21.48,73.16 21.77,72.88 21.77,72.17 21.91,72.02 21.91,71.62 21.77,71.48 21.77,71.07 22.28,70.56 22.48,70.56 22.77,70.28 22.77,70.07 23.05,69.79 23.05,69.42 23.3,69.17 23.49,69.17 23.63,69.3 v2(23.63,69.48)
  BOTTOM w0.102: RV17.1 19.06,110.19 19.65,110.19 v2(19.78,110.06) ; UV2.14 24.06,65.31 24.36,65.6 24.36,69.1 24.12,69.34 23.77,69.34 v2(23.63,69.48)
TON_DDR: length 2.1
  BOTTOM w0.203: PRM7.2 90.87,24 v1(91.19,24.32) 91.25,24.38 PUM1.9
TP_CLK: length 83.8
  TOP w0.127: RK12.1 140.84,25.28 UK1.87 140.84,21.52 v2(140.42,21.11) ; v2(86.4,8.75) 86.04,8.4 C5257.1 85.79,8.89 86.24,9.35 86.24,10.82 86.07,10.99 85.95,10.99 DM5.1 86.03,11.96 86.36,11.96 v2(86.64,12.24)
  IN2 w0.127: v2(115.49,18.62) 115.76,18.35 116.81,18.35 117.82,19.36 121.22,19.36 121.35,19.49 123.23,19.49 124.04,20.3 130.19,20.3 130.43,20.54 131.79,20.54 132.77,19.57 135.97,19.57 136.78,20.37 139.68,20.37 v2(140.42,21.11)
  BOTTOM w0.127: v2(86.4,8.75) 85.97,8.33 85.97,7.65 86.17,7.46 99.22,7.46 99.86,8.1 116.65,8.1 117.4,8.85 117.4,11.28 115.3,13.38 115.3,16.12 114.55,16.86 114.55,17.27 115.49,18.21 v2(115.49,18.62) ; v2(86.64,12.24) 87.2,12.8 JTP1.6
TP_DATA: length 86.8
  TOP w0.127: v2(84.81,5.91) 84.33,6.39 84.33,8.16 84.58,8.41 C5256.1 85.51,9.06 DM5.3 84.6,9.54 v3(84.16,9.98) 84.16,11.19 85.22,12.24 v2(85.37,12.24) ; RK13.1 140.44,24.87 UK1.88 140.44,21.76 v2(139.78,21.11)
  IN2 w0.127: v2(139.78,21.11) 139.78,20.85 139.57,20.64 136.67,20.64 135.86,19.84 132.88,19.84 131.91,20.81 130.32,20.81 130.08,20.57 123.93,20.57 123.65,20.29 120.02,20.29 119.36,19.63 116.9,19.63 116.06,18.79 v2(116.06,18.79)
  BOTTOM w0.127: v2(85.37,12.24) 86.2,13.07 JTP1.7 ; v2(84.81,5.91) 85.78,5.91 87.07,7.19 99.33,7.19 99.97,7.84 116.76,7.84 117.66,8.74 117.66,11.39 115.56,13.49 115.56,16.23 114.94,16.84 114.94,17.29 116.06,18.41 v2(116.06,18.79)
TP_EN: length 52.6
  TOP w0.127: v2(93.71,14.2) 94.16,13.75 94.65,13.75 95.12,13.28 95.33,13.28 DT1.3 96.17,12.06 v3(97.82,10.41) 98.2,10.03 98.2,9.07 101.77,5.5 125.89,5.5 125.89,5.5 135.19,5.5 136.28,6.58 136.83,6.58 137.24,6.99 UK1.1
  BOTTOM w0.127: v2(93.71,14.2) 93.71,13.76 92.8,12.85 92.34,12.85 92.2,12.99 JTP1.1
TP_SMBCLK: length 151.4
  TOP w0.127: QC7.6 202.01,7.89 RC81.1 201.99,7.49 201.99,6.66 v2(202,6.65) 201.58,6.23 v3(201.46,6.23) 201.16,5.93 172.45,5.93 170.11,8.27 170.11,9.37 167.61,11.86 164.6,11.86 164.47,11.99 164.47,12.54 164.35,12.66 164.09,12.66 163.97,12.54 163.97,11.99 163.84,11.86 163.58,11.86 163.46,11.99 163.46,12.54 163.33,12.66 163.08,12.66 162.95,12.54 162.95,11.99 162.82,11.86 162.57,11.86 162.44,11.99 162.44,12.54 162.31,12.66 162.06,12.66 161.93,12.54 161.93,11.99 161.81,11.86 161.55,11.86 161.43,11.99 161.43,12.54 161.3,12.66 161.04,12.66 160.92,12.54 160.92,11.99 160.79,11.86 160.54,11.86 160.41,11.99 160.41,12.54 160.28,12.66 160.03,12.66 159.9,12.54 159.9,11.99 159.77,11.86 155.94,11.86 150.74,6.66 v2(150.74,5.1) ; v2(97.77,9.38) 97.77,8.89 101.59,5.06 126.78,5.06 135.37,5.06 136.45,6.15 137.09,6.15 137.5,5.75 v2(137.5,5.68) ; v2(207.59,7.59) 207.59,8.29 QC10.6 ; v2(89.43,12.22) 88.93,12.22 88.16,11.44 DM5.6 87.47,11.44 87.09,11.06 87.09,8.63 C5258.1 86.76,8.37 v2(86.55,8.16)
  IN1 w0.127: v2(202,6.65) 202.14,6.51 206.61,6.51 207.59,7.5 v2(207.59,7.59)
  IN2 w0.127: v2(150.74,5.1) 150.74,5.51 149.82,6.43 138.25,6.43 v2(137.5,5.68)
  BOTTOM w0.127: v2(97.77,9.38) 97.77,8.69 96.97,7.89 86.82,7.89 v2(86.55,8.16) ; v2(89.43,12.22) 89.2,12.44 JTP1.4
TP_SMBDATA: length 150.8
  TOP w0.127: v2(96.69,9.01) v3(98.83,6.86) 101.06,4.63 135.73,4.63 136.82,5.72 v2(136.91,5.72) ; v2(90.72,12.2) 90.84,12.08 90.84,10.58 89.8,9.54 DM5.4 87.73,9.54 87.53,9.34 87.53,9.12 C5259.1 v2(89.38,8.38) ; QC7.3 204.93,10.21 207.95,10.21 208.38,9.77 QC10.3 209.99,9.77 210.17,9.6 210.17,8.43 210.19,8.41 210.19,6.85 209.45,6.12 205.7,6.12 RC82.1 202.85,5.5 172.27,5.5 169.67,8.09 169.67,9.19 167.44,11.43 156.29,11.43 154.32,9.47 154.32,8.82 151.33,5.83 v2(151.33,5.11)
  IN2 w0.127: v2(136.91,5.72) 138.06,6.86 150,6.86 151.33,5.54 v2(151.33,5.11)
  BOTTOM w0.127: v2(96.69,9.01) 96.18,8.5 89.5,8.5 v2(89.38,8.38) ; JTP1.3 90.2,12.72 v2(90.72,12.2)
TPM_GPIO: length 2.9
  TOP w0.127: v1(119.61,17.31) 119.61,16.99 RTT10.1
  TOP w0.135: UT1.6 119.27,16.16 RTT10.1
TPM_IRQ#: length 105.6
  TOP w0.127: R5202.1 129.41,15.14 v2(130.3,16.03) ; v2(208.99,21.44) 209.11,21.55 210.73,21.55 211.52,22.34 212.59,22.34 212.68,22.25 RH178.2 ; v2(172.55,28.67) v1(173.26,28.67) 173.6,28.67 178.78,23.49 v2(179.15,23.49)
  IN2 w0.127: v2(179.15,23.49) 179.36,23.49 183.37,27.5 184.27,27.5 184.95,26.82 184.95,26.35 186.06,25.25 186.99,25.25 187.56,25.81 188.56,25.81 189.48,26.73 190.7,26.73 192.18,25.26 194.16,25.26 194.34,25.44 194.88,25.44 195.47,24.84 198.1,24.84 198.48,25.21 201.75,25.21 203.54,23.42 203.54,22.69 204.03,22.2 204.03,21.76 204.99,20.8 206.47,20.8 207.1,21.43 208.99,21.43 v2(208.99,21.44)
  IN3 w0.127: v2(130.3,16.03) 130.88,16.61 131.08,16.61 132.48,18 132.48,19.32 131.48,20.32 131.48,22.51 134.83,25.85 134.83,26.88 135.58,27.63 140.9,27.63 141.34,27.2 149.2,27.2 150.06,28.05 150.5,28.05 150.86,28.41 169.21,28.41 169.48,28.67 v2(172.55,28.67)
  BOTTOM w0.127: v2(208.99,21.44) 208.88,21.55 208.57,21.55 UH1.AW13
TPM_PP: length 2.5
  TOP w0.135: UT1.7 119.05,15.66 RTT12.1 RTT35.2
TPM_SERIRQ: length 2.3
  TOP w0.127: R5202.2 126.99,15.14 v1(126.98,15.15) 126.46,15.66 UT1.18
TSENSE_2PH: length 2.9
  BOTTOM w0.203: PRZ75.1 PCZ32.1 163.96,132.23 164.76,131.44 PUZ1.25
TSENSE_4PH: length 4
  BOTTOM w0.127: PRZ74.1 164.27,125.83 v1(164.74,125.36)
  BOTTOM w0.203: PUZ1.14 164.81,127.04 164.17,126.39 164.17,126.21 PRZ74.1 163.05,125.83 PCZ30.1
U2D_DN1: length 6
  TOP w0.127: LS9.4 20.46,85.61 20.56,85.52 v4(20.56,84.88) 20.56,84.5 20.18,84.11 19.91,84.11 v2(19.75,83.95)
  BOTTOM w0.127: v2(19.75,83.95) 19.75,84.13 19.62,84.26 19.47,84.26 19.28,84.08 19.28,83.1 19.48,82.9 19.48,82.9 19.61,82.77 19.61,82.53 19.72,82.42 19.96,82.42 20.03,82.36 US2.11
U2D_DP1: length 6
  TOP w0.127: v2(19.75,84.66) 19.69,84.6 19.69,84.5 19.82,84.37 20.07,84.37 20.3,84.6 20.3,85.41 20.2,85.51 20.04,85.51 19.96,85.59 LS9.1
  BOTTOM w0.127: US2.10 19.53,82.25 19.36,82.43 19.36,82.66 19.03,82.99 19.03,84.19 19.36,84.52 19.61,84.52 v2(19.75,84.66)
UART_2_CCTS_DRTS: length 4.9
  TOP w0.127: v2(205.22,21.82) 204.88,21.82 204.14,21.08 204.14,20.54 203.85,20.24 v1(203.85,20.03) 203.85,19.86 204.17,19.54 RH81.1
  BOTTOM w0.127: v2(205.22,21.82) 205,21.82 204.51,22.3 UH1.AV21
UART_2_CRTS_DCTS: length 4.1
  TOP w0.127: v2(205.28,21.22) 204.76,21.22 204.42,20.88 204.42,20.34 204.26,20.18 204.26,19.78 204.93,19.1 RH79.1
  BOTTOM w0.127: v2(205.28,21.22) 204.81,21.68 UH1.AW21
UART_2_CRXD_DTXD: length 144.7
  TOP w0.127: v2(276.77,5.35) 276.77,5.35 277.52,6.1 v1(277.52,6.56) 277.51,6.56 277.51,16.22 v2(277.75,16.45) ; RH76.1 213.59,9.68 v2(213.14,10.13)
  TOP w0.135: RWL32.1 310.98,18.04 v2(311.19,17.83)
  IN3 w0.127: v2(311.19,17.83) 311.66,17.83 311.96,17.53 311.96,10.66 309.46,8.17 309.04,8.17 308.13,7.26 306.26,7.26 303.63,4.63 282.7,4.63 281.56,5.78 277.2,5.78 276.77,5.35 v2(276.77,5.35) ; v2(221.3,9.28) 221.72,9.28 222.04,9.6 222.04,10.3 224.57,12.84 225.37,12.84 226.85,14.33 233.85,14.33 235.08,15.56 237.02,15.56 238.16,16.71 257.46,16.71 257.82,16.35 263.71,16.35 264.53,17.18 270.79,17.18 272.84,19.22 275.78,19.22 277.11,17.88 277.11,17.09 v2(277.75,16.45)
  BOTTOM w0.102: UH1.BD20 204.64,19.36 204.64,18.83 204.89,18.57 204.89,18.14
  BOTTOM w0.127: 204.89,18.14 205.65,17.38 205.65,17.03 209.13,13.55 209.13,12.98 210.94,11.17 212.09,11.17 v2(213.14,10.13) 213.84,9.43 218.3,9.43 219.01,10.14 220.44,10.14 v2(221.3,9.28)
