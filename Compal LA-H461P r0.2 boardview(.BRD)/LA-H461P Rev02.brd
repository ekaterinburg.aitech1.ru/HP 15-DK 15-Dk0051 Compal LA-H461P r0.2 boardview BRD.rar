# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_CS_TPM: length 82
  TOP w0.127: RTT7.1 129.51,16.66 130.36,17.52 v2(130.62,17.52) ; v2(174.23,30.34) 174.23,28.65 178.83,24.05 v1(181.08,24.05) 181.43,24.05 182.79,22.69 185.75,22.69 186.54,23.48 187.17,23.48 188.25,22.41 191.98,22.41 192.25,22.14 193.68,22.14 194.29,22.74 194.97,22.74 v2(195.09,22.63)
  IN3 w0.127: v2(174.23,30.34) 173.37,29.49 169.68,29.49 169.04,28.84 150.68,28.84 150.32,28.48 149.88,28.48 149.02,27.63 141.52,27.63 141.08,28.06 135.4,28.06 134.4,27.06 134.4,26.03 131.05,22.68 131.05,20.15 130.43,19.53 130.43,17.71 v2(130.62,17.52)
  BOTTOM w0.089: UH1.AT40 195.32,22.85 v2(195.09,22.63)
PCH_CS_TPM_R: length 2.1
  TOP w0.127: UT1.20 v1(126.95,16.66) 127.76,16.66 127.77,16.66 RTT7.2
PCH_DP1_CTRL_CLK: length 7.8
  TOP w0.127: v2(207.81,25.31) 208.2,24.92 208.6,24.92 208.83,24.69 208.83,23.67 v1(209.28,23.23) 209.54,23.23 210.09,23.77 RH33.2
  BOTTOM w0.127: UH1.AL13 207.81,25.49 v2(207.81,25.31)
PCH_DP1_CTRL_DATA: length 3.8
  TOP w0.127: RH34.2 213.01,23.01 212.54,23.48 211.24,23.48 v1(211.1,23.34) 211.01,23.24 v2(211.01,22.84)
  BOTTOM w0.127: UH1.AR8 v2(211.01,22.84)
PCH_DP1_HPD: length 244.5
  TOP w0.127: 53.19,34.87 53.51,35.19 53.51,36.33 52.76,37.09 52.76,39.05 52.51,39.3 RU78.2 RU79.2 51.62,40.61 50.97,41.26 UU4.30 ; 53.19,34.87 51.09,34.87 50.51,34.29 50.51,30.54 v2(50.8,30.24) ; 53.19,34.87 v1(53.19,34.12) 53.19,31.17 57.7,26.66 61.46,26.66 v2(63.55,28.74)
  IN2 w0.127: v2(209.43,29.02) 209,29.45 207.97,29.45 206.03,27.51 204.42,27.51 204.03,27.9 200.4,27.9 200.08,27.58 199.36,27.58 198.68,28.27 196.66,28.27 195.04,29.89 189.22,29.89 188,28.68 186.86,28.68 186.16,29.38 182.52,29.38 179.97,26.83 179.46,26.83 175.26,22.63 161.39,22.63 160.77,23.25 152.43,23.25 150.89,21.71 146.6,21.71 145.92,22.39 142.48,22.39 142.17,22.07 138.74,22.07 138.11,21.45 136.33,21.45 135.53,20.64 133.21,20.64 132.24,21.62 129.99,21.62 129.75,21.38 123.6,21.38 123.37,21.15 117.29,21.15 116.85,20.71 112.46,20.71 109.39,23.78 99.66,23.78 97.66,21.78 95.15,21.78 94.59,21.21 90.89,21.21 87.71,24.4 83.84,24.4 82.24,25.99 82.24,26.96 81.68,27.53 67.45,27.53 66.23,28.74 v2(63.55,28.74)
  IN3 w0.127: v2(50.8,30.24) 50.42,30.63 50.42,34.45 49.64,35.23 49.64,35.99 49.78,36.12 49.78,36.82 49.53,37.06 42.62,37.06 41.84,37.84 40.51,37.84 38.33,40.02 38.33,43.62 35.12,46.83 34.23,46.83 33.24,47.82 33.24,50.38 32.66,50.96 29.38,50.96 29.15,51.19 27.79,51.19 27.39,51.6 v2(24.72,51.6)
  BOTTOM w0.102: UH1.AT6 211.65,23.44 211.07,24.02 211.07,24.45 211.44,24.82 211.44,25.32 211.4,25.43 210.68,26.14 209.92,26.14 209.2,26.86 209.2,28.78 v2(209.43,29.02)
  BOTTOM w0.127: RT839.1 24.8,51.67 v2(24.72,51.6)
PCH_DP2_CTRL_CLK: length 1.7
  TOP w0.127: v2(208.41,25.32) 209.21,25.32 RH35.2
  BOTTOM w0.127: UH1.AN13 208.18,25.08 v2(208.41,25.32)
PCH_DP2_CTRL_DATA: length 3.1
  TOP w0.127: RH36.2 210.24,25.78 210.08,25.62 v2(210.08,25.18) v1(210.08,24.22)
  BOTTOM w0.127: v2(210.08,25.18) 209.68,25.58 UH1.AL10
PCH_DP2_HPD: length 303.2
  IN2 w0.127: v2(208.7,27.65) 208.06,27.01 208.06,26.74 207.42,26.1 205.63,26.1 205.3,25.77 200.47,25.77 200.16,26.07 200.16,26.76 199.88,27.04 199.15,27.04 199.11,27.09 195.89,27.09 194.29,28.69 188.92,28.69 187.48,27.25 186.05,27.25 184.72,28.58 182.92,28.58 180.37,26.03 179.8,26.03 175.6,21.83 161.05,21.83 160.43,22.44 152.76,22.44 151.22,20.9 146.8,20.9 146.29,20.39 141.52,20.39 140.97,19.83 137.99,19.83 137.18,19.03 132.54,19.03 131.57,20 130.66,20 130.42,19.76 124.27,19.76 123.45,18.95 121.57,18.95 121.45,18.83 119.42,18.83 117.79,17.2 116.8,17.2 116.18,17.81 112.82,17.81 108.78,21.85 99.89,21.85 99.44,21.4 98.42,21.4 97.7,20.67 95.79,20.67 95.47,20.99 95.12,20.99 94.81,20.67 90.67,20.67 87.49,23.86 83.61,23.86 81.7,25.77 81.7,26.74 81.46,26.99 64.14,26.99 62.18,25.03 60.74,25.03 60.37,24.67 58.77,24.67 54.39,29.05 54.39,32.91 55.87,34.39 55.87,40.37 55.52,40.72 54.69,40.72 54.38,41.03 49.09,41.03 48.56,40.5 44.27,40.5 43.96,40.81 43.96,41.14 38.84,46.26 38.42,46.26 34.58,50.1 34.3,50.1 33.32,51.09 30.17,51.09 29.74,51.53 27.9,51.53 27.41,52.02 26.25,52.02 24.24,54.03 23.13,54.03 22.76,54.4 22.76,55.17 20.89,57.03 20.89,61.23 17.94,64.18 17.94,65.43 19.4,66.9 19.4,70.42 19.64,70.65 19.64,72 17.69,73.95 17.69,75.24 16.98,75.95 16.98,82.13 16.65,82.45 16.65,84.51 17.37,85.22 17.37,96.67 16.65,97.38 16.65,106.5 17.66,107.5 17.66,114.02 17.15,114.53 16.72,114.53 15.47,115.78 15.47,117.77 15.82,118.12 v2(15.82,118.8)
  BOTTOM w0.127: v1(17.8,119.25) 17.58,119.46 QV1.3 16.61,119.97 16.69,120.06 RV38.2 16.59,120.51 15.95,119.87 15.95,118.93 v2(15.82,118.8) ; v2(208.7,27.65) 208.37,27.32 208.37,26.25 208.5,26.12 208.5,25.78 209.68,24.6 UH1.AN10
PCH_DP3_CTRL_CLK: length 3.5
  TOP w0.127: v2(210.67,25.13) 210.9,24.9 v1(211.17,24.9) 212.24,24.9 212.64,25.3 RH38.2
  BOTTOM w0.127: UH1.AL9 210.41,25.38 v2(210.67,25.13)
PCH_DP3_CTRL_DATA: length 4.1
  TOP w0.127: v2(211.46,24.19) 211.91,24.64 212.38,24.64 212.41,24.61 v1(212.41,24.6) 212.47,24.53 RH37.2
  BOTTOM w0.127: v2(211.46,24.19) 211.9,23.76 211.91,23.76 212.16,23.51 UH1.AR3
PCH_DP3_HPD: length 2.4
  TOP w0.127: v2(210.09,23.09) 210.6,22.59 TH4953.1
  BOTTOM w0.127: v2(210.09,23.09) 210.41,23.42 UH1.AP9
PCH_DPWROK: length 64.7
  TOP w0.127: RH52.2 190.54,21.96 CK14.2 190.49,22 v1(183.14,22) 183.07,21.94 181.69,21.94 v2(181.69,21.94) ; UK1.127 136.48,10.22 136.71,10.45 136.71,11.53 139.58,14.4 139.58,16.22 140.83,17.47 140.83,18.11 140.71,18.23 v2(140.71,18.41)
  IN3 w0.127: v2(140.71,18.41) 140.87,18.26 143.9,18.26 144.91,19.28 146.27,19.28 147.6,20.61 150.22,20.61 152.7,23.09 159.52,23.09 159.97,22.64 161.35,22.64 161.59,22.4 165.94,22.4 166.26,22.72 169.34,22.72 169.56,22.5 177.19,22.5 177.71,21.98 180.07,21.98 180.36,22.27 181.35,22.27 181.68,21.94 v2(181.69,21.94)
PCH_DPWROK_R: length 4.6
  TOP w0.127: RH52.1 191.62,20.78 RH50.2 192.61,20.78 193.58,21.75 v2(194.16,21.75) 194.16,21.96 v1(194.53,22.32)
  BOTTOM w0.127: UH1.AW41 194.44,21.75 v2(194.16,21.75)
PCH_ENBKL: length 65.5
  TOP w0.127: v2(186.84,23.09) 186.14,22.38 182.71,22.38 182.31,22.78 180.05,22.78 v1(180.01,22.74) 179.98,22.78 179.12,22.78 173.65,28.25 v2(172.13,28.25) ; v2(137.37,22.5) 137.09,22.22 UK1.97
  BOTTOM w0.102: UH1.AV46 192.27,22.56 191.42,22.56
  BOTTOM w0.127: v2(172.13,28.25) 172.41,27.97 172.41,27.04 172.19,26.82 167.54,26.82 165.91,25.18 164.48,25.18 163.09,23.79 148.02,23.79 147.42,23.18 138.05,23.18 v2(137.37,22.5) ; 191.42,22.56 190.73,22.56 189.98,23.31 189.78,23.31 189.41,23.68 189.28,23.68 188.9,24.06 188.13,24.06 RH204.1
  BOTTOM w0.135: RH204.1 186.84,24.23 v2(186.84,23.09)
PCH_ENVDD: length 173.9
  TOP w0.127: v2(70.26,41.22) 70.52,40.97 RV47.1 71.28,40.54 71.47,40.34 UV1.1 ; v2(72.11,31.73) 72.11,30.71 71.65,30.25 71.76,30.14 71.87,30.14 72.09,29.92 72.09,29.44 71.31,28.65 67.47,28.65 v3(67.4,28.58) 64.31,25.49 v2(63.35,25.49)
  IN1 w0.127: v2(70.26,41.22) 70.26,41.21 68.41,39.37 68.41,31.59 69,31 71.55,31 72.11,31.56 v2(72.11,31.73)
  IN2 w0.127: v2(193.07,22.99) 188.35,22.99 187.83,23.51 184.3,23.51 184.16,23.65 181.2,23.65 177.49,19.94 168.95,19.94 168.2,19.19 152.21,19.19 150.12,17.1 142.71,17.1 140.77,15.16 135.63,15.16 134.35,16.44 132.07,16.44 131.79,16.73 131.24,16.73 131.03,16.52 127.76,16.52 127.28,16.03 121.41,16.03 120.99,15.61 118.98,15.61 118.11,14.74 113.19,14.74 110.33,17.6 108.07,17.6 107.77,17.9 102.11,17.9 101.49,18.52 86.88,18.52 83.91,21.48 75.34,21.48 73.98,20.12 67.12,20.12 67.1,20.15 67.1,21.12 66.77,21.45 65.28,21.45 65.02,21.71 65.02,23.83 v2(63.35,25.49)
  BOTTOM w0.122: v2(193.07,22.99) 193.07,22.14 UH1.AV44
PCH_ENVDD#: length 2.6
  TOP w0.127: v1(74.55,29.96) RV51.2
  TOP w0.254: RV51.2 74.07,30.88 74.06,30.9 QV7.3 73.55,30.25
PCH_GPP_B1: length 2.8
  BOTTOM w0.102: UH1.BF33 198.4,18.25 198.4,17.3 198.22,17.12 198.22,16.85 198.63,16.45 198.71,16.36 TH4967.1
PCH_GPP_B11: length 1.5
  TOP w0.135: TH129.1 199.82,24.47 v2(199.97,24.62)
  BOTTOM w0.127: v2(199.97,24.62) 200.49,24.11 UH1.AP29
PCH_GPP_K17: length 3.9
  BOTTOM w0.127: UH1.R47 191.83,33.72 190.82,33.72 190.47,34.06 189.36,34.06 188.68,33.37 TH128.1
PCH_JTAG_TCK1: length 4.6
  BOTTOM w0.102: UH1.AJ3 213.17,26.79 214.23,26.79 214.41,26.97 215.29,26.97 215.56,26.7
  BOTTOM w0.127: RC391.1 217.31,26.38 215.89,26.38 v2(215.64,26.62) 215.56,26.7
PCH_PECI: length 4.5
  BOTTOM w0.102: UH1.AF2 214.19,28.41 215.78,28.41 v1(216.34,27.86) 216.86,27.34
  BOTTOM w0.127: 216.86,27.34 217.12,27.07 RH13.1
PCH_PLTRST#: length 43.6
  TOP w0.102: v1(217.64,7.54) 217.53,7.66 v2(217.53,8.23) 217.53,8.81 218.27,9.55 UH3.1 218.27,10.51 218.17,10.61 218.05,10.61 UH3.2 217.62,9.89 217.28,9.55 RH7.1
  IN1 w0.127: v2(217.53,8.23) 215.7,10.05 215.7,10.28 215.42,10.57 209.57,10.57 209.06,11.08 207.83,11.08 207.34,11.57 207.34,11.92 204.21,15.06 204.21,15.57 203.78,16 203.78,16.22 203.17,16.83 199.77,16.83 198.68,15.74 196.51,15.74 v2(195.78,16.48)
  IN2 w0.127: v2(199.99,22.91) 200.06,22.91 200.44,22.54 200.44,21.82 200.32,21.71 200.32,19.74 199.4,18.81 197.75,18.81 196.37,17.42 196.37,16.67 196.17,16.48 v2(195.78,16.48)
  BOTTOM w0.102: UH1.AV29 200.48,22.42 v2(199.99,22.91)
PCH_PWR_EN: length 238.1
  TOP w0.127: v2(263.63,24.46) 265.52,22.57 v3(271.66,22.57) 273.68,22.57 v2(275.78,20.46) ; v2(178,33.09) 177.79,32.87 U11.3 ; v2(180.89,7.02) 180.89,7.05 179.48,8.46 177.07,8.46 174.55,10.98 172.07,10.98 164.02,19.04 164.02,21.59 163.14,22.47 163.14,26.09 v2(163.13,26.1) ; v2(136.82,18.34) 136.71,18.22 UK1.107 134.31,18.22 133.56,18.97 RK30.2
  IN2 w0.127: v2(275.78,20.46) 276.8,19.44 276.8,17.24 275.59,16.03 264.98,16.03 263.9,14.95 257.39,14.95 256.38,15.95 237.92,15.95 236.45,14.48 232.22,14.48 231.15,15.55 228.22,15.55 224.29,11.62 224.29,10.11 220.75,6.58 203.25,6.58 202.38,7.44 199.67,7.44 198.88,6.65 181.27,6.65 v2(180.89,7.02) 180.91,7.04 180.91,7.23 180.21,7.92 171.76,7.92 167.39,12.29 156.96,12.29 154.16,9.49 154.16,7.11 153.77,6.72 v2(153.77,4.8)
  IN3 w0.127: v2(178,33.09) 177.04,32.13 177.04,30.82 173.51,27.3 171.82,27.3 170.91,26.38 166.81,26.38 166.24,26.95 163.98,26.95 v2(163.13,26.1)
  BOTTOM w0.127: PR1804.1 264.37,23.72 v2(263.63,24.46) ; v2(153.77,4.8) 153.77,5.34 153.13,5.98 143.25,5.98 137.99,11.24 137.99,15.28 138.57,15.86 138.57,16.9 138.16,17.3 137.09,17.3 136.82,17.57 v2(136.82,18.34)
PCH_PWROK: length 79.6
  TOP w0.127: v2(194.81,20.66) 194.78,20.66 v3(193.99,19.86) 193.94,19.81 193.94,18.09 CH73.2 ; v2(147.19,13.8) 147.19,14.05 147.5,14.35 148.01,14.35 148.19,14.18 148.19,13.17 147.77,12.75 147.77,11.62 148.06,11.33 148.97,11.33 150.12,10.18 150.12,9.58 149.64,9.09 UK1.32 149.64,7.17 RK20.2 148.19,6.56 CK10.1 ; DH2.2 193.55,17.35 CH73.2 ; CH73.2 193.35,17.55 RH210.2
  IN3 w0.127: v2(147.19,13.8) 147.19,13.95 147.88,14.64 150.12,14.64 151.2,15.72 151.88,15.72 153.74,17.58 178.61,17.58 180.06,16.13 180.06,15.16 180.78,14.44 190.16,14.44 190.5,14.09 193.23,14.09 194.71,15.57 196.93,15.57 197.48,16.11 197.48,17.35 195.63,19.2 195.63,20.01 194.98,20.66 v2(194.81,20.66)
  BOTTOM w0.127: UH1.AY42 194.51,20.66 v2(194.81,20.66)
PCH_RSMRST#: length 71.6
  TOP w0.102: v2(136.97,19.85) 136.89,19.94 136.89,20.7 136.56,21.02 UK1.100 ; v2(188.04,17.04) 188.04,16.87 188.38,16.53 189.31,16.53 189.9,15.95 CH108.1 190,16.33 189.95,16.38 RH212.2 190.33,16.76 190.81,16.28 DH2.1 191.22,16.02 191.01,15.81 DH3.2
  IN3 w0.127: v2(136.97,19.85) 137.45,20.32 145.84,20.32 147.17,21.66 149.79,21.66 152.27,24.14 159.96,24.14 160.41,23.69 161.79,23.69 162.03,23.45 164.25,23.45 164.9,24.1 166.19,24.1 166.42,23.87 171.55,23.87 172.45,24.76 173.37,24.76 173.75,24.39 176.63,24.39 v2(178.26,22.76)
  BOTTOM w0.102: v2(178.26,22.76) v1(179.56,21.46) 180.26,20.76 180.57,20.76 183.44,17.89 187.19,17.89 v2(188.04,17.04) 188.44,17.44 188.44,18.42 190.32,20.3 191.49,20.3 UH1.BA47
PCH_RTCRST#: length 22.2
  TOP w0.102: RH32.2 186.52,21.23 186.95,21.66 188.75,21.66 189.03,21.38 CLRP2.2 189.25,20.85 CH10.2 CH83.2 191.31,19.42 v2(191.49,19.42) ; v3(181.13,16.15) v2(181.84,15.44) QC11.6
  IN3 w0.127: v2(181.84,15.44) 182.41,16.01 186.83,16.01 187.35,15.48 188.95,15.48 189.73,16.26 189.73,17.66 v2(191.49,19.42)
  BOTTOM w0.122: v2(191.49,19.42) 191.64,19.27 UH1.BE47
PCH_RTCX1: length 6.2
  BOTTOM w0.127: YH2.2 185.36,21.07 186.08,20.34 CH6.1 187.04,20.34 187.16,20.47 RH19.1 187.76,20.47 188.07,20.78 UH1.BA49
PCH_RTCX2: length 7.1
  BOTTOM w0.102: UH1.BA48 191.15,20.54 189.98,20.54
  BOTTOM w0.127: YH2.1 185.37,18.57 186.26,19.45 CH7.1 186.93,19.45 187.02,19.55 RH19.2 187.91,19.97 187.91,20.1 188.35,20.54 189.98,20.54
PCH_SERIRQ: length 10.3
  TOP w0.102: v1(195.9,15.82) 196.17,16.09 196.17,19.94 196.7,20.47 v2(196.7,20.84)
  TOP w0.127: v1(195.9,15.82) 195.52,15.44 195.52,15.02 194.39,13.89 RH65.1
  BOTTOM w0.127: v2(196.7,20.84) 197.21,21.35 197.31,21.35 UH1.AW35
PCH_SMBCLK: length 16.1
  TOP w0.102: 203.33,17.25 202.9,17.68 202.9,19.2 202.99,19.3 202.99,19.72 v2(202.58,20.13)
  TOP w0.127: 203.33,17.25 203.84,16.74 203.84,15.9 203.94,15.8 QC8.6 203.94,15.14 204.45,14.63 204.93,14.63 205.61,13.95 205.61,13.2 205.5,13.09 205.5,12.03 204.97,11.49 v1(204.97,11.28) 204.97,10.97 204.26,10.26 204.26,9.08 QC7.1 205.46,8.66 RH226.1
  BOTTOM w0.102: v2(202.58,20.13) 202.2,19.74 202.2,19.44 UH1.BE26
PCH_SMBDATA: length 14.1
  TOP w0.102: 202.93,16.95 202.93,17.25 202.7,17.48 202.7,19.42 v2(202.6,19.52)
  TOP w0.127: QC7.4 203.31,10.49 203.31,10.6 RH227.1 204.05,10.92 204.09,10.88 204.5,10.88 204.65,11.03 204.65,11.5 205.27,12.12 205.27,13.45 QC8.3 205.24,13.71 204.82,14.13 203.88,14.13 202.93,15.09 v1(202.93,16.67) 202.93,16.95
  BOTTOM w0.102: v2(202.6,19.52) 202.59,19.52 202.08,19.01 202.08,18.61 UH1.BF26
PCH_SML0ALERT#: length 4.2
  BOTTOM w0.127: RH97.2 204.32,15.49 v1(204.19,15.62) 203.82,15.99 203.82,16.18 203.03,16.97 UH1.BF24
PCH_SML0CLK: length 4.4
  BOTTOM w0.127: UH1.BF25 201.97,17.76 201.97,16.92 202.09,16.79 202.2,16.68 202.62,16.68 202.9,16.39 v1(202.9,15.68) RH225.1
PCH_SML0DATA: length 5.5
  BOTTOM w0.102: 201.96,16.62 201.76,16.81 201.76,17.89 202.27,18.4 202.27,18.93 202.44,19.1 203.13,19.1 UH1.BE24
  BOTTOM w0.127: RH224.1 202.14,16.44 201.96,16.62
PCH_SML1ALERT#: length 4.8
  BOTTOM w0.127: UH1.BD33 198.74,19.03 198.74,18.2 199.02,17.92 199.02,15.58 198.66,15.22 RH63.2
PCH_SML1CLK: length 38.6
  TOP w0.127: RH223.1 202.39,15.31 201.76,15.95 v2(201.76,16.28) ; v2(224.97,10.71) v1(225.89,10.71) 226.9,10.71 227.76,11.57 228.42,11.57 QC9.1
  IN1 w0.127: v2(201.76,16.28) 201.76,16.13 201.56,15.93 201.56,13.25 202.08,12.72 204.31,12.72 205.29,11.75 205.29,10.73 206.66,9.36 209.28,9.36 209.48,9.15 214.6,9.15 216.25,7.51 220.91,7.51 221.86,8.45 222.71,8.45 v2(224.97,10.71)
  BOTTOM w0.102: v2(201.76,16.28) 201.57,16.46 201.57,18.15 UH1.BF27
PCH_SML1DATA: length 40.2
  TOP w0.127: QC9.4 226.08,13.07 v1(225.39,12.38) 224.54,11.53 224.54,10.53 v2(224.97,10.1) ; RH222.1 201.17,15.59 v2(201.17,16.3)
  IN1 w0.127: v2(201.17,16.3) 201.12,16.25 201.12,13.07 201.9,12.29 204.13,12.29 204.85,11.57 204.85,10.55 206.48,8.93 209.1,8.93 209.3,8.72 214.43,8.72 216.07,7.07 221.09,7.07 222.03,8.02 222.89,8.02 v2(224.97,10.1)
  BOTTOM w0.102: UH1.BE27 201.05,18.66 201.05,18.19 201.38,17.86 201.38,17.05 201.17,16.84 v2(201.17,16.3)
PCH_SPI_CLK: length 105.5
  TOP w0.127: RTT6.1 129.44,15.9 v2(129.57,16.03)
  IN3 w0.127: v2(129.57,16.03) 129.57,16.8 130,17.23 130,17.83 129.67,18.15 129.33,18.15 128.71,18.78 128.71,19.18 129.92,20.39 129.92,22.78 133.53,26.39 133.53,27.42 135.08,28.96 148.77,28.96 149.16,29.35 149.97,29.35 150.32,29.71 168.68,29.71 169.32,30.35 171.73,30.35 173.47,32.09 174.77,32.09 177.86,35.18 180.1,35.18 180.45,34.82 v2(181.05,34.82) 181.09,34.86 181.09,40.16 179.85,41.4 179.85,42.88 182.41,45.45 182.41,46.43 v2(180.83,48.02)
  BOTTOM w0.089: UH1.AW47 191.82,21.7 191.22,21.7 191.04,21.89 190.52,21.89 189.75,22.66 189.02,22.66
  BOTTOM w0.127: v2(180.83,48.02) 181.09,48.28 RH2.1 ; v2(181.05,34.82) 181.86,34.82 181.99,34.95 181.99,35.75 182.11,35.87 182.49,35.87 182.63,35.73 182.63,34.95 182.75,34.82 183.02,34.82 184.6,33.25 184.6,25.21 CH65.2 186.08,23.72 186.08,22.94 186.37,22.66 189.02,22.66
PCH_SPI_CLK_R: length 4.5
  BOTTOM w0.127: UH2.6 184.01,51 CH3.1 RH2.2 182.32,48.28 RH243.1
PCH_SPI_CLK_TPM: length 2.2
  TOP w0.127: UT1.19 127.21,16.16 127.47,15.9 RTT6.2
PCH_SPI_CS#0: length 34.3
  TOP w0.127: v2(183.89,33.35) 184.54,34 v1(184.54,34.33) 184.54,34.82 184.84,35.12 184.84,44.29 v2(184.35,44.78)
  BOTTOM w0.089: UH1.AY47 191.72,21.32 191.51,21.53 191.15,21.53 190.96,21.71 190.43,21.71 189.7,22.45 189.02,22.45
  BOTTOM w0.127: 189.02,22.45 184.87,22.45 184.1,23.21 RH175.2 183.76,23.21 181.9,25.07 181.9,27.55 183.18,28.83 183.18,32.64 v2(183.89,33.35) ; v2(184.35,44.78) 184.87,44.26 RH242.1 185.85,44.26 RH259.1
PCH_SPI_CS#0_R: length 11.3
  BOTTOM w0.127: RH259.2 185.86,45.74 186.82,46.7 186.82,49.57 v2(187.58,50.33) 190.79,53.54 UH2.1
PCH_SPI_HOLD#: length 44.8
  TOP w0.127: v2(179.83,33.93) 180.91,33.93 182.76,35.77 v3(182.76,37.04) 182.76,42.82 182.61,42.97 182.61,43.77 183.72,44.89 183.72,46.76 183.09,47.39 183.09,49.23 v2(182.36,49.96)
  BOTTOM w0.076: 190.13,21.18 190.74,21.18 191.03,20.89 191.94,20.89 UH1.BA46
  BOTTOM w0.127: v2(179.83,33.93) 180.3,33.46 181.26,33.46 181.72,33 181.72,29.21 180.6,28.09 180.6,24.54 183.34,21.8 188.6,21.8 189.21,21.18 190.13,21.18 ; RH238.1 181.41,50.91 v2(182.36,49.96)
PCH_SPI_HOLD#_R: length 3.6
  BOTTOM w0.127: UH2.7 183.1,52.27 182.89,52.47 RH4.1 182.33,52.25 182.35,52.23 RH176.1 182.35,51.51 182.33,51.49 RH238.2
PCH_SPI_SI: length 106.9
  TOP w0.127: RTT8.1 129.35,17.42 v2(129.46,17.52) ; v2(181.49,43.3) 182.33,42.47 182.33,36.54 181.37,35.58 v1(175.4,35.58) 175.11,35.58 v2(174.02,34.5) 174.66,33.86 174.66,28.83 179.01,24.48 181.61,24.48 182.61,23.48 185.32,23.48 185.63,23.78 RH98.1 186.95,24.03 188.34,22.63 192.08,22.63 192.35,22.37 193.59,22.37 194.33,23.11 v2(194.33,23.27)
  IN3 w0.127: v2(174.02,34.5) 170.31,30.79 169.14,30.79 168.5,30.14 150.15,30.14 149.79,29.78 148.98,29.78 148.59,29.4 134.32,29.4 133.1,28.18 133.1,26.57 129.39,22.86 129.39,20.48 128.27,19.36 128.27,18.58 129.32,17.54 129.44,17.54 v2(129.46,17.52)
  BOTTOM w0.089: UH1.AU41 194.33,22.94 v2(194.33,23.27)
  BOTTOM w0.127: v2(181.49,43.3) 181.23,43.57 181.23,45.75 181.44,45.96 RH236.1
PCH_SPI_SI_R: length 7.2
  BOTTOM w0.127: RH240.1 183.19,44.69 v2(182.87,44.69) 182.35,45.21 RH236.2 183.24,47.17 183.24,49.38 183.59,49.73 UH2.5
PCH_SPI_SI_TPM: length 2.2
  TOP w0.127: RTT8.2 127.47,17.42 127.22,17.16 UT1.21
PCH_SPI_SO: length 98.4
  TOP w0.127: RTT9.1 129.04,19.07 v2(129.14,18.97)
  IN3 w0.127: v2(179.84,34.7) 177.99,34.7 174.45,31.16 174.36,31.16 173.12,29.92 169.5,29.92 168.86,29.28 150.5,29.28 150.14,28.92 149.34,28.92 148.95,28.53 135.26,28.53 133.96,27.24 133.96,26.21 130.35,22.6 130.35,20.18 v2(129.14,18.97)
  BOTTOM w0.089: 189.16,22.01 189.62,22.01 190.29,21.35 190.82,21.35 191.11,21.06 192.49,21.06 UH1.BA45
  BOTTOM w0.127: RH237.1 187.42,43.88 186.74,43.2 186.19,43.2 185.62,42.63 185.08,42.63 183.99,41.54 183.99,39.08 179.84,34.92 v2(179.84,34.7) 180.64,33.89 181.53,33.89 182.15,33.27 v1(182.15,30.58) 182.15,29.03 181.04,27.91 181.04,24.72 183.52,22.23 184.38,22.23 184.6,22.01 189.16,22.01
PCH_SPI_SO_R: length 9.9
  BOTTOM w0.127: UH2.2 191.07,52.27 v2(189.9,51.09) 187.42,48.62 RH237.2 RH241.1
PCH_SPI_SO_TPM: length 1.8
  TOP w0.127: RTT9.2 126.97,19.07 126.56,18.66 UT1.24
PCH_SPI_WP#: length 33.9
  BOTTOM w0.089: 189.02,22.23 189.66,22.23 190.36,21.53 190.89,21.53 191.1,21.32 UH1.AY48
  BOTTOM w0.127: RH239.1 186.33,42.73 185.8,42.2 185.26,42.2 184.42,41.36 184.42,38.9 180.6,35.08 180.6,34.58 180.86,34.32 181.71,34.32 182.58,33.45 v1(182.58,32.9) 182.58,28.85 181.47,27.73 181.47,24.89 183.7,22.66 184.26,22.66 184.69,22.23 189.02,22.23
PCH_SPI_WP#_R: length 10.3
  BOTTOM w0.127: UH2.3 191.02,51 189.35,49.32 v2(189.35,48.42) 188.37,47.45 RH3.1 187.93,44.71 187.93,43.46 187.55,43.08 RH239.2
PCH_SRTCRST#: length 26.7
  TOP w0.127: QC11.3 183.14,13.38 182.73,13.79 180.92,13.79 180.71,13.99 v1(180.71,14.41) 180.71,15.02 v2(181.13,15.44) ; RH31.2 188.02,18.51 188.45,18.51 CLRP1.2 189.08,18.44 190.71,18.44 191.17,18.9 CH9.2 191.98,18.9 CH82.2 192.03,19.23 191.93,19.33 191.93,20.04 192.07,20.18 v2(192.11,20.18)
  IN3 w0.127: v2(192.11,20.18) 191.74,19.82 189.78,19.82 188.8,18.83 188.8,17.15 188.16,16.51 181.86,16.51 181.13,15.79 v2(181.13,15.44)
  BOTTOM w0.127: UH1.BD46 191.96,19.18 191.96,20.04 v2(192.11,20.18)
PCH_SUSWARN#: length 66.7
  TOP w0.127: v2(146.52,13.89) 146.52,13.57 143.02,10.07 143.02,9.65 143.26,9.41 143.48,9.41 143.64,9.25 UK1.17
  IN3 w0.127: v2(197.08,16.89) 195.99,15.79 194.55,15.79 193.12,14.36 190.61,14.36 190.27,14.71 180.89,14.71 180.33,15.27 180.33,16.24 178.73,17.85 152.81,17.85 149.87,14.91 147.54,14.91 v2(146.52,13.89)
  BOTTOM w0.102: UH1.BC37 196.61,19.64 196.61,18.28 196.74,18.16 196.74,17.24 v2(197.08,16.89)
  BOTTOM w0.127: v2(146.52,13.89) 146.52,14.26 v1(146.85,14.59)
PCH_THERMTRIP#: length 4.6
  BOTTOM w0.102: UH1.AD3 213.53,28.87 213.94,28.87 214,28.81 215.36,28.81 215.73,29.18 v1(216.37,29.18) 216.79,29.18 RH158.1
PCH_THERMTRIP#_R: length 168
  TOP w0.127: v2(176.25,101.52) 175.95,101.82 RC45.1 ; v2(218.93,28.34) 219.05,28.47 RH166.2
  IN2 w0.127: v2(218.93,28.34) 218.93,29.51 221.78,32.36 221.78,34.56 224.77,37.55 243.54,37.55 244.49,36.6 245.7,36.6 246.78,37.69 v2(246.78,38.12) ; v2(237.64,42.63) 220.9,42.63 214.72,48.81 194.2,48.81 188.72,54.29 188.72,68.09 188.28,68.53 186.67,70.14 186.67,80.11 187.58,81.02 187.58,83.88 187.95,84.25 187.95,85.94 188.82,86.81 188.82,93.68 187.36,95.13 185.22,95.13 184.61,94.52 178.42,94.52 177.42,95.52 177.42,100.86 176.84,101.45 176.32,101.45 v2(176.25,101.52)
  IN3 w0.127: v2(246.78,38.12) 247.5,38.12 248.07,38.69 248.07,38.95 247.7,39.31 245.5,39.31 244.36,38.17 239.52,38.17 237.64,40.05 v2(237.64,42.63)
  BOTTOM w0.127: v2(218.93,28.34) 218.67,28.6 RH158.2
PCH_TRIGOUT: length 4.9
  BOTTOM w0.102: UH1.AK3 213.15,26.13 213.9,26.13 214.14,25.89 214.99,25.89 215.27,26.18 216.5,26.18 RH1.1
PCH_TRIGOUT_R: length 117.8
  IN1 w0.127: v2(180.4,68.5) 180.4,68.57 182.85,71.02 182.85,78.28 181.95,79.18 181.95,81.32 180.74,82.53 180.74,84.12 169.73,95.13 169.73,95.34 169.18,95.9 169.18,96.37 167.86,97.68 166.42,97.68 165.3,98.8 164.85,98.8 164.62,98.58 164.06,98.58 163.62,99.02 v2(163.62,99.06)
  BOTTOM w0.127: UC1.H23 v2(163.62,99.06) ; RH1.2 218.59,25.3 220.58,27.28 220.58,29.69 222.43,31.54 222.43,39.78 220.27,41.94 220.27,43.39 216.82,46.84 210.32,46.84 209.84,47.32 201.08,47.32 200.39,48.01 195.32,48.01 193.3,50.03 193.3,54.14 192.45,54.99 191.09,54.99 189.96,56.11 189.96,57.76 189.6,58.13 189.56,58.13 184.36,63.33 184.36,65.3 181.77,67.89 v1(181.3,67.89) 180.7,67.89 180.4,68.2 v2(180.4,68.5)
PCH_VRALERT#: length 3.7
  BOTTOM w0.102: UH1.BE32 199.35,18.67 199.35,18.04 199.23,17.92
  BOTTOM w0.127: 199.23,17.92 199.23,17.47 199.8,16.9 199.8,15.99 TH125.1
PCH_XDP_CLK_R_DN: length 1.9
  TOP w0.127: TC305.1 212.74,30.34 v2(212.74,30.12)
  BOTTOM w0.089: UH1.Y3 212.74,30.43 v2(212.74,30.12)
PCH_XDP_CLK_R_DP: length 1.8
  TOP w0.127: v2(212.16,30.12) 212.16,30.35 TC306.1
  BOTTOM w0.089: UH1.Y4 212.81,30.77 v2(212.16,30.12)
PCIE_PRX_C_DTX_N14: length 3.8
  BOTTOM w0.127: UL1.18 56.71,17.45 57.14,17.02 58.06,17.02 v4(58.36,16.71) 58.89,16.19 59.17,16.19 CR13.2
PCIE_PRX_C_DTX_N15: length 2.8
  BOTTOM w0.127: CR15.2 39.03,13.36 39.03,13.65 39.4,14.02 40.11,14.02 40.28,14.19 40.28,14.32 40.21,14.39 UR1.8
PCIE_PRX_C_DTX_P14: length 3.8
  BOTTOM w0.127: UL1.17 57.11,17.41 57.2,17.32 58.16,17.32 58.56,16.91 59.03,16.45 59.49,16.45 59.57,16.53 59.57,16.68 CR11.2
PCIE_PRX_C_DTX_P15: length 2.8
  BOTTOM w0.127: CR14.2 39.29,13.4 39.29,13.54 39.51,13.76 40.21,13.76 40.53,14.08 40.53,14.28 40.61,14.35 UR1.7
PCIE_PRX_DTX_N9: length 195.4
  IN1 w0.135: v2(196.82,37.41) 196.82,37.55 197.06,37.79 197.06,38.19 196.16,39.09 193.56,39.09 193.25,38.78 192.84,38.78 191.97,39.65 191.26,39.65 189.68,38.07 189.34,38.07 188.82,37.55 188.82,29.78 187.22,28.18 187.22,27.79 186.67,27.24 186.04,27.24 185.59,26.79 185.59,25.04 180.75,20.2 179.89,20.2 178.13,18.43 177.39,18.43 173.47,14.51 172.35,14.51 172.21,14.65 155.09,14.65 153.2,12.76 152.63,12.76 151.26,11.39 140.38,11.39 139.01,10.03 135.15,10.03 134.87,9.76 122.73,9.76 122.26,9.29 122.26,8.89 121.87,8.51 114.93,8.51 112.94,8.51 111.37,10.08 108.69,10.08 106.44,7.83 91.03,7.83 89.62,9.24 87.92,9.24 85.54,11.62 83.91,11.62 81.93,13.6 81.93,14.27 79.42,16.78 61.3,16.78 56.86,12.34 46.55,12.34 45.37,11.15 36.53,11.15 35.93,11.75 35.18,11.75 34.43,11.01 34.17,11.01 v2(34.03,11.14)
  BOTTOM w0.127: UH1.G36 197.2,37.21 196.85,37.35 v2(196.82,37.41) ; JSSD1.5 34.85,10.73 34.61,10.97 34.2,10.97 v2(34.03,11.14)
PCIE_PRX_DTX_N10: length 203.7
  IN1 w0.135: v2(196.28,35.68) 196.18,35.78 195.82,35.78 195.45,35.41 194.89,35.41 194.31,34.83 194.31,34.49 195.58,33.22 195.58,28.05 193.99,26.46 193.48,26.46 193.04,26.02 193.04,24.94 192.23,24.12 192.23,20.96 191,19.73 191,18.75 191.44,18.31 191.44,16.38 190.97,15.91 190.97,14 189.51,12.54 182.71,12.54 180.09,9.92 176.98,9.92 174.94,7.88 173.41,7.88 172.62,8.68 168.89,8.68 167.51,10.06 157,10.06 155.66,8.73 155.66,7.46 154.1,5.89 141.49,5.89 141.04,5.44 139.75,5.44 138.95,4.64 84.86,4.64 83.85,5.65 83.85,6.31 79.17,10.99 78.5,10.99 77.05,12.45 73.49,12.45 72.4,13.54 63.91,13.54 59.56,9.18 48.01,9.18 44.86,6.03 37.65,6.03 36.57,7.11 31.82,7.11 31.68,6.96 31.68,6.72 31.77,6.63 v2(31.97,6.63)
  BOTTOM w0.127: JSSD1.17 31.85,8.41 31.74,8.3 31.74,6.86 v2(31.97,6.63) ; UH1.K37 196.45,35.86 v2(196.28,35.68)
PCIE_PRX_DTX_N11: length 202.9
  IN1 w0.135: v2(195.71,36.7) 195.67,36.74 195.32,36.74 193.61,35.03 193.61,33.84 193.97,33.48 193.97,28.54 192.84,27.41 192.84,27.02 191.86,26.04 191.86,24.77 191.51,24.42 191.51,21.74 190.11,20.34 190.11,19.63 189.75,19.27 189.75,17.77 190.25,17.27 190.25,15.77 188.62,14.14 187.93,14.14 187.05,13.26 180.4,13.26 177.79,10.64 176.48,10.64 175.24,9.39 169.2,9.39 167.81,10.78 156.7,10.78 154.95,9.02 154.95,7.76 153.82,6.63 141.09,6.63 140.62,6.16 136.75,6.16 135.95,5.36 87.19,5.36 84.93,7.62 83.82,7.62 79,12.44 78.4,12.44 77.21,13.64 73.32,13.64 72.63,14.32 63.48,14.32 59.06,9.9 47.7,9.9 44.55,6.75 37.95,6.75 36.08,8.62 29.08,8.62 28.63,8.17 28.63,8.05 28.92,7.77 v2(28.92,7.72)
  BOTTOM w0.127: UH1.G38 196.02,36.77 195.95,36.7 v2(195.71,36.7) ; v2(28.92,7.72) 28.76,7.88 28.76,8.32 28.85,8.41 JSSD1.29
PCIE_PRX_DTX_N12: length 207.4
  IN1 w0.135: v2(194.15,36.52) 193.95,36.52 193.67,36.24 193.67,36.03 193.38,35.75 193.18,35.75 192.75,35.31 192.75,34.91 192.89,34.77 192.89,34.36 192.75,34.22 192.75,33.81 192.89,33.67 192.89,33.27 192.75,33.12 192.75,32 192.89,31.86 192.89,31.46 192.75,31.31 192.75,30.91 192.89,30.76 192.89,30.36 192.75,30.21 192.75,29.03 191.76,28.04 191.76,27.22 191.14,26.61 191.14,25.18 190.33,24.36 189.83,24.36 189.45,23.98 189.45,22.23 189,21.78 189,20.87 189.2,20.67 189.2,19.76 189,19.56 189,17.39 189.34,17.05 189.34,15.87 188.39,14.93 187.55,14.93 186.6,13.98 180.1,13.98 177.49,11.36 176.15,11.36 174.91,10.11 169.49,10.11 168.11,11.5 156.4,11.5 154.23,9.32 154.23,8.21 153.37,7.35 140.79,7.35 140.32,6.88 136.46,6.88 135.65,6.07 88.36,6.07 87.06,7.37 86.29,7.37 85.24,8.43 84.54,8.43 80.21,12.76 80.21,13.39 79.23,14.37 73.6,14.37 72.91,15.06 63.17,15.06 58.72,10.62 47.37,10.62 44.32,7.57 41.16,7.57 39.95,8.78 39.01,8.78 38.52,8.29 38.52,8.14 38.62,8.05 38.9,8.05 v2(38.9,8.05)
  BOTTOM w0.089: UH1.H42 193.97,36.7 v2(194.15,36.52)
  BOTTOM w0.127: JSSD1.43 25.35,7.46 27.46,5.35 33,5.35 33.54,5.89 37.03,5.89 38.74,7.6 38.74,7.89 v2(38.9,8.05)
PCIE_PRX_DTX_N14: length 159.2
  IN1 w0.135: v2(110.1,9.02) 110.25,8.88 110.25,8.32 111.05,7.51 122.55,7.51 122.97,7.92 123.38,7.92 124.22,8.76 135.29,8.76 135.56,9.03 139.43,9.03 140.79,10.4 151.67,10.4 153.04,11.76 153.62,11.76 155.51,13.65 171.8,13.65 171.94,13.52 176.56,13.52 178.19,15.14 178.19,16.22 183.93,21.96 184.96,21.96 185.64,22.64 185.64,23.65 186.94,24.94 186.94,25.85 188.22,27.14 188.22,27.77 189.91,29.46 189.91,32.51 190.39,32.98 190.39,36.91 v2(192.05,38.58)
  BOTTOM w0.127: v2(110.1,9.02) 110.33,9.02 110.39,9.08 110.39,9.37 109.92,9.84 105.85,9.84 104.71,10.98 102.93,10.98 101.11,12.81 101.11,14.1 98.52,16.68 82.56,16.68 80.55,18.69 65.78,18.69 63.43,16.34 60.4,16.34 60.32,16.26 CR13.1 ; v2(192.05,38.58) 192.09,38.61 192.09,39.02 UH1.D46
PCIE_PRX_DTX_N15: length 186.2
  IN1 w0.135: v2(41.25,10.13) 41.47,9.92 41.47,8.93 42.06,8.34 44.07,8.34 47.07,11.34 58.42,11.34 62.87,15.78 73.21,15.78 73.9,15.09 79.52,15.09 80.93,13.68 80.93,13.08 84.74,9.26 86.48,9.26 88.95,6.79 122.85,6.79 123.26,7.21 123.68,7.21 124.52,8.04 135.59,8.04 135.86,8.31 139.72,8.31 140.52,9.11 151.98,9.11 155.8,12.93 171.5,12.93 171.64,12.8 176.89,12.8 180.18,16.09 185.25,16.09 186.67,17.5 186.67,22.25 186.42,22.49 186.42,23.27 189.69,26.54 189.69,28.22 191.24,29.77 191.24,35.88 192.23,36.87 192.23,37.12 v2(192.82,37.71)
  BOTTOM w0.127: v2(41.25,10.13) 41.48,10.36 41.48,10.5 41.05,10.93 39.52,10.93 39.05,11.39 39.05,11.83 CR15.1 ; UH1.F44 193.32,37.71 v2(192.82,37.71)
PCIE_PRX_DTX_N16: length 164.2
  IN1 w0.135: v2(310.22,25.54) 310.34,25.66 310.84,25.66 311.23,26.04 311.23,26.92 310.29,27.86 310.29,38.44 306.06,42.67 287.91,42.67 286.73,41.49 272.72,41.49 271.81,42.39 265.84,42.39 265.43,41.98 262.95,41.98 261.77,40.81 258.21,40.81 257.57,41.45 255.55,41.45 255.17,41.83 254.82,41.83 253.72,42.93 249.07,42.93 248.3,43.7 242.71,43.7 241.4,42.38 238.64,42.38 238.2,41.94 236.84,41.94 236.4,42.38 234.36,42.38 233.38,41.4 231.97,41.4 231.55,40.99 230.54,40.99 230.04,40.48 222.23,40.48 218.98,43.74 214.62,43.74 213.84,44.52 210.38,44.52 209.83,43.97 203,43.97 202.32,43.3 202.32,41.12 201.76,40.56 201.14,40.56 199.83,39.25 199.06,39.25 198.37,38.56 198.37,36.9 197.79,36.33 197.79,35.54 196.82,34.57 196.04,34.57 195.61,35 195.19,35 194.85,34.67 v2(194.71,34.67)
  BOTTOM w0.127: v2(310.22,25.54) 310.06,25.71 309.74,25.71 309.4,25.37 309.4,25.04 308.54,24.18 307.14,24.18 306.6,23.64 306.6,22.09 307.09,21.6 307.09,20.84 308.07,19.87 308.07,17.45 307.66,17.04 307.66,16.1 306.29,14.73 304.89,14.73 304.4,14.24 303.84,14.24 303.7,14.1 JWLAN1.35 ; v2(194.71,34.67) 194.71,35.39 UH1.L41
PCIE_PRX_DTX_P9: length 195.3
  IN1 w0.135: v2(34.03,10.43) 34.03,10.6 34.16,10.73 34.55,10.73 35.29,11.47 35.82,11.47 36.42,10.87 45.48,10.87 46.67,12.06 56.97,12.06 61.42,16.5 79.3,16.5 81.65,14.15 81.65,13.49 83.79,11.34 85.42,11.34 87.81,8.96 89.51,8.96 90.91,7.55 106.56,7.55 108.81,9.8 111.26,9.8 112.83,8.23 114.93,8.23 121.99,8.23 122.54,8.78 122.54,9.17 122.84,9.48 134.99,9.48 135.26,9.75 139.13,9.75 140.49,11.11 151.38,11.11 152.74,12.48 153.32,12.48 155.21,14.37 172.1,14.37 172.24,14.24 173.58,14.24 177.5,18.15 178.24,18.15 180.01,19.92 180.86,19.92 185.87,24.92 185.87,26.68 186.16,26.96 186.79,26.96 187.5,27.68 187.5,28.07 189.1,29.66 189.1,35.83 189.24,35.97 189.24,36.37 189.1,36.52 189.1,37.43 189.45,37.79 189.8,37.79 190.53,38.52 190.74,38.52 191.02,38.81 191.02,39.01 191.38,39.37 191.85,39.37 192.72,38.5 193.36,38.5 193.68,38.81 194.95,38.81 195.09,38.66 195.5,38.66 195.64,38.81 196.05,38.81 196.78,38.08 196.78,37.9 196.63,37.76 196.51,37.76 v2(196.37,37.9)
  BOTTOM w0.127: UH1.F36 v2(196.37,37.9) ; v2(34.03,10.43) 33.94,10.52 33.94,10.61 34.05,10.72 34.5,10.72 34.59,10.63 34.59,10.18 34.54,10.13 34.44,10.13 34.35,10.03 JSSD1.7
PCIE_PRX_DTX_P10: length 203.8
  IN1 w0.135: v2(195.98,36.18) 195.85,36.06 195.7,36.06 195.34,35.69 194.78,35.69 194.03,34.95 194.03,34.37 195.3,33.1 195.3,28.16 193.87,26.74 193.37,26.74 192.76,26.13 192.76,25.05 191.95,24.24 191.95,21.07 190.72,19.85 190.72,18.64 191.16,18.2 191.16,16.5 190.69,16.03 190.69,14.12 189.39,12.82 182.59,12.82 179.98,10.2 176.87,10.2 174.83,8.16 173.53,8.16 172.73,8.96 169,8.96 167.62,10.34 156.88,10.34 155.39,8.84 155.39,7.58 153.98,6.17 141.38,6.17 140.92,5.72 139.63,5.72 138.83,4.92 84.97,4.92 84.13,5.76 84.13,6.43 79.29,11.27 78.62,11.27 77.16,12.73 73.61,12.73 72.52,13.82 63.8,13.82 59.44,9.46 47.89,9.46 44.74,6.31 37.77,6.31 36.69,7.39 31.71,7.39 31.4,7.08 31.4,6.77 v2(31.26,6.63)
  BOTTOM w0.127: UH1.J37 v2(195.98,36.18) ; v2(31.26,6.63) 31.48,6.85 31.48,8.28 31.35,8.41 JSSD1.19
PCIE_PRX_DTX_P11: length 202.9
  IN1 w0.135: v2(195.34,37.15) 193.33,35.14 193.33,33.72 193.69,33.37 193.69,28.66 192.56,27.53 192.56,27.13 191.58,26.16 191.58,24.89 191.23,24.53 191.23,21.85 189.83,20.45 189.83,19.75 189.47,19.39 189.47,17.66 189.97,17.16 189.97,15.89 188.5,14.42 187.82,14.42 186.94,13.54 180.29,13.54 177.67,10.92 176.37,10.92 175.12,9.67 169.31,9.67 167.93,11.06 156.58,11.06 154.67,9.14 154.67,7.87 153.7,6.91 140.98,6.91 140.5,6.44 136.64,6.44 135.84,5.63 87.31,5.63 85.05,7.9 83.94,7.9 79.11,12.72 78.52,12.72 77.32,13.92 73.43,13.92 72.75,14.6 63.36,14.6 58.94,10.18 47.58,10.18 44.43,7.03 38.06,7.03 36.19,8.9 28.97,8.9 28.35,8.29 28.35,7.74 v2(28.33,7.72)
  BOTTOM w0.127: v2(28.33,7.72) 28.51,7.9 28.51,8.25 28.35,8.41 JSSD1.31 ; UH1.F39 v2(195.34,37.15)
PCIE_PRX_DTX_P12: length 207.3
  IN1 w0.135: v2(194.43,37.08) 194.12,37.08 192.47,35.43 192.47,29.15 191.48,28.15 191.48,27.33 190.87,26.72 190.87,25.29 190.21,24.64 189.71,24.64 189.17,24.1 189.17,22.35 188.72,21.9 188.72,20.76 188.92,20.56 188.92,19.88 188.72,19.68 188.72,17.28 189.06,16.94 189.06,15.99 188.28,15.21 187.44,15.21 186.49,14.25 179.99,14.25 177.37,11.64 176.04,11.64 174.79,10.39 169.61,10.39 168.23,11.78 156.29,11.78 153.95,9.44 153.95,8.32 153.25,7.63 140.68,7.63 140.2,7.15 136.34,7.15 135.54,6.35 88.47,6.35 87.17,7.65 86.41,7.65 85.36,8.71 84.65,8.71 80.49,12.87 80.49,13.5 79.34,14.65 73.72,14.65 73.03,15.34 63.05,15.34 58.61,10.9 47.25,10.9 44.2,7.85 41.28,7.85 40.07,9.06 38.89,9.06 38.24,8.41 38.24,8.21 v2(38.08,8.05)
  BOTTOM w0.089: UH1.J41 194.43,36.92 v2(194.43,37.08)
  BOTTOM w0.127: JSSD1.41 25.85,8.42 25.77,8.34 25.67,8.34 25.61,8.28 25.61,7.57 27.56,5.61 32.9,5.61 33.43,6.14 36.92,6.14 38.48,7.7 38.48,8.2 38.38,8.3 38.23,8.3 38.08,8.14 v2(38.08,8.05)
PCIE_PRX_DTX_P14: length 159.2
  IN1 w0.135: v2(110.81,9.02) 110.6,9.02 110.53,8.95 110.53,8.43 111.17,7.79 122.44,7.79 122.85,8.2 123.27,8.2 124.1,9.04 135.17,9.04 135.45,9.31 139.31,9.31 140.67,10.67 151.56,10.67 152.93,12.04 153.5,12.04 155.39,13.93 171.92,13.93 172.05,13.8 176.45,13.8 177.91,15.25 177.91,16.34 183.81,22.24 184.84,22.24 185.36,22.76 185.36,23.76 186.66,25.06 186.66,25.97 187.94,27.25 187.94,27.88 189.63,29.57 189.63,32.62 190.11,33.1 190.11,34.77 189.96,34.92 189.96,35.32 190.11,35.46 190.11,35.87 189.96,36.01 189.96,36.34 190.11,36.49 190.11,37.03 190.86,37.78 190.86,37.99 191.15,38.27 191.35,38.27 191.65,38.57 191.65,38.84 191.58,38.91 v2(191.52,38.91)
  BOTTOM w0.127: v2(191.52,38.91) 191.64,39.03 UH1.C47 ; CR11.1 60.56,16.6 63.33,16.6 65.67,18.95 80.65,18.95 82.66,16.94 98.63,16.94 101.36,14.2 101.36,12.91 103.04,11.24 104.82,11.24 105.96,10.1 110.03,10.1 110.65,9.48 110.65,9.18 v2(110.81,9.02)
PCIE_PRX_DTX_P15: length 186.1
  IN1 w0.135: v2(192.36,38.08) 192.42,38.03 192.42,37.7 191.95,37.23 191.95,36.98 190.96,36 190.96,31.98 190.82,31.84 190.82,31.43 190.96,31.29 190.96,30.88 190.82,30.74 190.82,30.33 190.96,30.19 190.96,29.89 189.41,28.34 189.41,26.66 189.13,26.37 188.92,26.37 188.64,26.08 188.64,25.88 188.35,25.59 188.15,25.59 187.86,25.31 187.86,25.1 186.14,23.38 186.14,22.38 186.39,22.13 186.39,17.61 185.14,16.36 180.06,16.36 176.78,13.08 171.76,13.08 171.62,13.21 155.69,13.21 151.86,9.39 140.4,9.39 139.61,8.59 135.74,8.59 135.47,8.32 124.4,8.32 123.57,7.48 123.15,7.48 122.74,7.07 89.07,7.07 86.6,9.54 84.86,9.54 81.21,13.19 81.21,13.8 79.64,15.37 74.01,15.37 73.32,16.06 62.75,16.06 58.31,11.62 46.95,11.62 43.95,8.62 42.18,8.62 41.75,9.05 41.75,9.92 v2(41.97,10.13)
  BOTTOM w0.127: v2(41.97,10.13) 41.74,10.36 41.74,10.6 41.16,11.18 39.62,11.18 39.31,11.5 39.31,11.83 CR14.1 ; v2(192.36,38.08) 192.6,38.08 UH1.E45
PCIE_PRX_DTX_P16: length 164.1
  IN1 w0.135: v2(310.22,26.13) 310.22,26.09 310.37,25.94 310.73,25.94 310.95,26.16 310.95,26.8 310.01,27.74 310.01,38.32 305.94,42.39 288.03,42.39 286.84,41.21 272.61,41.21 271.7,42.11 265.96,42.11 265.55,41.7 263.06,41.7 261.89,40.53 258.1,40.53 257.45,41.17 255.44,41.17 255.06,41.55 254.7,41.55 253.61,42.65 248.95,42.65 248.18,43.42 242.83,43.42 241.51,42.1 238.76,42.1 238.32,41.66 236.72,41.66 236.29,42.1 234.47,42.1 233.49,41.12 232.08,41.12 231.67,40.71 230.66,40.71 230.15,40.2 222.12,40.2 218.86,43.46 214.5,43.46 213.72,44.24 210.49,44.24 209.94,43.69 208.84,43.69 208.7,43.55 208.29,43.55 208.15,43.69 207.75,43.69 207.6,43.55 207.2,43.55 207.05,43.69 206.65,43.69 206.5,43.55 206.1,43.55 205.96,43.69 205.55,43.69 205.41,43.55 205,43.55 204.86,43.69 204.45,43.69 204.31,43.55 203.91,43.55 203.76,43.69 203.11,43.69 202.6,43.18 202.6,42.17 202.74,42.03 202.74,41.62 202.6,41.48 202.6,41 201.88,40.28 201.25,40.28 200.72,39.75 200.72,39.54 200.43,39.26 200.23,39.26 199.94,38.97 199.18,38.97 198.65,38.44 198.65,37.89 198.8,37.74 198.8,37.34 198.65,37.19 198.65,36.79 198.07,36.21 198.07,35.43 197.71,35.07 197.71,34.86 197.43,34.58 197.22,34.58 196.94,34.29 195.92,34.29 195.5,34.72 195.3,34.72 195.13,34.55 195.13,34.42 v2(195.23,34.32)
  BOTTOM w0.127: JWLAN1.33 303.74,14.6 303.84,14.5 304.3,14.5 304.78,14.98 306.18,14.98 307.41,16.21 307.41,17.15 307.81,17.56 307.81,19.76 306.84,20.74 306.84,21.49 306.34,21.98 306.34,23.74 307.04,24.44 308.43,24.44 309.15,25.15 309.15,25.48 309.63,25.96 310.06,25.96 v2(310.22,26.13) ; UH1.M40 195.53,34.66 195.53,34.39 195.47,34.32 v2(195.23,34.32)
PCIE_PTX_C_DRX_N9: length 4
  TOP w0.127: C369.2 34.67,7.85 34.67,7.71 34.56,7.6 33.84,7.6 33.63,7.39 33.32,7.39 33.25,7.46 33.25,7.7 v2(33.39,7.83)
  BOTTOM w0.127: JSSD1.11 33.35,8.6 33.23,8.48 33.23,8 v2(33.39,7.83)
PCIE_PTX_C_DRX_N10: length 2.7
  TOP w0.127: v2(30.39,7.91) 30.23,7.75 30.23,7.24 C371.2
  BOTTOM w0.127: v2(30.39,7.91) 30.23,8.07 30.23,8.46 30.35,8.58 JSSD1.23
PCIE_PTX_C_DRX_N11: length 2.9
  TOP w0.127: C373.2 27.26,7.18 27.26,7.75 v2(27.4,7.89)
  BOTTOM w0.127: v2(27.4,7.89) 27.23,8.07 27.23,8.37 27.35,8.49 JSSD1.35
PCIE_PTX_C_DRX_N12: length 2.7
  TOP w0.127: v2(24.4,7.88) 24.29,7.77 24.29,7.29 C375.2
  BOTTOM w0.127: JSSD1.47 24.35,8.65 24.23,8.52 24.23,8.05 v2(24.4,7.88)
PCIE_PTX_C_DRX_N14: length 168.6
  IN1 w0.135: v2(112.71,9.97) 112.85,9.82 112.85,9.23 113.12,8.95 114.38,8.95 115.23,9.8 115.56,9.8 116.81,11.06 119.51,11.06 120.8,12.35 124.45,12.35 124.87,12.78 134.88,12.78 135.13,13.03 138.33,13.03 139.55,14.24 142.21,14.24 143.17,15.2 150.59,15.2 150.75,15.36 152.01,15.36 153.89,17.25 171.79,17.25 172.51,17.96 173.24,17.96 173.99,18.71 173.99,19.36 186.19,31.56 186.19,33.51 185.62,34.08 185.62,35.66 186.05,36.08 186.05,38.72 190.81,43.48 193.14,43.48 194.95,45.29 195.23,45.29 v2(195.37,45.16)
  BOTTOM w0.127: v2(195.37,45.16) 195.37,45.26 195.3,45.33 194.83,45.33 194.57,45.06 194.57,44.59 194.72,44.44 194.89,44.44 CH76.1 ; v2(112.71,9.97) 112.55,10.12 112.55,10.3 112.63,10.38 112.94,10.38 113,10.44 113,10.63 112.66,10.97 109.08,10.97 107.59,12.46 105.74,12.46 99.99,18.21 86.96,18.21 83.66,21.52 75.46,21.52 74.57,20.62 72.71,20.62 72.32,20.23 65.16,20.23 63.03,18.11 60.36,18.11 59.39,19.08 59.15,19.08 58.75,19.49 58.32,19.49 58.17,19.34 UL1.14
PCIE_PTX_C_DRX_N15: length 183.2
  IN1 w0.135: v2(44.52,12.25) 44.68,12.41 44.68,12.98 46.2,14.49 49.27,14.49 50.09,13.67 51.1,13.67 51.71,13.05 56.34,13.05 60.87,17.59 79.66,17.59 83.21,14.04 86.34,14.04 87.36,13.01 87.36,11.99 88.74,10.62 99.47,10.62 100.58,9.5 107.1,9.5 108.39,10.8 113.97,10.8 115.22,12.06 119.1,12.06 121.33,14.29 124.82,14.29 125.44,14.91 127.98,14.91 128.59,14.29 132.27,14.29 132.91,14.93 133.46,14.93 133.85,14.54 138.44,14.54 139.14,15.24 141.79,15.24 142.76,16.2 150,16.2 152.05,18.25 171.38,18.25 184.82,31.69 184.82,33.47 184.62,33.67 184.62,38.94 190.17,44.49 191.16,44.49 191.41,44.73 191.41,45.39 191.67,45.65 191.92,45.65 v2(192.12,45.85)
  BOTTOM w0.127: CH78.1 192.93,44.74 192.93,45.53 192.67,45.79 192.19,45.79 v2(192.12,45.85) ; UR1.4 41.81,14.39 41.92,14.27 41.92,13.38 42.51,12.8 44.64,12.8 44.75,12.69 44.75,12.48 v2(44.52,12.25)
PCIE_PTX_C_DRX_N16: length 164.2
  IN1 w0.135: v2(311.51,27.89) 311.63,28 311.63,28.18 311.51,28.3 311.01,28.3 310.73,28.59 310.73,38.79 305.84,43.68 287.64,43.68 286.72,42.75 282.45,42.75 281.55,43.65 265.28,43.65 264.09,42.45 261.92,42.45 261.56,42.1 260.76,42.1 259.46,43.4 258.81,43.4 257.91,44.29 255.32,44.29 254.66,44.96 250.77,44.96 249.58,46.14 245.8,46.14 245.04,46.9 240.49,46.9 238.48,44.9 237.56,44.9 236.73,45.73 235.45,45.73 234.63,44.91 233.91,44.91 232.83,43.82 231.42,43.82 230.86,43.26 228.16,43.26 227.46,42.56 223.14,42.56 219.86,45.83 215.66,45.83 214.94,46.55 209.54,46.55 209.08,46.09 197.13,46.09 196.71,46.52 191.33,46.52 190.83,46.02 190.83,45.79 v2(191.01,45.62)
  BOTTOM w0.127: CH60.1 190.84,44.84 190.84,45.45 v2(191.01,45.62) ; JWLAN1.29 303.73,15.6 303.86,15.72 304.65,15.72 304.81,15.57 305.95,15.57 306.95,16.57 306.95,19.37 306.3,20.03 306.3,21.37 305.91,21.75 305.91,23.99 306.19,24.27 306.19,25.13 307.46,26.4 309.67,26.4 310.24,26.96 310.24,27.52 310.9,28.19 311.22,28.19 v2(311.51,27.89)
PCIE_PTX_C_DRX_P9: length 4
  TOP w0.127: C370.2 34.29,7.34 33.94,7.34 33.73,7.13 33.22,7.13 33,7.35 33,7.65 v2(32.81,7.83)
  BOTTOM w0.127: JSSD1.13 32.85,8.58 32.97,8.46 32.97,8 v2(32.81,7.83)
PCIE_PTX_C_DRX_P10: length 2.7
  TOP w0.127: C372.2 29.97,7.21 29.97,7.74 v2(29.81,7.91)
  BOTTOM w0.127: v2(29.81,7.91) 29.97,8.08 29.97,8.5 29.85,8.62 JSSD1.25
PCIE_PTX_C_DRX_P11: length 2.9
  TOP w0.127: v2(26.82,7.89) 27.01,7.71 27.01,7.08 C374.2
  BOTTOM w0.127: v2(26.82,7.89) 26.97,8.05 26.97,8.38 26.85,8.5 JSSD1.37
PCIE_PTX_C_DRX_P12: length 2.8
  TOP w0.127: v2(23.81,7.88) 24.03,7.66 24.03,7.23 C376.2
  BOTTOM w0.127: JSSD1.49 23.85,8.6 23.97,8.48 23.97,8.04 v2(23.81,7.88)
PCIE_PTX_C_DRX_P14: length 168.6
  IN1 w0.135: v2(195.37,45.74) 195.2,45.57 194.84,45.57 194.51,45.25 194.31,45.25 194.02,44.96 194.02,44.76 193.02,43.76 192.62,43.76 192.47,43.9 192.07,43.9 191.92,43.76 190.69,43.76 185.77,38.83 185.77,36.2 185.34,35.77 185.34,33.96 185.91,33.39 185.91,31.67 173.72,19.48 173.72,18.83 173.13,18.24 172.39,18.24 171.68,17.53 153.78,17.53 151.89,15.64 150.64,15.64 150.48,15.48 143.05,15.48 142.09,14.52 139.43,14.52 138.22,13.3 135.01,13.3 134.77,13.06 124.76,13.06 124.33,12.63 120.69,12.63 119.4,11.34 116.7,11.34 115.44,10.08 115.11,10.08 114.26,9.23 113.24,9.23 113.13,9.34 113.13,9.91 113.19,9.97 v2(113.42,9.97)
  BOTTOM w0.127: v2(195.37,45.74) 195.21,45.58 194.73,45.58 194.31,45.17 194.31,44.75 CH75.1 ; v2(113.42,9.97) 113.25,10.13 113.25,10.73 112.77,11.22 109.19,11.22 107.69,12.72 105.85,12.72 100.09,18.47 87.07,18.47 83.76,21.77 75.36,21.77 74.46,20.88 72.6,20.88 72.21,20.49 65.05,20.49 62.93,18.37 60.46,18.37 59.5,19.34 59.26,19.34 58.85,19.74 UL1.13
PCIE_PTX_C_DRX_P15: length 183.2
  IN1 w0.135: v2(192.12,45.22) 191.97,45.37 191.78,45.37 191.69,45.28 191.69,44.62 191.28,44.21 190.28,44.21 190,43.92 190,43.72 189.71,43.43 189.51,43.43 189.22,43.14 189.22,42.94 188.94,42.65 188.73,42.65 188.45,42.37 188.45,42.16 188.16,41.88 187.96,41.88 184.9,38.82 184.9,33.78 185.1,33.58 185.1,31.57 171.49,17.97 152.16,17.97 150.12,15.92 142.87,15.92 141.91,14.96 139.25,14.96 138.56,14.26 133.73,14.26 133.34,14.65 133.02,14.65 132.38,14.01 128.47,14.01 127.86,14.63 125.55,14.63 124.94,14.01 121.45,14.01 119.21,11.78 115.34,11.78 114.08,10.52 108.51,10.52 107.21,9.22 100.47,9.22 99.35,10.34 88.62,10.34 87.08,11.88 87.08,12.9 86.22,13.76 83.09,13.76 79.55,17.31 60.99,17.31 56.46,12.78 51.6,12.78 50.98,13.39 49.98,13.39 49.16,14.21 46.31,14.21 44.96,12.86 44.96,12.39 45.1,12.25 v2(45.23,12.25)
  BOTTOM w0.127: UR1.3 42.21,14.32 42.18,14.29 42.18,13.49 42.62,13.05 44.75,13.05 45,12.8 45,12.48 v2(45.23,12.25) ; CH77.1 192.6,44.51 192.67,44.58 192.67,45.43 192.57,45.53 192.42,45.53 192.34,45.44 192.24,45.44 192.12,45.33 v2(192.12,45.22)
PCIE_PTX_C_DRX_P16: length 164.2
  IN1 w0.135: v2(190.42,45.62) 190.55,45.75 190.55,46.14 191.21,46.8 196.82,46.8 197.25,46.37 208.96,46.37 209.42,46.83 215.06,46.83 215.77,46.11 219.98,46.11 223.25,42.84 227.34,42.84 228.04,43.54 230.74,43.54 231.31,44.1 232.71,44.1 233.79,45.19 234.51,45.19 235.34,46.01 236.84,46.01 237.67,45.18 238.37,45.18 240.37,47.18 245.15,47.18 245.92,46.42 249.7,46.42 250.88,45.24 254.78,45.24 255.44,44.57 258.03,44.57 258.93,43.68 259.58,43.68 260.88,42.38 261.45,42.38 261.8,42.73 263.97,42.73 265.17,43.93 281.67,43.93 282.56,43.03 286.6,43.03 287.53,43.96 305.96,43.96 311.01,38.91 311.01,28.7 311.13,28.58 311.37,28.58 v2(311.51,28.73)
  BOTTOM w0.127: v2(311.51,28.73) 311.23,28.44 310.8,28.44 309.98,27.63 309.98,27.07 309.56,26.65 307.35,26.65 305.94,25.24 305.94,24.38 305.66,24.1 305.66,21.64 306.04,21.26 306.04,19.92 306.7,19.27 306.7,16.67 305.85,15.82 304.91,15.82 304.76,15.98 303.86,15.98 303.73,16.1 JWLAN1.27 ; v2(190.42,45.62) 190.58,45.47 190.58,44.8 CH61.1
PCIE_PTX_DRX_N9: length 203.1
  TOP w0.127: C369.1 35.44,7.65 35.5,7.6 37.79,7.6 38.54,6.85 40.75,6.85 45.68,11.79 46,11.79 46.69,12.47 53.34,12.47 54.16,11.65 58.13,11.65 60.8,14.32 61.45,14.32 65.75,18.63 69.29,18.63 74.53,23.86 84.27,23.86 88.86,19.27 96.44,19.27 101.06,14.64 101.06,13.79 102.5,12.34 103.81,12.34 105.9,10.26 111.24,10.26 113,8.5 115.85,8.5 115.97,8.62 115.97,8.97 115.86,9.08 v2(115.69,9.08)
  IN1 w0.135: v2(196.14,44.01) 196.01,43.88 194.44,43.88 193.6,43.03 190.99,43.03 186.55,38.6 186.55,35.85 186.17,35.47 186.17,34.15 186.63,33.69 186.63,31.33 180.42,25.12 180.42,24.04 176.97,20.59 176.49,20.59 173.43,17.52 172.69,17.52 171.97,16.81 154.07,16.81 152.19,14.92 150.96,14.92 150.8,14.77 143.35,14.77 142.39,13.8 139.73,13.8 138.27,12.34 125.06,12.34 124.63,11.91 120.99,11.91 119.69,10.62 117,10.62 115.86,9.48 115.86,9.26 v2(115.69,9.08)
  BOTTOM w0.089: v2(196.14,44.01) 196.14,43.92 196.3,43.76 196.72,43.76 198.07,42.4 198.07,39.44 198.16,39.35 198.16,39.19 198.11,39.14 198.01,39.14 UH1.C34
PCIE_PTX_DRX_N10: length 209.7
  TOP w0.127: C371.1 30.24,5.68 30.24,5.5 30.36,5.39 34.38,5.39 35.57,6.57 37.83,6.57 38.27,6.13 41,6.13 45.96,11.08 46.32,11.08 47,11.76 53.08,11.76 53.87,10.97 58.42,10.97 61.09,13.64 61.93,13.64 66.16,17.87 69.67,17.87 74.96,23.16 83.72,23.16 88.33,18.56 96.11,18.56 100.34,14.33 100.34,10.13 102.66,7.81 v4(114.3,7.81) 116.4,7.81 117.4,8.81 117.4,9.35 117.9,9.85 118.89,9.85 119.14,9.6 119.14,9.3 v2(119.37,9.07)
  IN1 w0.135: v2(119.37,9.07) 119.18,9.07 119.07,9.18 119.07,9.35 119.35,9.62 120.11,9.62 121.4,10.91 125.04,10.91 125.47,11.34 138.68,11.34 140.15,12.8 142.8,12.8 143.07,13.07 150.75,13.07 151.6,13.92 152.6,13.92 154.49,15.81 172.39,15.81 173.1,16.53 173.84,16.53 176.91,19.59 177.49,19.59 181.82,23.93 181.82,25.1 187.63,30.9 187.63,38.26 191.14,41.78 192.28,41.78 192.43,41.63 192.83,41.63 192.98,41.78 193.38,41.78 193.53,41.63 193.93,41.63 194.07,41.78 194.48,41.78 195.15,42.45 195.91,42.45 v2(196.12,42.24)
  BOTTOM w0.089: v2(196.12,42.24) 196.3,42.42 196.89,42.42 197.48,41.83 197.48,40.18 197.34,40.04 197.34,39.24 UH1.C35
PCIE_PTX_DRX_N11: length 212.1
  TOP w0.127: C373.1 27.33,5.87 27.18,5.71 27.18,5.15 27.69,4.65 34.62,4.65 35.85,5.88 37.42,5.88 37.86,5.44 41.28,5.44 46.23,10.39 46.63,10.39 47.29,11.05 52.82,11.05 53.59,10.28 58.71,10.28 61.38,12.95 62.25,12.95 66.17,16.87 69.67,16.87 75.23,22.42 83.33,22.42 87.9,17.84 95.81,17.84 99.65,14.01 99.65,9.85 102.52,6.97 115.8,6.97 115.95,7.12 116.35,7.12 116.5,6.97 116.9,6.97 117.05,7.12 117.45,7.12 117.59,6.97 118,6.97 118.14,7.12 118.55,7.12 118.69,6.97 119.21,6.97 120.04,7.8 120.04,8.01 120.33,8.29 120.54,8.29 120.82,8.58 120.82,9 120.75,9.07 v2(120.54,9.07)
  IN1 w0.135: v2(196.17,41.65) 195.46,41.65 194.75,40.94 191.54,40.94 189.38,38.79 188.92,38.79 188.09,37.96 188.09,30.06 186.8,28.78 186.14,28.78 184.82,27.46 184.82,26.61 183.7,25.49 183.32,25.49 182.35,24.52 182.35,23.73 177.77,19.15 177.09,19.15 174.02,16.09 173.29,16.09 172.57,15.37 154.77,15.37 152.89,13.49 151.97,13.49 151.12,12.64 143.26,12.64 142.98,12.36 140.33,12.36 138.87,10.9 125.65,10.9 125.23,10.48 121.58,10.48 120.71,9.6 120.71,9.24 v2(120.54,9.07)
  BOTTOM w0.089: v2(196.17,41.65) 196.34,41.49 196.94,41.49 197.3,41.13 197.3,40.46 197.04,40.2 197.02,40.18 197.02,40.06 197.14,39.94 197.14,39.74 197.09,39.69 197.01,39.69 UH1.B36
PCIE_PTX_DRX_N12: length 216.4
  TOP w0.127: v2(124.18,6.79) 124.3,6.79 124.48,6.61 124.48,6.46 124.28,6.26 123.18,6.26 123.04,6.4 122.63,6.4 122.49,6.26 122.09,6.26 121.94,6.4 121.54,6.4 121.39,6.26 102.09,6.26 98.96,9.38 98.96,13.72 95.65,17.03 87.6,17.03 83.03,21.61 75.47,21.61 69.94,16.08 66.58,16.08 62.76,12.26 61.67,12.26 58.99,9.59 53.3,9.59 52.65,10.24 47.48,10.24 46.92,9.68 46.56,9.68 41.64,4.75 37.48,4.75 37.05,5.18 36.14,5.18 34.9,3.94 25.3,3.94 24.19,5.05 24.19,6.07 24.25,6.14 24.52,6.14 C375.1
  IN1 w0.135: v2(124.18,6.79) 124.42,7.03 124.42,7.32 124.7,7.6 129.25,7.6 129.78,7.07 135.24,7.07 136.04,7.87 139.91,7.87 140.7,8.67 152.16,8.67 155.99,12.5 168.52,12.5 169.91,11.11 174.42,11.11 175.66,12.36 177.07,12.36 179.69,14.97 185.07,14.97 185.6,15.5 185.6,15.78 187.34,17.52 187.34,17.94 187.76,18.36 187.76,19.13 187.44,19.45 187.44,20.36 187.8,20.72 187.8,23.9 190.13,26.23 190.13,28.04 191.72,29.63 191.72,35.66 193.35,37.3 193.35,37.81 193.81,38.26 194.77,38.26 v2(194.83,38.32)
  BOTTOM w0.089: UH1.D38 196.29,38.78 195.92,38.42 195.44,38.42 195.33,38.31 195.33,38.3 195.27,38.24 194.9,38.24 v2(194.83,38.32)
PCIE_PTX_DRX_N14: length 5.7
  BOTTOM w0.089: 195.14,41.67 195.14,41.65 195.11,41.61 195.11,41.21 195.38,40.94 195.38,40.52 195.79,40.11 195.79,39.62 195.97,39.44 195.97,39.11 195.9,39.03 195.8,39.03 195.74,39.09 UH1.C39
  BOTTOM w0.127: CH76.2 194.55,43.18 194.55,42.74 195.14,42.14 195.14,41.67
PCIE_PTX_DRX_N15: length 5.7
  BOTTOM w0.089: 194.44,41.5 194.45,41.49 194.45,41.44 194.67,41.22 194.67,41.1 195.01,40.76 195.01,40.13 195.15,39.99 195.15,39.62 195.2,39.58 195.25,39.58 UH1.B40
  BOTTOM w0.127: CH78.2 192.8,43.6 192.72,43.52 192.72,43.22 194.44,41.5
PCIE_PTX_DRX_N16: length 7.4
  BOTTOM w0.089: 193.71,41.02 193.73,41.02 193.76,40.99 194.26,40.99 194.64,40.6 194.64,40.19 194.47,40.02 194.47,39.64 194.53,39.58 194.67,39.58 194.72,39.62 UH1.B41
  BOTTOM w0.127: 193.71,41.02 192.59,41.02 190.76,42.84 190.76,43.53 190.83,43.59 CH60.2
