# Allegro board LA-H461P Rev02.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on BOTTOM (solid shape): 56.16,40.51 56.16,39.51 55.74,39.09 55.74,38.59 55.68,38.5 55.58,38.51 55.55,38.53 55.51,38.58 55.51,38.65 55.07,39.12 54.99,38.48 55.04,38.42 55.03,38.35 55.15,37.94 55.58,37.94 55.68,37.95 55.74,37.86 55.74,34.76 56.02,34.48 56.03,34.47 56.35,34.15 56.36,34.13 56.44,34 56.58,33.91 56.59,33.91 56.74,33.76 56.74,32.56 57.02,32.28 57.02,31.15 56.92,31.06 55.82,31.06 55.43,31.44 55.43,33.29 54.6,34.13 54.6,35.04 53.82,35.83 53.82,39.79 54.84,40.82 55.85,40.82
+5VS on IN2 (solid shape): 17.35,113.28 17.35,112.6 15.98,111.22 15.52,111.22 15.12,111.63 15.12,112.09 16.57,113.54 17.1,113.54
+5VS on IN2 (solid shape): 264.02,43.9 264.02,43.06 263.84,42.88 261.79,42.88 261.58,42.67 261.21,42.67 261.1,42.77 261.1,43.9 261.21,44 261.37,44 261.37,44.01 263.91,44.01
+5VS on IN2 (solid shape): outline of 108 points within 56.37,29.36 59.28,32.6
+5VS on IN3 (solid shape): outline of 227 points within 95,11.52 99.02,24.7
+5VS on VCC: 178.47,9.68 176.59,11.55 172.22,11.55 169.53,14.25 154.61,14.25 150.22,9.85 94.55,9.85 94.11,10.29 94.11,12.06 94.34,12.29 98.66,12.29 99.26,11.68 149.79,11.68 153.88,15.77 170.18,15.77 172.8,13.15 177.57,13.15 178.66,12.06 199.61,12.06 201.14,13.6 217.26,13.6 218.94,15.27 237.88,15.27 239.78,17.18 270.8,17.18 272.05,18.42 272.05,25.6 271.46,26.19 258.12,26.19 257.89,26.42 257.89,39.07 256.77,40.18 256.77,42.18 257.19,42.59 257.76,42.59 257.95,42.79 257.95,43.06 257.8,43.21 258.59,43.99 263.85,43.99 264.04,43.81 264.04,30.47 264.84,29.68 275.39,29.68 276.08,28.99 276.08,15.11 275.8,14.83 249.35,14.83 247.79,13.28 226.52,13.28 222.91,9.68 ; 1 cut-out
+5VS on IN2: 91.92,26.98 91.91,26.96 92.02,26.7 92.29,26.59 92.31,26.59 93.63,25.27 96.19,25.27 96.43,25.18 96.67,25.27 97.72,25.27 98,24.99 98,24.13 97.16,23.29 96.78,23.29 96.77,23.3 96.63,23.33 96.49,23.3 96.48,23.29 90.23,23.29 88.13,25.39 85.22,25.39 82.09,28.53 77.81,28.53 77.81,29.69 77.95,29.82 84.57,29.82 86.2,28.19 88.22,28.19 88.47,28.1 88.71,28.19 88.93,28.19 88.98,28.09 89.04,28.01 89.06,27.92 89,27.85 88.97,27.2 89.48,27.61 89.5,27.7 89.58,27.74 89.79,27.76 89.99,27.84 90.71,27.12 90.7,27.09 90.98,26.59 91.38,27 91.4,27.08 91.48,27.11 91.79,27.11
+5VS on IN2: 53.13,39.28 53.02,39.4 52.51,39.4 52.29,39.62 52.22,39.62 52.18,39.66 50.08,39.66 50.03,39.62 49.82,39.62 49.53,39.33 39.86,39.33 38.59,40.59 38.59,43.21 36.84,44.96 35.88,45.91 34.29,45.91 33.43,46.77 32.72,46.77 32.71,46.76 31.93,46.76 30.97,47.72 30.65,47.72 29.46,48.92 25.07,48.92 24.46,49.53 24.46,51.33 24.81,51.67 24.83,51.67 25.03,51.69 25.19,51.81 27.35,51.81 27.82,51.33 29.66,51.33 30.09,50.9 32.98,50.9 34.05,49.84 34.58,49.84 35.09,49.33 38.22,46.2 38.72,46.2 43.77,41.15 43.77,40.73 44.18,40.32 48.65,40.32 49.17,40.84 53.61,40.84 53.7,40.79 53.7,40.69 53.93,40.16 54.37,40.53 54.43,40.63 54.54,40.6 54.62,40.53 55.41,40.53 55.59,40.35 55.59,39.55 55.45,39.41 54.95,39.41 54.82,39.28
+5VS on IN3: 261,43.94 261,42.74 261.54,42.2 273.25,42.2 273.56,42.51 273.56,42.69 274.41,43.54 276.98,43.54 277.2,43.75 277.2,45.64 276.81,46.03 275.03,46.03 273.15,47.91 265.88,47.91 262.26,44.29 261.35,44.29
+5VS_HDD1 on TOP (solid shape): 248.82,14.97 248.82,12.8 248.69,12.68 248.15,12.68 248.1,12.72 248.1,12.89 248.1,12.94 248.1,12.98 248.1,13.14 247.97,13.28 247.86,13.28 247.75,13.3 247.64,13.28 245.98,13.28 245.9,13.36 245.9,15.13 246.07,15.31 248.47,15.31
+5VS_HDD1 on BOTTOM (solid shape): 257.62,16.92 257.62,14.78 257.58,14.75 256.96,14.75 256.78,14.93 256.53,14.93 256.52,14.93 254.01,14.93 254,14.92 252.33,14.92 250.11,12.7 248.24,12.7 248.13,12.81 248.13,14.53 248.66,15.06 249.86,15.06 249.98,15.17 249.98,16.74 250.23,16.99 257.55,16.99
+5VS_KBL on BOTTOM (solid shape): 213.63,12.7 214.21,12.7 215.15,11.76 215.15,11 215.11,10.97 213.84,10.97 212.93,11.87 212.36,11.87 212.25,11.98 212.25,12.88 213.46,12.88
+5VS_PVDD on TOP (solid shape): 289.39,21.23 289.39,18.95 289.64,18.69 290.91,18.69 291.04,18.57 291.04,18.18 290.91,18.06 290.02,18.06 289.64,17.68 289.64,16.03 289.39,15.77 288.5,15.77 288.42,15.85 288.42,20.27 288.88,20.72 288.88,21.23 289.01,21.36 289.26,21.36
+16.8V_BATT on TOP (solid shape): 274.48,10.82 274.48,7.92 273.39,6.83 269.91,6.83 269.32,7.41 269.32,10.69 269.6,10.97 274.32,10.97
+16.8V_BATT on BOTTOM (solid shape): 271.09,10.77 271.43,10.77 271.48,10.72 272.6,10.72 272.75,10.56 272.75,5.87 272.27,5.38 269.22,5.38 268.74,5.87 268.74,6.51 269.26,6.51 269.61,6.87 269.26,7.23 268.74,7.23 268.74,8.63 269.35,9.24 269.35,10.67 270.41,10.67 270.62,10.87 271.09,10.87
+16.8V_BATT+ on TOP (solid shape): 276.46,9.18 276.46,6.77 276.23,6.54 274.95,6.54 274.69,6.79 274.69,9.48 274.78,9.56 276.08,9.56
+16.8V_BATT+ on BOTTOM: 273.31,5.26 273.02,5.55 273.02,9.9 273.03,9.91 273.03,10.51 273.11,10.59 274.62,10.59 274.81,10.78 274.81,12.88 275.68,13.75 276.01,13.75 276.8,14.53 278.57,14.53 278.66,14.48 278.65,14.37 278.92,13.79 279.2,14.37 279.19,14.48 279.28,14.53 283.63,14.53 285.87,12.29 286.58,12.29 286.8,12.06 289.08,12.06 289.21,11.93 289.21,9.22 289.2,9.19 289.18,9.15 289.16,9.03 289.18,8.9 289.18,8.88 289.18,6.97 289.18,6.97 289.18,6.51 288.67,5.99 287.57,5.99 287.53,5.99 287.49,5.98 287.32,5.98 287.14,5.81 286.46,5.81 286.25,5.93 286.02,5.89 280.54,5.89 280.14,5.49 279.03,5.49 278.77,5.69 278.46,5.6 278.39,5.57 278.33,5.6 278.06,5.68 277.81,5.54 277.68,5.54 277.42,5.71 277.13,5.62 277.07,5.6 277,5.62 276.63,5.68 276.42,5.36 276.39,5.29 276.32,5.26
+16.8V_BATT_CHG on BOTTOM (solid shape): 264.43,12.81 264.43,11.16 264.85,10.74 265.79,10.74 266.07,10.46 266.07,8.46 266.12,8.41 267.39,8.41 267.77,8.02 267.77,7.23 267.17,7.23 266.82,6.87 267.17,6.51 267.77,6.51 267.77,5.71 267.67,5.61 260.8,5.61 260.58,5.83 260.58,12.98 260.66,13.05 264.19,13.05
+19V_ADPIN on TOP (solid shape): 281.51,39.39 281.51,38 283.8,35.71 283.8,32.1 282.88,31.18 282.45,31.18 282.1,30.83 282.1,30.68 281.89,30.48 280.17,30.48 280.16,30.59 279.95,30.86 279.61,30.82 277.89,30.82 277.07,31.65 277.07,38.1 277.12,38.15 277.13,38.15 277.35,38.26 277.45,38.48 277.45,38.5 277.58,38.63 279.86,38.63 280.24,39.01 280.24,39.39 280.5,39.65 281.26,39.65
+19V_P1 on TOP (solid shape): 268.39,35.1 268.39,32.11 268.12,31.84 265.29,31.84 265.17,31.96 265.17,34.25 265.3,34.39 266.13,34.39 266.38,34.64 266.38,35.04 265.96,35.47 265.96,36.54 266.02,36.6 266.9,36.6
+19V_P2 on TOP (solid shape): 264.62,35.52 264.62,32.67 264.48,32.53 260.52,32.53 260.27,32.78 260.27,34.11 260.36,34.19 260.8,34.19 261.16,34.54 260.8,34.9 260.32,34.9 260.27,34.96 260.27,35.56 260.39,35.68 264.46,35.68
+19V_VIN on TOP (solid shape): 276.63,36.07 276.63,30.44 276.46,30.27 270.36,30.27 269.23,29.14 267.74,29.14 267.68,29.2 267.68,30.08 267.85,30.26 268.55,30.26 269.01,30.72 269.01,35.33 269.35,35.66 271.93,35.66 272.54,36.27 276.43,36.27
+19VB on TOP (solid shape): 177.63,82.62 177.65,82.56 177.68,82.5 177.68,80.81 177.43,80.56 175.34,80.56 175.06,80.84 175.06,82.64 175.73,83.31 176.94,83.31
+19VB on TOP (solid shape): 170.87,95.21 170.87,93.81 170.78,93.72 168.67,93.72 168.65,93.74 168.6,93.76 168.55,93.77 168.5,93.78 168.45,93.78 168.39,93.77 168.34,93.76 168.32,93.75 167.99,94.07 167.99,95.19 168.02,95.19 168.03,95.14 168.04,95.09 168.06,95.04 168.09,94.99 168.12,94.95 168.16,94.91 168.2,94.88 168.25,94.86 168.3,94.84 168.35,94.83 168.41,94.83 168.46,94.84 168.51,94.86 168.56,94.88 168.6,94.91 168.64,94.95 168.68,94.99 168.7,95.04 168.72,95.09 168.73,95.14 168.74,95.19 168.73,95.24 168.72,95.3 168.7,95.35 168.68,95.39 168.64,95.43 168.6,95.47 168.56,95.5 168.51,95.52 168.46,95.54 168.41,95.55 168.35,95.55 168.3,95.54 168.25,95.52 168.2,95.5 168.16,95.47 168.12,95.43 168.09,95.39 168.06,95.35 168.04,95.3 168.03,95.24 168.02,95.19 167.99,95.19 167.99,95.46 168.27,95.73 170.35,95.73
+19VB on TOP (solid shape): 84.27,19.03 84.27,13.25 84.22,13.07 84.27,12.88 84.27,12.65 83.71,12.08 83.71,7.65 83.4,7.34 82.66,7.34 82.64,7.32 82.64,6.8 82.62,6.78 82.44,6.78 82.42,6.8 82.42,7.32 82.41,7.33 81.86,7.33 81.85,7.32 81.85,6.79 81.83,6.78 81.62,6.78 81.61,6.79 81.61,7.31 81.59,7.32 81.14,7.32 81.1,7.37 81.1,7.53 81.27,7.72 81.26,7.98 81.26,7.99 81.26,8.28 81.1,8.44 81.1,8.44 80.66,8.89 80.65,8.9 80.55,9.11 80.35,9.21 80.33,9.21 80.26,9.28 80.26,19.65 81.26,20.64 82.66,20.64
+19VB on TOP (solid shape): outline of 800 points within 82.68,35.74 110.24,75.41
+19VB on BOTTOM (solid shape): 269.04,13.26 269.04,9.22 268.71,8.89 266.73,8.89 266.37,9.24 266.37,13.23 266.6,13.46 268.84,13.46
+19VB on BOTTOM (solid shape): 185.91,97.22 186.46,97.22 186.46,97.77 186.71,97.77 186.71,97.22 187.19,97.22 187.2,97.19 187.24,97.13 187.3,97.08 187.33,97.07 187.33,94.89 187.24,94.8 187.24,92.91 187.08,92.75 185.08,92.75 184.61,93.22 184.61,97.02 184.84,97.25 184.99,97.25 184.99,97.22 185.66,97.22 185.66,97.77 185.91,97.77
+19VB on BOTTOM (solid shape): outline of 90 points within 238.07,30.02 252.21,44.3
+19VB on IN1 (solid shape): 169.11,94.91 169.11,94.76 170.27,93.6 170.27,93.6 170.76,93.11 170.76,91.43 170.27,90.94 169.76,90.94 168.75,91.95 168.4,91.95 167.98,92.38 167.98,93.13 168.14,93.13 168.14,93.08 168.15,93.03 168.17,92.98 168.2,92.93 168.23,92.89 168.27,92.85 168.32,92.82 168.36,92.8 168.42,92.79 168.47,92.78 168.52,92.78 168.57,92.79 168.63,92.8 168.67,92.82 168.72,92.85 168.76,92.89 168.79,92.93 168.82,92.98 168.84,93.03 168.85,93.08 168.85,93.13 168.85,93.19 168.84,93.24 168.82,93.29 168.79,93.33 168.76,93.38 168.72,93.41 168.67,93.44 168.63,93.47 168.57,93.48 168.52,93.49 168.47,93.49 168.42,93.48 168.36,93.47 168.32,93.44 168.27,93.41 168.23,93.38 168.2,93.33 168.17,93.29 168.15,93.24 168.14,93.19 168.14,93.13 167.98,93.13 167.98,93.9 167.92,93.95 167.92,94.69 168.15,94.92 168.17,94.9 168.21,94.88 168.26,94.85 168.31,94.84 168.36,94.83 168.42,94.84 168.47,94.84 168.52,94.86 168.56,94.88 168.61,94.91 168.64,94.95 168.66,94.97 169.05,94.97
+19VB on IN3 (solid shape): outline of 1263 points within 78.82,18.11 91.76,45.62
+19VB on TOP: 187.58,93.36 187.58,95.67 187.1,96.15 185.84,96.15 185.32,95.63 185.32,93.36 185.73,92.95 187.17,92.95
+19VB on TOP: outline of 196 points within 163.12,11.42 270.54,65.94
+19VB on IN1: 176.48,84.37 175.79,83.68 175.79,81.88 175.98,81.7 179.44,81.7 179.82,82.08 179.82,83.61 179.06,84.37
+19VB_1.35VSDGPUP on TOP (solid shape): 257.76,46.25 257.76,44.73 255.35,44.73 254.97,45.11 254.97,46.12 255.35,46.51 257.51,46.51
+19VB_1.35VSDGPUP on BOTTOM (solid shape): 256.88,52.22 256.88,47.23 257.64,46.47 257.64,44.6 257.3,44.27 252.52,44.27 252.32,44.46 251.74,44.46 251.73,44.45 251.73,43.93 251.71,43.9 251.5,43.9 251.49,43.92 251.49,44.45 251.48,44.46 250.94,44.46 250.93,44.45 250.93,43.92 250.92,43.9 250.71,43.9 250.69,43.92 250.69,44.45 250.69,44.46 250.25,44.46 250.22,44.49 250.22,46.7 251.99,48.47 251.99,52.16 252.26,52.43 256.67,52.43
+19VB_1V5 on BOTTOM (solid shape): 239.95,31 239.96,31 239.96,30.92 240.03,30.92 240.04,30.91 240.38,30.91 240.4,30.92 240.46,30.92 240.46,30.99 240.47,31 240.47,31.47 241.12,31.47 242.12,30.47 242.12,30.03 242.25,29.9 242.71,29.9 242.8,29.81 242.8,28.94 242.57,28.7 240.34,28.7 240.23,28.81 240.16,28.81 240.15,28.81 239.98,28.85 239.82,28.81 239.8,28.81 239.58,28.81 239.57,28.81 239.4,28.86 239.23,28.81 239.21,28.81 239.2,28.81 238.93,28.54 238.93,28.33 238.82,28.22 237.36,28.22 237.24,28.34 237.24,29.57 237.02,29.79 237.02,30.29 237.19,30.46 238.04,30.46 238.05,30.48 238.05,31.16 238.36,31.46 239.14,31.46 239.14,31 239.16,30.99 239.16,30.92 239.22,30.92 239.23,30.92 239.44,30.92 239.67,30.92 239.67,31.47 239.95,31.47
+19VB_3V on BOTTOM (solid shape): 247.87,34.72 247.87,33.71 248.02,33.57 248.02,31.4 248.28,31.14 248.28,31.11 248.34,31.06 248.34,29.6 248.26,29.52 247.36,29.52 247.04,29.21 247.04,28.73 246.87,28.55 246.29,28.55 246.22,28.63 246.22,29.41 246.07,29.56 245.31,29.56 245.06,29.81 245.06,30.25 245.06,30.56 245.09,30.59 245.62,30.59 245.66,30.63 245.66,31.89 245.62,31.93 245.14,31.93 245.08,31.98 245.08,32.92 247.02,34.85 247.74,34.85
+19VB_5V on TOP (solid shape): 82.24,7.16 82.24,6.62 82.25,6.61 82.8,6.61 82.81,6.62 82.81,7.15 82.83,7.17 83.11,7.17 83.13,7.14 83.13,4.96 82.89,4.72 74.79,4.72 74.58,4.92 74.58,5.3 75.22,5.94 79.45,5.94 80.46,6.95 80.85,6.95 81.06,7.16 81.41,7.16 81.44,7.14 81.44,6.63 81.46,6.6 81.99,6.6 82.01,6.62 82.01,7.15 82.03,7.17 82.23,7.17
+19VB_5V on BOTTOM (solid shape): 77.12,6.45 78.43,6.45 78.78,6.1 79.96,6.1 80.02,6.04 81.67,6.04 81.82,5.89 81.82,4.92 81.57,4.67 74.84,4.67 74.58,4.92 74.58,6.83 74.71,6.95 76.62,6.95
+19VB_CHG on TOP (solid shape): 251.58,14.09 251.58,13.56 251.59,13.55 252.33,13.55 252.35,13.57 252.35,14.07 252.38,14.1 253.03,14.1 253.09,14.03 253.09,12.33 252.91,12.15 252.91,10.64 253.07,10.49 253.47,10.49 253.52,10.44 253.52,10.06 253.5,10.03 250.85,10.03 250.64,9.83 250.64,9.75 246.46,9.75 246.18,10.03 246.18,12.16 246.46,12.44 248.92,12.44 249.18,12.7 249.18,13.26 249.46,13.54 249.86,13.54 249.86,14.07 249.89,14.09 250.38,14.09 250.39,14.09 250.39,13.57 250.4,13.56 251.14,13.56 251.14,13.57 251.14,14.09 251.16,14.1 251.58,14.1
+19VB_CPU on TOP (solid shape): 106.15,80.11 106.15,75.54 103.03,75.54 102.85,75.72 102.85,80.13 103.05,80.34 105.92,80.34
+19VB_CPU on TOP (solid shape): 115.78,92.1 115.78,91.72 115.52,91.46 109.68,91.46 109.56,91.59 109.56,92.48 109.68,92.61 115.27,92.61
+19VB_CPU on TOP (solid shape): outline of 905 points within 123.78,125.25 158.45,132.99
+19VB_CPU on BOTTOM (solid shape): outline of 93 points within 122.26,124.1 158.2,133.12
+19VB_CPU on BOTTOM: 103.67,75.84 103.38,76.13 103.38,79.66 103.62,79.9 104.72,79.9 105.27,80.45 105.62,80.42 105.83,80.71 105.42,80.71 105.42,81.73 106,81.73 109.03,83.97 107.78,87.52 107.78,91.34 107.9,91.46 109.17,91.46 109.43,91.72 109.43,92.48 109.56,92.61 114.51,92.61 114.64,92.73 114.64,93.62 114.76,93.75 115.65,93.75 115.78,93.62 115.78,91.72 115.52,91.46 111.71,91.46 111.71,90.45 112.31,89.85 112.35,89.8 112.4,89.76 113.78,88.38 113.78,81.45 113.43,79.57 114.04,77.75 114.04,76.75 113.13,75.84
+19VB_CPU on VCC: 103.44,75.97 102.8,76.6 101.99,76.6 102.55,79.15 102.94,81.73 106,81.73 109.17,84.9 106,88.07 103.18,88.07 103.05,90 102.82,91.92 102.57,93.72 103.4,93.72 105.04,94.47 105.55,96.19 103.93,107.72 103.93,107.72 107.28,107.72 114.59,110.49 118.72,117.12 118.72,131 120.52,132.07 121.57,133.88 127.1,133.88 128.25,132.74 131.25,132.74 132.27,133.75 134.72,133.75 135.74,132.74 138.74,132.74 139.76,133.75 142.34,133.75 143.36,132.74 146.49,132.74 147.51,133.75 150.09,133.75 151.11,132.74 152.33,132.74 153.35,133.75 157.33,133.75 159.87,131.21 161.65,131.21 162.26,130.6 162.26,127.38 162.03,127.15 157.54,127.15 157.18,127.51 157.18,129.29 156.78,129.69 156.52,129.69 155.89,130.33 127.74,130.33 126.83,129.41 126.83,127.55 128.1,126.28 128.1,124.63 131.15,121.58 131.15,119.89 130.64,119.38 130.64,117.73 130,117.1 130,115.7 125.94,111.63 125.94,110.49 125.71,110.26 118.72,110.26 112.73,104.27 112.73,95.04 117.56,90.21 117.56,86.36 117.2,86 114.4,86 110.95,82.55 110.95,76.2 110.72,75.97
+19VB_CPU on IN2: outline of 155 points within 102.32,74.95 127.46,134.07
+19VB_DDR on TOP (solid shape): 91.49,41.38 91.49,40.84 91.5,40.83 92.05,40.83 92.07,40.85 92.07,41.38 92.08,41.39 92.39,41.39 92.54,41.24 92.54,40.66 94.06,39.14 94.06,37.62 94.57,37.11 94.57,34.44 93.76,33.63 92.92,33.63 92.84,33.55 92.84,32.99 92.77,32.92 92.38,32.92 92.31,32.99 92.31,35.38 92.33,35.41 92.49,35.41 92.79,35.71 92.79,36.98 92.28,37.49 91.52,37.49 91.39,37.62 91.39,39.39 90.89,39.9 90.52,39.9 90.32,40.1 90.32,41.35 90.37,41.4 90.68,41.4 90.69,41.39 90.69,40.86 90.71,40.84 91.24,40.84 91.25,40.85 91.25,41.37 91.28,41.4 91.47,41.4
+19VB_GPU_NVVDD on TOP (solid shape): outline of 81 points within 194.73,44.71 229.61,56.47
+19VB_GPU_NVVDD on BOTTOM (solid shape): outline of 210 points within 194.69,45.67 232.29,56.39
+19VB_INVPWR on TOP (solid shape): 82.51,43.69 82.51,43.31 82.53,43.29 83.06,43.29 83.08,43.27 83.08,43.14 83.07,43.12 82.58,43.12 82.54,43.09 82.54,37.79 82.34,37.59 80.25,37.59 80.06,37.78 80.06,40.75 80.51,41.2 80.51,42.57 80.78,42.84 80.78,43.5 80.97,43.7 82.5,43.7
+19VB_VCCIOP on BOTTOM (solid shape): 187.9,103.36 187.9,100.32 187.81,100.23 187.81,97.53 187.49,97.21 187.38,97.19 187.31,97.28 187.31,97.35 186.84,97.35 186.84,97.9 186.33,97.9 186.33,97.35 186.04,97.35 186.04,97.9 185.53,97.9 185.53,97.35 185.12,97.35 185.12,98.75 185.83,99.46 185.83,101.95 185.73,102.05 185.73,103.5 185.78,103.55 187.71,103.55
+VCC_CORE on TOP (solid shape): outline of 2002 points within 125.68,90.27 161.46,120.02
+VCC_CORE on BOTTOM (solid shape): outline of 386 points within 142.96,90.07 162.9,91.97
+VCC_CORE on BOTTOM (solid shape): outline of 1810 points within 125.94,102.32 159.97,119.15
+VCC_CORE on IN1 (solid shape): outline of 4316 points within 126.7,90.35 161.63,120.67
+VCC_CORE on IN2 (solid shape): outline of 4212 points within 126.49,90.28 162.39,119.15
+VCC_CORE on VCC: 142.93,90.57 142.7,90.81 142.7,91.57 140.8,93.47 140.8,99.61 140.9,99.72 142.43,99.72 143.46,100.76 143.46,103.25 142.83,103.89 142.83,109.86 142.43,110.26 126.68,110.26 126.45,110.49 126.45,111.42 130.51,115.49 130.51,116.88 131.15,117.52 131.15,119.17 131.5,119.53 132.77,119.53 133.16,119.91 156.19,119.91 156.93,119.17 156.93,111.68 159.59,109.01 159.59,105.03 158.45,103.89 158.45,94.53 158.98,94 161.14,94 161.37,93.77 161.37,92.5 162.51,91.36 162.51,90.57
+VCC_GT on TOP (solid shape): outline of 4623 points within 112.86,90.21 142.83,110.64
+VCC_GT on BOTTOM (solid shape): outline of 2583 points within 112.73,90.07 142.32,109.75
+VCC_GT on IN2 (solid shape): outline of 4387 points within 126.34,91.19 142.26,110
+VCC_GT on VCC: 117.92,90.57 113.24,95.25 113.24,104.06 118.93,109.75 142.22,109.75 142.32,109.65 142.32,103.68 142.96,103.04 142.96,100.97 142.22,100.23 140.69,100.23 140.29,99.82 140.29,93.26 142.19,91.36 142.19,90.81 141.96,90.57
+VCC_SA on TOP (solid shape): outline of 407 points within 156.8,93.24 163.15,118.26
+VCC_SA on BOTTOM (solid shape): outline of 568 points within 157.43,102.52 163.28,118.51
+VCC_SA on IN2 (solid shape): outline of 1023 points within 157.05,93.62 165.56,116.48
+VCC_SA on VCC: 159.19,94.51 158.96,94.74 158.96,103.68 160.1,104.82 160.1,109.22 157.43,111.89 157.43,118.79 157.67,119.02 162.66,119.02 162.77,118.92 162.77,103.38 161.37,101.98 161.37,94.74 161.14,94.51
GND on TOP (solid shape): 19.73,116.47 19.73,115.46 19.61,115.34 18.62,115.34 18.37,115.59 18.37,116.48 18.5,116.61 19.59,116.61
GND on TOP (solid shape): 23.88,75.62 23.88,74.22 23.67,74.02 21.04,74.02 20.42,74.64 20.42,75.67 20.51,75.76 23.73,75.76
GND on TOP (solid shape): 262.54,46.93 262.54,46.12 261.14,44.73 258.4,44.73 258.09,45.03 258.09,46.56 258.59,47.05 262.41,47.05
GND on TOP (solid shape): 78.99,31.62 78.99,29.58 78.88,29.47 78.09,29.47 77.93,29.62 77.93,31.67 78,31.74 78.87,31.74
GND on TOP (solid shape): 274.21,12.97 274.21,11.46 274.07,11.31 269.59,11.31 269.46,11.44 269.46,13.42 269.74,13.7 273.48,13.7
GND on TOP (solid shape): 98.88,42.32 98.88,40.79 98.72,40.63 97.99,40.63 97.89,40.73 96.84,40.73 96.71,40.86 96.71,43.36 96.82,43.47 97.72,43.47
GND on TOP (solid shape): 171.28,131.6 171.28,126.39 171.15,126.26 166.83,126.26 165.82,127.28 165.82,127.53 165.69,127.66 165.69,131.6 166.07,131.98 170.9,131.98
GND on TOP (solid shape): 209.4,91.23 209.3,91.13 208.95,91.13 207.83,92.26 207.83,92.78 207.98,92.93 209.4,92.93
GND on TOP (solid shape): 130.04,57.7 130.04,54.86 129.65,54.47 126.64,54.47 126.45,54.67 126.45,57.53 126.79,57.88 129.86,57.88
GND on TOP (solid shape): 156.49,104.42 156.49,104.14 156.24,103.88 156.24,102.89 156.19,102.84 155.2,102.84 155.17,102.87 155.17,104.34 155.33,104.49 156.42,104.49
GND on TOP (solid shape): 263.17,42.72 263.17,41.27 263.16,41.26 262.43,41.26 262.42,41.25 261.81,41.25 261.62,41.43 261.62,41.9 262.47,42.75 263.15,42.75
GND on TOP (solid shape): 30.96,45.42 30.96,44.85 31.12,44.69 31.12,44.07 30.98,43.92 29.47,43.92 29.27,44.13 29.27,44.39 29.81,44.93 29.81,45.45 29.86,45.51 30.87,45.51
GND on TOP (solid shape): 65.79,36.28 65.79,34.95 65.92,34.82 67.27,34.82 67.54,34.55 67.54,32.35 67.47,32.28 65.34,32.28 65.23,32.39 65.23,36.3 65.37,36.43 65.64,36.43
GND on TOP (solid shape): 80.63,43.68 80.63,42.87 80.39,42.63 80.39,41.68 80.1,41.4 79.49,41.4 78.99,41.89 78.99,42.98 78.06,43.92 78.06,44.36 78.4,44.71 79.6,44.71
GND on TOP (solid shape): 88.72,33.72 88.72,31.41 88.62,31.3 87.51,31.3 87.21,31.61 87.21,32.65 87.44,32.88 87.76,32.88 88.07,33.19 88.07,33.65 88.22,33.8 88.65,33.8
GND on TOP (solid shape): 144.73,104.39 144.73,104.11 144.66,104.04 144.2,104.04 144.15,103.99 144.15,102.92 144.07,102.84 143.24,102.84 143.13,102.94 143.13,104.19 143.44,104.49 144.63,104.49
GND on TOP (solid shape): 145.42,99.57 145.42,93.06 144.86,92.5 144.86,92.23 144.61,91.97 144.23,91.97 143.59,92.61 143.59,99.59 143.62,99.62 145.37,99.62
GND on TOP (solid shape): 158.86,104.39 158.86,103.24 158.78,103.16 158.39,103.16 158.04,102.82 157.61,102.82 157.56,102.87 157.56,104.37 157.71,104.52 158.73,104.52
GND on TOP (solid shape): 173.05,32.71 173.05,32.41 171.69,31.05 171.69,30.19 171.65,30.15 171.18,30.15 171.14,30.2 171.14,31.76 171.25,31.87 171.25,32.43 171.71,32.9 172.86,32.9
GND on TOP (solid shape): 199.87,121.56 199.87,120.99 199.75,120.88 199.06,120.88 198.79,120.61 198.08,120.61 197.94,120.75 197.94,121.5 198.07,121.64 199.79,121.64
GND on TOP (solid shape): 248.79,81.32 248.79,81.23 249.25,80.77 249.25,79.99 249.11,79.85 248.15,79.85 248.03,79.97 248.03,80.79 248.25,81 248.25,81.36 248.38,81.5 248.61,81.5
GND on TOP (solid shape): 42.25,42.83 42.25,42.37 42.06,42.18 38.77,42.18 38.55,42.4 38.55,43.21 38.6,43.26 41.81,43.26
GND on TOP (solid shape): 154.16,104.52 154.16,104.19 153.85,103.88 153.85,102.99 153.7,102.84 152.74,102.84 152.68,102.89 152.68,103.81 152.79,103.91 152.79,104.34 152.99,104.54 154.13,104.54
GND on TOP (solid shape): 161.5,129.18 161.5,124.23 161.37,124.1 161.18,124.1 159.91,125.37 158.83,125.37 158.7,125.5 158.7,128.04 159.72,129.06 160.74,129.06 160.99,129.31 161.37,129.31
GND on TOP (solid shape): 178.13,28.04 178.5,28.04 178.51,28.05 178.77,28.05 178.84,27.98 178.84,27.46 178.56,27.18 176.59,27.18 176.34,27.42 176.34,27.68 176.94,28.27 177.9,28.27
GND on TOP (solid shape): 109.05,95.4 109.3,95.4 109.43,95.27 109.43,95.02 109.94,94.51 114.13,94.51 114.25,94.38 114.25,93.11 114.13,92.99 108.03,92.99 107.9,93.11 107.9,95.53 108.03,95.65 108.79,95.65
GND on TOP (solid shape): 151.77,104.42 151.77,104.09 151.67,103.99 151.44,103.99 151.34,103.88 151.34,102.92 151.29,102.87 150.37,102.87 150.35,102.89 150.35,104.19 150.65,104.49 151.69,104.49
GND on TOP (solid shape): 62.39,11.4 62.39,6.57 62.65,6.32 63.54,6.32 63.66,6.19 63.66,5.43 63.41,5.18 59.85,5.18 59.6,5.43 59.6,8.1 60.61,9.11 60.61,10.26 61.88,11.53 62.27,11.53
GND on TOP (solid shape): 204.34,92.73 204.34,92.38 203.91,91.95 203.81,91.88 203.74,91.78 203.17,91.21 203,91.21 202.76,91.46 202.76,92.76 202.78,92.78 204.28,92.78
GND on TOP (solid shape): 21.14,56.49 21.57,56.49 21.62,56.44 21.62,55.9 21.52,55.8 21.52,55.09 21.59,55.01 21.85,55.01 22.28,54.58 22.28,54.18 22.2,54.1 21.26,54.1 20.35,55.01 20.35,56.64 20.38,56.67 20.96,56.67
GND on TOP (solid shape): 207.79,82.33 208.53,82.33 208.6,82.33 208.73,82.2 208.73,81.59 208.63,81.49 207.32,81.49 207.31,81.49 206.93,81.49 206.75,81.67 206.75,82.41 206.83,82.49 207.63,82.49
GND on TOP (solid shape): 212.01,125.6 212.01,125.08 212.27,124.81 213.34,124.81 213.42,124.73 213.42,124.46 213.32,124.36 212.35,124.36 212.1,124.1 211.67,124.1 211.34,124.43 211.34,125.26 211.35,125.26 211.35,125.64 211.4,125.69 211.91,125.69
GND on TOP (solid shape): 149.41,104.39 149.41,104.06 149.33,103.99 148.98,103.99 148.95,103.96 148.95,102.94 148.9,102.89 147.96,102.89 147.93,102.92 147.93,104.11 147.94,104.15 147.95,104.2 148.24,104.49 149.31,104.49
GND on TOP (solid shape): 161.83,98.73 161.83,96.85 161.8,96.79 161.78,96.71 161.78,96.7 161.61,96.53 161.16,96.53 161.02,96.67 161.02,96.95 160.84,97.13 160.69,97.13 160.58,97.23 160.58,98.85 160.63,98.91 161.65,98.91
GND on TOP (solid shape): 197.21,96.11 197.21,95.4 197.31,95.3 197.31,95.15 197.52,94.94 197.52,93.83 197.29,93.6 197.29,92.68 197.06,92.45 196.68,92.45 195.94,93.19 195.94,95.76 196.25,96.06 196.68,96.06 196.88,96.26 197.06,96.26
GND on TOP (solid shape): 213.11,80.43 213.11,79.84 212.98,79.71 212.98,78.36 212.91,78.29 212.72,78.29 212.33,78.68 212.33,79.16 212.16,79.32 211.61,79.32 211.57,79.36 211.57,79.82 211.62,79.87 211.62,80.43 211.72,80.52 213.02,80.52
GND on TOP (solid shape): 149.01,99.46 149.01,95.77 149.07,95.71 149.07,95.71 149.71,95.06 149.71,93.16 149.56,93.01 149.56,92.17 149.31,91.92 146.92,91.92 146.84,92 146.84,92.86 146.89,92.91 147.45,92.91 147.68,93.14 147.68,99.46 147.81,99.59 148.87,99.59
GND on TOP (solid shape): 213.3,90.89 213.3,89.77 213.18,89.65 213.18,89 213.08,88.91 212.62,88.91 212.43,89.09 212.37,89.09 212.21,89.25 212.21,90.16 212.33,90.28 212.63,90.28 212.8,90.45 212.8,90.88 212.87,90.95 213.24,90.95
GND on TOP (solid shape): 248.2,98.19 248.2,97.56 248.08,97.44 248.08,95.56 247.99,95.48 246.94,95.48 246.85,95.57 246.85,95.83 246.93,95.9 247.43,95.9 247.53,96 247.53,96.64 247.37,96.8 247.37,97.27 247.61,97.51 247.61,98.26 247.62,98.27 248.13,98.27
GND on TOP (solid shape): 23.88,83.55 23.88,83.24 23.78,83.14 23.41,83.14 23.2,83.36 21.32,83.36 21.28,83.32 20.45,83.32 20.4,83.37 20.4,83.73 21.38,84.72 22.67,84.72 22.69,84.73 22.94,84.73 23.3,85.09 23.66,85.09
GND on TOP (solid shape): 214.08,95.28 214.23,95.28 214.51,95.55 214.74,95.55 214.9,95.39 214.9,95.11 214.81,95.02 212.76,95.02 212.72,95.06 212.72,95.4 212.77,95.46 213.58,95.46 213.71,95.59 213.77,95.59
GND on TOP (solid shape): 287.27,21.39 288.6,21.39 288.65,21.33 288.65,20.85 288.61,20.85 288.18,20.42 288.18,17.88 288.03,17.73 287.63,17.73 287.56,17.8 287.56,18.04 287.45,18.15 285.88,18.15 285.81,18.22 285.81,18.77 285.1,19.48 285.1,22.41 285.43,22.74 285.92,22.74
GND on TOP (solid shape): 24.74,56.78 24.74,56.41 24.82,56.33 25.79,56.33 25.88,56.24 25.88,55.99 25.79,55.9 24.87,55.9 24.74,55.78 24.74,55.2 23.99,54.45 23.09,54.45 22.98,54.56 22.98,54.79 23.31,55.12 23.79,55.12 24.06,55.39 24.06,56.77 24.09,56.8 24.72,56.8
GND on TOP (solid shape): 91.01,39.39 91.01,38.38 91.14,38.25 91.14,37.62 91.01,37.49 90.89,37.49 90.63,37.23 90.63,35.46 90.73,35.35 90.73,33.78 90.63,33.68 90,33.68 89.74,33.93 89.24,33.93 88.73,34.44 88.73,35.96 89.36,36.6 89.36,39.27 89.74,39.65 90.76,39.65
GND on TOP (solid shape): 120.22,89.94 120.22,86.13 118.65,84.55 114.7,84.55 114.54,84.72 114.54,85.05 114.68,85.19 115.17,85.19 115.17,85.21 115.2,85.21 115.27,85.28 115.27,86.64 115.32,86.69 116.84,86.69 118.95,88.8 118.95,89.18 119.21,89.43 119.21,90.07 119.33,90.19 119.97,90.19
GND on TOP (solid shape): 147.07,104.39 147.07,104.09 146.97,103.99 146.66,103.99 146.65,103.97 146.64,103.97 146.64,103.96 146.56,103.88 146.56,102.92 146.49,102.84 145.62,102.84 145.55,102.92 145.55,104.05 145.57,104.1 145.58,104.15 145.95,104.52 146.94,104.52
GND on TOP (solid shape): 226.47,57.12 227.87,57.12 227.94,57.2 228.25,57.2 228.3,57.15 228.3,54.89 228.17,54.76 226.06,54.76 225.96,54.86 225.96,55.8 225.86,55.9 225.43,55.9 225.38,55.95 225.38,56.49 225.4,56.51 225.61,56.51 225.86,56.77 225.86,57.07 226.04,57.25 226.34,57.25
GND on TOP (solid shape): 250.57,9.25 250.57,8.86 251,8.43 252.8,8.43 252.92,8.3 252.92,7.62 252.8,7.5 252.8,5.99 252.63,5.82 251.85,5.82 251.85,5.82 251.75,5.82 251.65,5.93 251.65,6.74 250.88,7.5 246.66,7.5 246.48,7.68 246.48,9.59 246.51,9.62 250.19,9.62
GND on TOP (solid shape): 207.21,87.69 207.21,87.38 206.93,87.1 206.93,86.72 206.73,86.52 206.73,86.11 206.8,86.04 206.8,83.7 206.15,83.05 205.94,83.05 205.82,83.17 205.82,83.35 206.13,83.66 206.13,84.25 205.68,84.7 205.68,86.28 206.17,86.77 206.17,87.03 206.47,87.33 206.47,87.36 206.86,87.74 207.16,87.74
GND on TOP (solid shape): 154.32,99.34 154.32,92.35 154.2,92.23 153.88,92.23 153.57,91.92 152.61,91.92 152.61,91.92 152.48,91.95 152.36,91.92 152.35,91.92 152.15,91.92 152.1,91.97 152.1,92.1 151.97,92.23 151.66,92.23 151.48,92.4 151.48,92.75 151.64,92.91 152,92.91 152.29,93.2 152.29,99.5 152.3,99.51 154.14,99.51
GND on TOP (solid shape): 194.84,98.73 194.84,98.7 194.87,98.43 195.09,98.27 195.11,98.27 195.14,98.23 195.14,97.59 195.06,97.51 194.37,97.51 194.31,97.56 194.31,97.76 194.2,97.87 193.52,97.87 193.35,98.03 193.35,98.75 193.58,98.98 194.59,98.98
GND on TOP (solid shape): 234.28,8.16 234.28,7.58 233.94,7.23 233.94,5.45 233.75,5.26 232.9,5.26 232.8,5.36 232.79,5.43 232.77,5.49 232.77,6.03 232.77,6.04 233.18,7.08 233.25,8.2 233.25,8.22 233.32,8.29 234.16,8.29
GND on TOP (solid shape): 267.48,46.03 267.48,45.63 267.45,45.61 267.27,45.61 267.11,45.46 267.11,42.26 267.06,42.2 267.06,42 267.11,41.95 267.11,40.33 267.25,40.2 267.25,39.61 267.23,39.6 266.38,39.6 265.85,40.13 265.85,40.86 266.11,41.13 266.11,42.73 266.06,42.79 265.33,42.79 265.29,42.83 265.29,42.94 265.33,42.98 266.08,42.98 266.12,43.02 266.12,44.34 265.64,44.82 265.64,45.9 265.79,46.06 267.45,46.06
GND on TOP (solid shape): 72.54,33.21 72.54,32.64 71.96,32.06 71.95,32.05 71.75,31.75 71.92,31.43 71.92,30.79 71.83,30.7 71.35,30.7 71.18,30.87 71.18,31.18 71.02,31.34 70.57,31.34 70.5,31.4 70.5,31.58 70.5,31.59 70.5,32.95 70.92,33.37 72.39,33.37
GND on TOP (solid shape): 254.41,40.8 254.41,40.09 254.49,40.01 255.81,40.01 255.95,40.15 255.95,40.4 256.25,40.7 257.39,40.7 257.97,40.12 257.97,39.33 257.66,39.03 256.1,39.03 256.1,39.03 255.42,39.03 255.42,39.03 255.24,39.03 255.24,39.03 255.03,39.03 255.03,39.03 252.71,39.03 252.43,38.75 251.64,38.75 251.58,38.81 251.58,40.49 251.65,40.56 252.41,40.56 253,39.97 254.18,39.97 254.21,40 254.21,40.79 254.26,40.85 254.36,40.85
GND on TOP (solid shape): 42.33,38.32 42.33,37.76 42.03,37.47 41.48,37.51 41.53,36.97 41.44,36.88 39.67,36.88 39.49,37.06 39.49,38.32 39.54,38.37 42.28,38.37
GND on TOP (solid shape): 175.79,108.21 175.79,107.51 176.22,107.08 176.22,106.73 176.1,106.62 175.46,106.62 175.08,106.24 172.87,106.24 172.81,106.18 172.59,106.18 172.46,106.31 172.46,106.71 172.7,106.96 172.74,106.94 173.13,106.96 173.3,107.32 173.3,107.34 174.25,108.3 175.7,108.3
GND on TOP (solid shape): 46.65,50.02 46.9,50.02 47.99,48.92 47.99,48.8 48.12,48.8 48.24,48.68 48.26,48.68 48.38,48.55 48.78,48.55 48.83,48.49 48.83,46.25 48.85,46.22 49.6,46.22 49.7,46.12 49.7,40.79 49.62,40.7 46.57,40.7 46.44,40.57 46.44,39.52 46.39,39.48 46.3,39.48 46.23,39.54 46.23,46.06 46.4,46.22 47.54,46.22 47.85,46.53 47.85,46.54 47.85,47.63 47.77,47.71 47.77,48.09 46.26,49.6 46.26,49.87 46.42,50.02 46.65,50.02
GND on TOP (solid shape): 43.92,46.98 43.92,46 43.94,45.98 43.94,44.85 43.85,44.76 42.53,44.76 42.37,44.93 42.37,45.51 42.41,45.51 42.41,45.77 42.45,45.81 42.45,46.71 42.49,46.8 42.94,46.85 43.1,47.16 43.1,47.31 43.58,47.31
GND on TOP (solid shape): 199.28,84.48 199.28,83.61 199.32,83.56 199.32,83.53 199.51,83.35 199.94,83.35 200.02,83.26 200.02,82.73 199.93,82.64 199.37,82.64 199.37,81.4 199.32,81.36 198.89,81.36 198.71,81.53 198.35,81.53 198.25,81.63 198.25,81.96 198.36,82.06 198.66,82.06 198.72,82.13 198.76,82.13 198.76,82.76 198.71,82.76 198.65,82.83 198.12,82.83 198.06,82.76 196.88,82.76 196.88,82.75 196.04,82.75 195.99,82.79 195.99,83.79 196.11,83.91 197.85,83.91 198.06,84.13 198.55,84.13 198.66,84.23 198.66,84.56 198.69,84.59 199.17,84.59
GND on TOP (solid shape): 28.35,63.24 28.35,62.06 28.33,62.04 28.33,59.42 27.97,59.06 27.79,59.06 27.63,59.22 27.59,59.27 27.57,59.27 27.53,59.31 26.89,59.31 26.85,59.27 26.8,59.27 26.6,59.06 26.42,59.06 26.18,59.3 25.53,59.3 25.43,59.2 25.42,59.19 25.28,59.05 25.07,59.05 24.88,59.25 24.81,59.25 24.81,59.25 24.13,59.25 23.78,58.9 22.94,58.9 22.89,58.95 22.89,59.43 22.94,59.48 23.2,59.48 23.32,59.61 23.32,60.8 23.33,60.81 23.33,63.22 23.65,63.54 28.05,63.54
GND on TOP (solid shape): 140.82,102.11 140.82,101.8 141,101.62 141.31,101.62 141.38,101.55 141.38,101.29 141.25,101.17 140.87,101.17 140.82,101.12 140.82,100.48 140.92,100.38 141.33,100.38 141.43,100.28 141.43,99.97 141.31,99.85 139.1,99.85 138.89,99.64 138.61,99.64 138.49,99.77 138.49,100.05 138.56,100.12 138.97,100.12 139.12,100.28 139.12,100.68 138.99,100.81 138.82,100.81 138.81,100.81 138.72,100.83 138.62,100.83 138.6,100.83 138.51,100.91 138.51,101.37 138.61,101.47 138.92,101.47 139.12,101.67 139.12,102.08 139.22,102.18 140.75,102.18
GND on TOP (solid shape): 112.7,14.91 112.7,14.27 112.56,14.13 112.3,14.13 111.78,14.11 111.85,13.59 111.89,13.51 111.86,13.43 111.71,13.28 108.4,13.28 108.31,13.37 108.31,13.92 108.34,13.95 109.87,13.95 110.06,14.14 110.06,14.48 110.53,14.95 112.66,14.95
GND on TOP (solid shape): 159.26,102.15 159.26,99.84 159.58,99.52 159.58,94.74 159.31,94.47 159.31,93.38 158.7,92.77 158.7,91.91 158.58,91.78 158.06,91.78 157.91,91.92 156.92,91.92 156.62,92.23 156.62,93.05 156.62,93.06 156.62,94.74 155.77,95.59 155.77,95.6 155.57,95.8 155.57,99.05 155.75,99.24 156.66,99.24 156.93,99.5 156.93,100.18 156.75,100.35 156.39,100.35 156.34,100.41 156.34,100.78 156.39,100.84 156.77,100.84 156.93,100.99 156.93,101.5 156.82,101.6 156.42,101.6 156.34,101.68 156.34,102.05 156.39,102.11 158.32,102.11 158.49,102.27 159.14,102.27
GND on TOP (solid shape): 83.08,36.03 83.08,35.84 83.25,35.67 84.03,35.67 84.11,35.59 84.11,35.34 84.01,35.25 83.14,35.25 83.08,35.19 83.08,34.62 83.35,34.34 83.95,34.34 84.13,34.16 84.13,33.62 84.02,33.51 83.63,33.51 83.31,33.2 82.85,33.2 82.49,33.2 81.77,32.48 81.35,32.48 81.28,32.55 81.28,33.97 81.56,34.25 81.9,34.25 82.2,34.55 82.2,35.12 82.09,35.24 81.2,35.24 80.44,34.48 80.41,34.48 80.32,34.39 79.26,34.39 78.82,33.96 77.92,33.96 77.85,34.03 77.85,35.64 77.91,35.7 82.12,35.7 82.24,35.82 82.24,36.02 82.32,36.1 83,36.1
GND on TOP (solid shape): 275.26,39.25 275.25,39.23 275.43,38.86 275.84,38.91 275.9,38.93 275.97,38.91 276.36,38.88 276.54,39.23 276.54,39.26 276.59,39.31 276.72,39.18 276.72,36.76 276.5,36.54 274.29,36.54 274.15,36.68 274.15,39.18 274.36,39.4 275.12,39.4
GND on TOP (solid shape): 211.64,93.4 211.64,93.36 211.78,93.06 212.11,93.01 212.15,93.01 212.24,92.92 212.66,92.92 212.66,92.62 212.65,92.61 212.65,92.51 212.81,92.35 212.86,92.35 212.9,92.31 213.84,92.31 213.89,92.26 213.89,91.63 213.81,91.55 212.83,91.55 212.83,91.55 212.6,91.78 211.99,91.78 211.53,91.32 211,91.32 210.89,91.42 210.89,91.65 211.31,92.07 211.32,92.07 211.46,92.16 211.55,92.3 211.55,92.31 211.57,92.33 211.57,92.63 211.42,92.78 211.12,92.78 210.76,93.14 210.76,93.54 210.98,93.75 211.29,93.75
GND on TOP (solid shape): 214.91,87.25 214.91,86.86 216.01,85.76 216.01,85.63 215.81,85.42 215.63,85.42 215.36,85.69 215.17,85.69 215.04,85.56 215.04,85.46 215.03,85.45 214.97,85.26 215.04,85.07 215.04,84.64 214.97,84.45 215.03,84.26 215.04,84.24 215.04,84.22 215.97,83.29 215.97,83.16 215.83,83.02 215.51,83.02 215.4,83.13 215.4,83.16 215.39,83.25 215.34,83.33 215.29,83.38 215.25,83.39 215.14,83.45 215.08,83.56 215.07,83.6 214.91,83.76 214.77,83.76 214.56,83.97 214.56,85.35 214.54,85.38 214.54,85.7 214.48,85.76 214.48,85.82 214.47,85.83 214.47,85.85 214.45,85.85 214.24,86.06 214.24,86.3 214.37,86.43 214.37,87.27 214.42,87.32 214.84,87.32
GND on TOP (solid shape): outline of 86 points within 73.42,6.35 81.13,9.96
GND on TOP (solid shape): 14.94,83.08 14.94,82.07 14.56,81.68 14.44,81.68 14.27,81.52 14.25,81.52 13.84,81.19 14.2,80.81 14.27,80.78 14.31,80.71 14.31,80.64 3.41,80.64 3.38,80.65 3.35,80.66 2.96,80.66 2.92,80.71 2.73,80.71 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.51 14.51,83.51
GND on TOP (solid shape): outline of 108 points within 0.65,55.06 8.69,59.45
GND on TOP (solid shape): outline of 128 points within 0.65,41.6 33.56,49.81
GND on TOP (solid shape): 15.7,105.56 15.7,95.27 14.69,94.26 12.6,94.26 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.96,96.7 0.96,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.71,102.45 2.71,102.9 2.94,103.46 3.5,103.7 9.58,103.7 9.75,103.68 9.92,103.7 9.96,103.7 9.96,103.71 10.47,104.4 9.96,105.09 9.96,106.28 10.2,106.28 10.37,106.45 14.81,106.45
GND on TOP (solid shape): outline of 181 points within 133.69,91.97 141.79,102.35
GND on TOP (solid shape): outline of 192 points within 207.8,82.38 213.36,88.76
GND on TOP (solid shape): outline of 260 points within 128.61,117.4 157.57,129.82
GND on TOP (solid shape): outline of 260 points within 194.36,76.68 211.84,98.07
GND on TOP (solid shape): outline of 362 points within 193.02,56.18 217.63,65.05
GND on TOP (solid shape): outline of 383 points within 0.2,0.2 313.4,137.62
GND on BOTTOM (solid shape): 53.1,3.6 44.8,3.6 44.8,9.9 53.1,9.9
GND on BOTTOM (solid shape): 49.73,45.54 49.73,41.05 49.31,40.63 46.58,40.63 46.28,40.94 46.28,45.95 46.55,46.23 49.04,46.23
GND on BOTTOM (solid shape): 122.13,112.29 122.13,111.15 120.48,109.5 120.1,109.5 118.45,111.15 118.45,112.42 120.1,114.07 120.35,114.07
GND on BOTTOM (solid shape): 125.05,126.77 125.05,124.1 124.16,123.21 122.64,123.21 122.13,123.72 122.13,126.9 122.51,127.28 124.54,127.28
GND on BOTTOM (solid shape): 156.42,134.52 156.42,133.37 156.29,133.25 154.26,133.25 154.2,133.31 154.2,134.52 154.26,134.58 156.35,134.58
GND on BOTTOM (solid shape): 171.45,23.63 171.45,19.1 168.09,19.1 166.53,20.67 166.53,22.28 167.95,23.7 171.38,23.7
GND on BOTTOM (solid shape): 177.16,111.97 177.16,111.65 175.82,110.31 174.5,110.31 173.74,111.07 173.74,111.66 174.38,112.29 176.84,112.29
GND on BOTTOM (solid shape): 194.33,62.91 194.33,60.88 194.23,60.78 189.6,60.78 189.43,60.95 189.43,62.96 189.55,63.08 194.16,63.08
GND on BOTTOM (solid shape): 206.67,73.56 206.67,70.35 206.61,70.29 204.57,70.29 204.5,70.35 204.5,73.57 204.52,73.59 206.64,73.59
GND on BOTTOM (solid shape): 248.97,59.61 248.97,56.97 248.66,56.66 246.18,56.66 245.93,56.91 245.93,59.81 246.27,60.14 248.44,60.14
GND on BOTTOM (solid shape): 18.48,10 18.48,8.5 18.66,8.31 18.66,7.43 18.4,7.17 15.73,7.17 15.63,7.27 15.63,9.98 15.71,10.07 18.41,10.07
GND on BOTTOM (solid shape): 21.08,76.4 21.08,75.32 21.13,75.27 21.13,74.21 20.99,74.08 20.77,74.08 20.35,74.5 20.35,76.34 20.43,76.41 21.07,76.41
GND on BOTTOM (solid shape): 88.73,32.87 88.73,29.23 88.47,28.98 87.97,28.98 87.84,29.11 87.84,30.88 87.2,31.52 87.2,32.66 87.46,32.92 88.68,32.92
GND on BOTTOM (solid shape): 98.81,42.55 98.81,40.71 98.73,40.63 97.14,40.63 96.73,41.04 96.73,43.33 96.86,43.46 97.9,43.46
GND on BOTTOM (solid shape): 134.32,134.52 134.32,133.37 134.19,133.25 133.11,133.25 132.16,133.25 132.1,133.31 132.1,134.52 132.16,134.58 134.26,134.58
GND on BOTTOM (solid shape): 149.56,134.52 149.56,133.37 149.43,133.25 148.35,133.25 147.4,133.25 147.34,133.31 147.34,134.52 147.4,134.58 149.5,134.58
GND on BOTTOM (solid shape): 169.1,77.33 169.1,77.06 168.71,76.68 165.23,76.68 165.07,76.84 165.07,78.16 165.21,78.29 168.13,78.29
GND on BOTTOM (solid shape): 180.68,108.12 179.94,107.39 179.91,107.39 179.14,106.61 179.09,106.61 178.52,107.19 178.52,107.67 179.63,108.79 180.01,108.79
GND on BOTTOM (solid shape): 189.91,37.48 189.91,36.54 189.76,36.39 189,36.39 188.91,36.47 188.17,36.47 188.04,36.6 188.04,37.62 188.17,37.74 189.65,37.74
GND on BOTTOM (solid shape): 200.94,73.49 200.94,70.34 200.9,70.29 198.86,70.29 198.8,70.35 198.8,72.37 198.85,72.42 199.05,72.42 200.18,73.55 200.88,73.55
GND on BOTTOM (solid shape): 237.22,23.67 237.22,21.77 237.69,21.29 237.69,18.68 237.06,18.06 235.67,18.06 235.51,18.21 235.51,23.57 235.69,23.75 237.14,23.75
GND on BOTTOM (solid shape): 239.96,20.62 239.96,16.69 239.79,16.52 238.46,16.52 238.31,16.67 238.31,20.58 238.68,20.95 239.63,20.95
GND on BOTTOM (solid shape): 51.26,12.83 52.02,12.83 52.08,12.88 52.45,12.88 52.56,12.77 52.56,12.38 52.32,12.15 50.44,12.15 50.03,12.55 50.03,13.02 50.15,13.14 50.96,13.14
GND on BOTTOM (solid shape): 141.81,134.52 141.81,133.37 141.69,133.25 140.73,133.25 140.61,133.25 139.65,133.25 139.59,133.31 139.59,134.52 139.65,134.58 141.75,134.58
GND on BOTTOM (solid shape): 180.09,103.89 180.09,103.15 180.14,103.1 180.83,103.1 180.93,102.99 180.93,101.7 180.85,101.62 179.89,101.62 178.52,102.99 178.52,103.12 179.35,103.96 180.02,103.96
GND on BOTTOM (solid shape): 274.68,12.31 274.68,11 274.55,10.87 271.51,10.87 271.38,11 270.56,11 270.43,10.87 269.69,10.87 269.34,11.21 269.34,13.29 269.71,13.66 273.33,13.66
GND on BOTTOM (solid shape): 24.46,79.57 24.56,79.02 24.66,78.48 24.66,77.98 24.54,77.86 23.81,77.86 23.4,78.27 23.4,79.63 23.44,79.66 24.37,79.66
GND on BOTTOM (solid shape): 30.79,45.18 31.31,45.18 31.4,45.09 31.4,44.4 31.15,44.15 29.3,44.15 28.97,44.48 28.3,44.48 27.98,44.8 27.98,45.13 28.12,45.27 30.69,45.27
GND on BOTTOM (solid shape): 256.87,14.54 257.46,14.54 257.54,14.45 257.54,13.73 257.47,13.65 256.48,13.65 256.48,13.65 254.52,13.65 254.23,13.94 254.23,14.72 254.28,14.77 256.63,14.77
GND on BOTTOM (solid shape): 279.51,46.85 279.51,44.54 279.41,44.44 278.09,44.44 277.96,44.57 277.96,45.14 277.77,45.33 277.77,46.8 277.99,47.02 279.34,47.02
GND on BOTTOM (solid shape): 181.89,100.36 181.89,99.8 181.82,99.73 180.74,99.73 180.55,99.54 180.52,99.54 179.37,98.39 179.2,98.39 178.55,99.05 178.55,99.52 179.71,100.68 181.57,100.68
GND on BOTTOM (solid shape): 185.76,124.81 186.69,124.81 186.75,124.75 186.75,124.38 186.61,124.24 184.2,124.24 183.8,124.64 183.8,125.29 183.85,125.33 184.19,125.33 184.2,125.32 184.52,125.32 184.67,125.48 185.09,125.48
GND on BOTTOM (solid shape): 195.21,72.32 195.21,70.33 195.05,70.16 194.73,70.16 194.69,70.12 194.69,69.27 194.5,69.08 193.88,69.08 193.66,69.3 193.66,72.21 193.84,72.39 195.14,72.39
GND on BOTTOM (solid shape): 200.56,121.39 200.56,120.72 200.46,120.63 198.01,120.63 197.92,120.71 197.92,121.09 197.77,121.25 197.51,121.25 197.41,121.34 197.41,121.49 197.51,121.59 200.36,121.59
GND on BOTTOM (solid shape): 62.39,11.4 62.39,6.57 62.65,6.32 63.54,6.32 63.66,6.19 63.66,5.43 63.41,5.18 59.85,5.18 59.6,5.43 59.6,8.1 60.61,9.11 60.61,10.26 61.88,11.53 62.27,11.53
GND on BOTTOM (solid shape): 161.5,129.18 161.5,124.23 161.37,124.1 161.18,124.1 160.48,124.8 159.59,124.8 159.47,124.93 159.47,126.77 158.96,127.28 158.96,128.29 159.72,129.06 160.74,129.06 160.99,129.31 161.37,129.31
GND on BOTTOM (solid shape): 216.46,43.91 216.46,43.36 216.41,43.3 216.11,43.3 215.5,42.7 214.51,42.7 214.18,43.03 214.18,43.45 214.2,43.52 214.2,43.58 214.2,43.76 214.44,43.99 216.39,43.99
GND on BOTTOM (solid shape): 239.89,105.77 239.89,105.24 239.76,105.11 239.3,105.11 238.92,104.73 238.92,103.76 238.86,103.7 238.52,103.7 238.41,103.81 238.41,104.82 238.68,105.09 238.68,105.44 239.08,105.84 239.82,105.84
GND on BOTTOM (solid shape): 262.83,48.3 262.83,45.47 262.14,44.79 260.12,44.79 259.75,44.42 258.45,44.42 258.27,44.6 258.27,46.45 258.4,46.58 259.38,46.58 259.7,46.9 259.7,48.34 259.85,48.48 262.64,48.48
GND on BOTTOM (solid shape): 169.37,109.12 169.37,107.47 169.07,107.16 168.74,107.16 168.28,106.7 167.72,106.7 167.59,106.83 167.59,107.85 167.34,108.1 166.45,108.1 166.32,108.23 166.32,108.61 166.45,108.74 167.47,108.74 168.23,109.5 168.99,109.5
GND on BOTTOM (solid shape): 285.12,25.09 285.12,24.81 285.07,24.76 285.07,23.82 285.81,23.09 288.02,23.09 289.17,21.93 289.17,17.7 288.99,17.52 286.59,17.52 281.59,22.52 281.59,24.87 281.92,25.19 285.02,25.19
GND on BOTTOM (solid shape): 23.66,85.08 23.83,83.88 23.83,83.23 23.6,83 22.71,83 22.46,83.26 22.46,84.43 22.46,84.48 22.48,84.5 22.49,84.5 22.57,84.58 22.67,84.58 22.73,84.63 22.73,85.07 22.77,85.11 23.63,85.11
GND on BOTTOM (solid shape): 210.21,73.22 210.21,73 212.04,71.18 212.04,71.14 211.83,70.94 211.69,70.94 211.5,70.75 211.5,70.35 211.41,70.26 210.28,70.26 210.22,70.32 210.22,72.21 209.69,72.74 209.69,73.26 209.71,73.27 210.16,73.27
GND on BOTTOM (solid shape): 225.83,121.31 226.57,121.31 226.82,121.06 226.82,120.13 226.77,120.08 226.19,120.08 225.67,120.61 224.57,120.61 224.44,120.74 224.44,121.2 224.39,121.26 224.11,121.26 224.06,121.31 224.06,121.5 224.1,121.55 224.6,121.55 224.71,121.65 225.49,121.65
GND on BOTTOM (solid shape): 213.92,121.51 213.92,121.3 213.88,121.26 213.56,121.26 213.43,121.12 213.43,120.61 212.9,120.08 212.49,120.08 211.68,119.27 211.03,119.27 210.78,119.53 210.78,120.72 210.86,120.8 212,120.8 212.39,121.19 212.39,121.51 212.43,121.56 213.87,121.56
GND on BOTTOM (solid shape): 240.19,11.5 240.19,9.5 240.14,9.45 239.81,9.45 239.48,9.12 239.27,9.12 238.99,9.4 237.49,9.4 237.42,9.32 237.42,9.24 237.29,9.12 237.06,9.12 236.86,9.32 236.86,10.89 236.63,11.12 236.38,11.12 236.25,11.25 236.25,11.73 236.3,11.78 239.91,11.78
GND on BOTTOM (solid shape): 33.85,52.83 33.85,50.17 33.76,50.08 31.35,50.08 30.52,49.25 30.52,48.87 30.37,48.71 30.2,48.71 30.19,48.72 29.16,48.72 29.06,48.81 29.06,49.24 29.1,49.29 29.66,49.29 29.74,49.36 29.74,51.88 31.22,53.37 33.32,53.37
GND on BOTTOM (solid shape): 151.06,104.26 151.26,104.26 151.49,104.5 151.63,104.5 151.77,104.35 151.77,104.16 151.39,103.78 151.39,103.15 151.27,103.02 151.05,103.02 150.95,103.12 150.95,103.56 150.59,103.92 150.59,103.94 150.56,104 150.53,104.06 150.53,104.39 150.63,104.5 150.83,104.5
GND on BOTTOM (solid shape): 245.44,14.76 245.44,13.05 244.86,12.47 242.84,12.47 242.2,13.11 242.2,14.64 242.48,14.77 242.55,15.07 242.75,15.26 244.93,15.26
GND on BOTTOM (solid shape): 7.5,122.1 0,122.1 0,127.9 0.29,128.61 1,128.9 7.5,128.9
GND on BOTTOM (solid shape): 108.92,95.53 112.98,95.53 113.11,95.4 113.11,94.64 113.24,94.51 114.25,94.51 114.51,94.77 115.65,94.77 115.91,94.51 115.91,94.13 115.78,94 114.51,94 114.25,93.75 114.25,93.11 114.13,92.99 109.3,92.99 109.05,92.73 109.05,92.1 108.92,91.97 108.03,91.97 107.9,92.1 107.9,95.53 108.03,95.65 108.79,95.65
GND on BOTTOM (solid shape): 219.6,60.16 219.6,59.33 219.71,59.22 220.56,59.22 221.01,59.68 222.55,59.68 222.6,59.62 222.6,59.29 222.5,59.19 222.13,59.19 221.2,58.27 218.71,58.27 218.57,58.4 218.57,58.68 218.77,58.89 218.95,58.89 219.36,59.31 219.36,60.13 219.44,60.2 219.55,60.2
GND on BOTTOM (solid shape): 122.13,91.84 122.13,89.69 122,89.56 120.48,89.56 119.84,88.92 119.72,88.92 119.61,88.82 119.61,88.61 119.61,88.56 119.61,88.39 119.61,88.34 119.61,86.77 119.57,86.73 119.57,86.18 119.26,85.87 119.26,85.8 118.06,84.61 114.74,84.61 114.39,84.95 114.39,88.55 117.94,92.1 121.87,92.1
GND on BOTTOM (solid shape): 264.73,22 264.91,22 265.06,21.85 265.06,21.72 264.73,21.39 264.73,20.22 265.01,19.93 265.64,19.93 266.73,18.83 267.57,18.83 267.77,18.64 267.77,17.99 267.75,17.97 265.76,17.97 265.64,18.09 265.64,18.9 265.55,18.99 264.87,18.99 264.6,19.25 264.6,19.27 264.59,19.27 264.53,19.32 264.17,19.32 263.84,19.65 263.84,21.16 263.8,21.2 262.86,21.2 262.78,21.28 262.78,21.9 262.89,22.01 264.72,22.01
GND on BOTTOM (solid shape): 189.44,103.15 189.44,99.59 189.59,99.44 189.59,99.18 190.35,99.18 190.35,99.34 190.53,99.34 190.66,99.21 190.66,98.11 190.52,97.97 188.58,97.97 188.57,98 188.35,98.22 188.05,98.19 188.02,98.17 187.97,98.23 187.97,100.17 188.17,100.37 188.17,103.35 188.23,103.41 189.17,103.41
GND on BOTTOM (solid shape): 184.73,106.1 184.74,106.1 184.82,106.02 184.82,105.47 184.84,105.46 184.84,105.18 184.74,105.08 184.74,103.93 185.2,103.48 185.2,101.79 185.22,101.77 185.22,99.16 184.82,98.75 183.16,98.75 183.09,98.83 183.09,100.58 183.34,100.84 184.38,100.84 184.49,100.94 184.49,101.9 184.08,102.31 184.08,103.58 184.49,103.99 184.49,104.98 184.41,105.05 184.41,105.09 184.38,105.11 184.38,105.18 184.08,105.48 183.27,105.48 183.22,105.53 183.22,106.11 183.26,106.16 184.68,106.16
GND on BOTTOM (solid shape): 80.55,10.64 80.55,9.37 80.81,9.11 81.57,9.11 81.82,8.86 81.82,6.55 81.6,6.32 80.08,6.32 80.07,6.33 79.01,6.33 78.65,6.69 78.65,6.83 78.65,6.83 78.65,7.33 78.01,7.97 73.7,7.97 73.57,8.1 73.57,8.99 73.7,9.11 73.95,9.11 74.33,8.73 78.64,8.73 78.93,9.02 79.26,9.02 79.41,9.17 79.41,10.81 79.48,10.88 80.31,10.88
GND on BOTTOM (solid shape): 252.21,34.5 252.21,32.74 252.11,32.64 250.04,32.64 250.02,32.61 249.85,32.61 249.57,32.32 249.57,31.02 249.88,30.71 249.88,29.37 249.57,29.07 249.57,27.97 249.66,27.88 249.66,27.53 249.58,27.45 249.34,27.45 249.26,27.53 249.23,27.59 249.23,27.75 249.25,27.8 249.25,27.81 249.34,27.9 249.34,28.99 248.93,29.41 248.93,31.17 248.88,31.21 248.88,32.43 248.65,32.67 248.65,33.7 248.08,34.26 248.08,34.81 248.12,34.84 251.86,34.84
GND on BOTTOM (solid shape): 231.76,46.73 232,46.5 232.32,46.57 232.36,46.58 232.39,46.56 232.49,46.46 232.49,43.85 231.55,42.9 231.33,42.9 231.26,42.84 230.03,42.84 230.02,42.83 222.97,42.83 222.56,43.24 222.56,45.93 223,46.37 223.88,46.37 224.98,45.27 229.39,45.27 230.88,46.76 231.75,46.76
GND on BOTTOM (solid shape): 135.16,104.44 135.18,104.41 135.21,104.38 135.21,104.2 134.83,103.83 134.83,103.15 134.7,103.02 134.52,103.02 134.39,103.15 134.39,103.78 134.01,104.16 134.01,104.35 134.13,104.48 134.32,104.48 134.37,104.44 134.4,104.39 134.45,104.36 134.47,104.34 134.5,104.33 134.6,104.31 134.7,104.33 134.74,104.34 134.8,104.39 134.9,104.5 135.09,104.5
GND on BOTTOM (solid shape): 137.52,104.44 137.54,104.41 137.57,104.38 137.57,104.2 137.19,103.83 137.19,103.15 137.06,103.02 136.88,103.02 136.75,103.15 136.75,103.78 136.37,104.16 136.37,104.35 136.5,104.48 136.69,104.48 136.73,104.44 136.77,104.39 136.81,104.36 136.83,104.34 136.86,104.33 136.96,104.31 137.07,104.33 137.1,104.34 137.16,104.39 137.26,104.5 137.45,104.5
GND on BOTTOM (solid shape): 139.88,104.44 139.9,104.41 139.93,104.38 139.93,104.2 139.56,103.83 139.56,103.15 139.43,103.02 139.24,103.02 139.11,103.15 139.11,103.78 138.73,104.16 138.73,104.35 138.86,104.48 139.05,104.48 139.09,104.44 139.13,104.39 139.17,104.36 139.19,104.34 139.22,104.33 139.33,104.31 139.43,104.33 139.46,104.34 139.52,104.39 139.63,104.5 139.82,104.5
GND on BOTTOM (solid shape): 144.6,104.44 144.63,104.41 144.66,104.38 144.66,104.2 144.28,103.83 144.28,103.15 144.15,103.02 143.96,103.02 143.84,103.15 143.84,103.78 143.46,104.16 143.46,104.35 143.58,104.48 143.77,104.48 143.82,104.44 143.85,104.39 143.9,104.36 143.92,104.34 143.95,104.33 144.05,104.31 144.15,104.33 144.19,104.34 144.25,104.39 144.35,104.5 144.54,104.5
