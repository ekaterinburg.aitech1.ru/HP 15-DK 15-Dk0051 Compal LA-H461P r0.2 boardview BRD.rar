# Allegro board LA-H461P Rev02.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 146.97,104.44 146.99,104.41 147.02,104.38 147.02,104.2 146.64,103.83 146.64,103.15 146.51,103.02 146.33,103.02 146.2,103.15 146.2,103.78 145.82,104.16 145.82,104.35 145.94,104.48 146.14,104.48 146.18,104.44 146.21,104.39 146.26,104.36 146.28,104.34 146.31,104.33 146.41,104.31 146.52,104.33 146.55,104.34 146.61,104.39 146.71,104.5 146.9,104.5
GND on BOTTOM (solid shape): 149.33,104.44 149.35,104.41 149.38,104.38 149.38,104.2 149.01,103.83 149.01,103.15 148.87,103.02 148.69,103.02 148.56,103.15 148.56,103.78 148.18,104.16 148.18,104.35 148.31,104.48 148.5,104.48 148.54,104.44 148.58,104.39 148.62,104.36 148.64,104.34 148.67,104.33 148.77,104.31 148.88,104.33 148.91,104.34 148.97,104.39 149.08,104.5 149.27,104.5
GND on BOTTOM (solid shape): 154.05,104.44 154.08,104.41 154.1,104.38 154.1,104.2 153.73,103.83 153.73,103.15 153.6,103.02 153.41,103.02 153.29,103.15 153.29,103.78 152.9,104.16 152.9,104.35 153.03,104.48 153.22,104.48 153.27,104.44 153.3,104.39 153.34,104.36 153.37,104.34 153.4,104.33 153.5,104.31 153.6,104.33 153.63,104.34 153.7,104.39 153.8,104.5 153.99,104.5
GND on BOTTOM (solid shape): 156.42,104.44 156.44,104.41 156.47,104.38 156.47,104.2 156.09,103.83 156.09,103.15 155.96,103.02 155.78,103.02 155.65,103.15 155.65,103.78 155.27,104.16 155.27,104.35 155.39,104.48 155.58,104.48 155.63,104.44 155.66,104.39 155.71,104.36 155.73,104.34 155.76,104.33 155.86,104.31 155.96,104.33 156,104.34 156.06,104.39 156.16,104.5 156.35,104.5
GND on BOTTOM (solid shape): 158.78,104.44 158.8,104.41 158.83,104.38 158.83,104.2 158.45,103.83 158.45,103.15 158.32,103.02 158.14,103.02 158.01,103.15 158.01,103.78 157.63,104.16 157.63,104.35 157.76,104.48 157.95,104.48 157.99,104.44 158.03,104.39 158.07,104.36 158.09,104.34 158.12,104.33 158.22,104.31 158.33,104.33 158.36,104.34 158.42,104.39 158.52,104.5 158.71,104.5
GND on BOTTOM (solid shape): 242.93,28.36 242.93,26.93 242.71,26.72 241.92,26.72 241.41,26.21 240.41,26.21 240.29,26.09 240.07,26.09 239.98,26.17 239.98,26.91 239.87,27.02 238.88,27.02 238.49,26.63 237.27,26.63 237.19,26.7 237.19,26.98 237.15,27.02 235.63,27.02 235.5,26.89 235.32,26.89 235.19,27.02 235.19,27.22 235.3,27.33 235.54,27.33 235.61,27.26 236.54,27.26 236.54,27.26 237.04,27.26 237.25,27.47 237.25,27.62 237.34,27.7 240.15,27.7 240.42,27.98 240.42,28.41 240.54,28.52 242.76,28.52
GND on BOTTOM (solid shape): 73.41,31.59 73.41,31.37 73.17,31.12 73.17,29.92 73.11,29.86 72.99,29.86 72.93,29.92 72.93,31.07 72.89,31.12 72.69,31.12 72.67,31.09 72.67,29.91 72.59,29.83 72.51,29.83 72.43,29.91 72.43,31.06 72.37,31.12 72.24,31.12 72.16,31.05 72.16,29.9 72.09,29.83 72.02,29.83 71.95,29.9 71.95,31.19 72.13,31.37 72.14,31.38 72.39,31.51 72.46,31.78 72.46,31.8 72.63,31.98 73.03,31.98
GND on BOTTOM (solid shape): 244.11,43.93 244.11,43.15 244.25,43.01 245.32,43.01 245.52,43.21 247.61,43.21 247.76,43.06 247.76,41.85 247.59,41.68 246.05,41.68 245.63,42.1 242.68,42.1 242,41.43 240.45,41.43 240,40.98 240,40.97 239.97,40.94 239.97,40.16 240.14,40 240.24,39.9 240.25,39.9 240.52,39.9 240.61,39.81 240.61,39.01 240.53,38.92 239.79,38.92 239.62,39.09 239.62,41.86 239.3,42.18 239.3,42.85 239.66,43.21 242.2,43.21 242.4,43.01 243.69,43.01 243.93,43.25 243.93,43.91 243.99,43.97 244.07,43.97
GND on BOTTOM (solid shape): 202.27,62.39 202.27,58.91 202.39,58.79 205.83,58.79 205.95,58.67 205.95,57.75 206.03,57.67 207.76,57.67 208.04,57.95 208.04,58.79 208.19,58.94 210.19,58.94 210.39,58.75 213.74,58.75 213.85,58.63 213.85,57.8 213.97,57.68 215.17,57.68 215.4,57.9 215.4,58.19 215.72,58.52 217.47,58.52 217.86,58.13 217.86,56.6 217.73,56.47 215.14,56.47 214.9,56.23 210.38,56.23 210.07,56.54 207.68,56.54 207.55,56.41 207.16,56.41 207,56.25 202.43,56.25 202.05,56.64 199.69,56.64 199.24,56.19 194.69,56.19 194.07,56.81 194.07,58.01 194.01,58.06 193.64,58.06 193.55,58.15 193.55,58.93 193.59,58.98 193.95,58.98 194.21,58.72 197.82,58.72 197.91,58.64 197.91,57.77 198.01,57.67 199.67,57.67 199.88,57.87 199.88,62.55 200.02,62.7 201.97,62.7
GND on BOTTOM (solid shape): 1.84,59.13 1.84,59.1 1.99,58.95 6.18,58.95 7.83,57.3 8.21,57.3 8.46,57.05 8.46,56.92 8.08,56.54 7.32,56.54 7.14,56.36 7.1,56.32 7.06,56.28 6.94,56.16 6.94,56.04 6.92,55.89 6.94,55.74 6.94,55.52 6.56,55.14 6.3,55.14 5.67,55.78 5.07,55.78 5.07,57.24 1.45,57.24 0.89,57.48 0.65,58.04 0.65,58.64 0.82,59.12 1.23,59.4 1.38,59.45 1.52,59.45
GND on BOTTOM (solid shape): 176.04,101.23 176.25,101.16 176.46,101.23 176.63,101.23 178.07,99.79 178.07,99.51 177.92,99.35 177.61,99.35 176.97,100 176.4,100 176.31,99.91 176.23,99.88 176.16,99.91 175.58,99.82 175.88,99.31 175.92,99.3 175.93,99.26 175.93,98.62 175.56,98.25 175.38,98.25 174.93,98.7 174.49,98.7 173.84,99.34 175.73,101.23
GND on BOTTOM (solid shape): 169.82,40.96 169.93,40.98 170,40.89 170,40.82 170.27,40.54 170.28,40.53 170.39,40.38 170.58,40.32 171.31,40.32 171.31,38.91 171.25,38.82 171.14,38.84 170.82,39.15 170.79,39.24 170.85,39.31 170.96,39.87 170.39,39.83 170.18,39.83 169.72,40.29 169.7,40.31 169.57,40.44 169.57,40.71
GND on BOTTOM (solid shape): 191.92,41.04 191.93,41.04 192.4,40.57 192.61,40.57 192.61,40.28 192.57,40.24 192.54,40.25 192.25,40.19 192.12,39.92 192.1,39.86 192.05,39.82 192,39.8 191.96,39.77 191.6,39.77 191.47,39.65 191.47,39.58 191.4,39.46 191.42,39.32 191.42,39.25 191.37,39.19 191.2,38.88 191.43,38.6 191.47,38.59 191.47,38.38 191.34,38.25 191.09,38.25 190.96,38.38 190.96,39.65 190.84,39.77 190.8,39.77 190.79,39.78 190.69,39.8 190.58,39.78 190.57,39.77 186.52,39.77 186.39,39.9 186.39,40.92 186.8,41.33 186.81,41.33 186.92,41.36 187.01,41.42 191.54,41.42
GND on BOTTOM (solid shape): outline of 94 points within 127.21,121.5 156.8,129.94
GND on BOTTOM (solid shape): 6.94,49.43 6.94,49.2 6.92,49.13 6.92,49.05 6.92,48.93 6.99,48.65 7.17,48.44 7.19,48.41 7.21,48.41 7.53,48.32 7.85,48.41 8.34,48.41 8.59,48.16 8.59,43.13 8.69,43.03 9.42,43.03 9.43,43.03 13.84,43.03 13.84,45.03 26.14,45.03 28.14,43.03 33.56,43.03 33.56,41.78 33.1,41.78 33.1,42.57 25.1,42.57 25.1,44.57 14.3,44.57 14.3,42.57 4.3,42.57 4.15,42.57 4.15,43.07 1.45,43.07 0.88,43.31 0.65,43.87 0.65,44.72 0.65,44.72 0.65,46.84 0.89,47.4 1.45,47.64 5.07,47.64 5.07,49.05 5.53,49.05 5.54,49.04 6.3,49.81 6.56,49.81
GND on BOTTOM (solid shape): 14.94,83.08 14.94,82.07 14.36,81.48 14.33,81.5 13.85,81.23 14.2,80.81 14.27,80.78 14.31,80.71 14.31,80.52 14.26,80.43 14.16,80.43 13.9,80.45 13.69,80.29 2.73,80.29 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.46 14.56,83.46
GND on BOTTOM (solid shape): 15.7,105.56 15.7,95.27 14.69,94.26 12.6,94.26 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.96,96.7 0.96,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.71,102.45 2.71,102.9 2.94,103.46 3.5,103.7 9.59,103.7 9.75,103.68 9.91,103.7 9.96,103.7 9.96,103.71 10.47,104.4 9.96,105.09 9.96,106.18 10.11,106.18 10.11,106.2 10.37,106.45 14.81,106.45
GND on BOTTOM (solid shape): outline of 148 points within 209.45,30.79 213.08,32.1
GND on BOTTOM (solid shape): outline of 87 points within 141.48,102.33 143.85,109.83
GND on BOTTOM (solid shape): outline of 360 points within 56.1,33.68 90.62,46.3
GND on BOTTOM (solid shape): outline of 705 points within 0.2,92.59 26.3,128.7
GND on BOTTOM (solid shape): outline of 2417 points within 0.2,0.2 313.4,137.62
GND on BOTTOM (solid shape): outline of 17613 points within 101.46,27.89 172.39,55.59
GND on IN1 (solid shape): 14.94,83.08 14.94,82.07 14.43,81.56 13.92,81.56 13.54,81.18 13.54,80.64 2.95,80.64 2.93,80.66 2.73,80.66 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.36 13.06,83.36 13.16,83.46 14.56,83.46
GND on IN1 (solid shape): 6.99,49.68 6.99,49.34 6.94,49.2 6.92,49.05 6.92,48.93 7.24,48.39 7.87,48.42 8.43,48.42 8.59,48.26 8.59,43.38 8.94,43.03 13.84,43.03 13.84,45.03 25.56,45.03 25.56,44.22 27.06,44.22 27.83,43.44 27.84,43.44 27.84,43.03 33.56,43.03 33.56,41.68 33.1,41.68 33.1,42.57 25.1,42.57 25.1,44.57 14.3,44.57 14.3,42.57 4.67,42.57 4.15,42.57 4.15,43.07 1.45,43.07 0.88,43.31 0.65,43.87 0.65,44.46 0.65,44.46 0.65,46.84 0.89,47.4 1.45,47.64 5.07,47.64 5.07,49.02 5.53,49.02 6.32,49.81 6.86,49.81
GND on IN1 (solid shape): outline of 104 points within 0.65,55.04 8.67,59.45
GND on IN1 (solid shape): 14.43,106.07 14.43,98.58 14.49,98.52 14.49,98.48 15.7,97.26 15.7,95.27 14.69,94.26 13.06,94.26 13.06,94.12 12.6,94.12 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.96,96.7 0.96,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.71,102.45 2.71,102.9 2.94,103.46 3.5,103.7 9.59,103.7 9.75,103.68 9.91,103.7 9.96,103.7 9.96,103.71 10.47,104.4 9.96,105.09 9.96,105.97 10.11,105.97 10.11,106.2 10.37,106.45 14.05,106.45
GND on IN1 (solid shape): outline of 2942 points within 0.2,0.2 313.4,137.62
GND on IN2 (solid shape): 13.06,83.46 14.56,83.46 14.94,83.08 14.94,82.07 14.36,81.48 14.33,81.5 13.95,81.42 13.86,81.05 13.87,81.02 13.48,80.63 2.89,80.63 2.86,80.66 2.73,80.66 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,83.49 13.06,83.49
GND on IN2 (solid shape): outline of 103 points within 0.65,55.04 8.72,59.45
GND on IN2 (solid shape): outline of 124 points within 0.65,41.7 33.56,49.81
GND on IN2 (solid shape): 15.03,106.23 15.03,96.7 15.7,96.03 15.7,95.27 13.97,93.55 13.4,93.55 13.4,93.55 13.2,93.57 13,93.55 13,93.55 12.86,93.55 12.83,93.57 12.6,93.57 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.96,96.7 0.96,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.71,102.45 2.71,102.9 2.94,103.46 3.5,103.7 9.6,103.7 9.75,103.68 9.9,103.7 9.96,103.7 9.96,103.71 10.47,104.4 9.96,105.09 9.96,105.29 9.96,105.29 9.96,106.27 10.14,106.45 14.81,106.45
GND on IN2 (solid shape): outline of 2957 points within 0.2,0.2 313.4,137.62
GND on IN2 (solid shape): outline of 20542 points within 181.31,64.67 252.16,135.7
GND on IN3 (solid shape): 14.94,83.08 14.94,82.07 14.55,81.67 13.81,81.67 12.55,80.41 3.26,80.41 3.07,80.61 2.73,80.61 2.73,81 2.97,81.56 3.53,81.8 11.23,81.8 12,81.3 12.6,82 12.6,84.05 13.97,84.05
GND on IN3 (solid shape): outline of 102 points within 0.65,55.01 8.77,59.81
GND on IN3 (solid shape): outline of 121 points within 0.65,41.78 33.56,49.88
GND on IN3 (solid shape): 15.7,105.56 15.7,95.27 14.69,94.26 12.6,94.26 12.6,95.65 12.03,96.34 11.24,95.9 1.75,95.9 1.19,96.14 0.96,96.7 0.96,100.95 1.19,101.51 1.75,101.75 2,101.75 2.5,101.95 2.71,102.45 2.71,102.9 2.94,103.46 3.5,103.7 9.59,103.7 9.75,103.68 9.91,103.7 9.96,103.7 9.96,103.71 10.47,104.4 9.96,105.09 9.96,105.88 9.96,105.88 9.96,106.25 10.16,106.45 14.81,106.45
GND on IN3 (solid shape): outline of 2849 points within 0.2,0.2 313.4,137.62
GND on GND1: outline of 247 points within 0.2,0.2 313.4,137.62 ; 5 cut-outs
GND on VCC: 244.28,55.14 244.05,55.37 244.05,64.64 243.52,65.17 225.23,65.17 214.27,76.09 214.27,80.75 213.91,81.11 213.91,83.57 214.32,83.98 214.32,96.62 213.56,97.39 197.94,97.39 197.04,98.32 192.21,98.32 188.42,102.11 188.42,108.08 182.58,113.92 182.58,136.44 182.79,136.65 233.28,136.65 233.28,135 234.11,132.5 236.28,131 236.28,117.12 240.41,110.49 247.72,107.72 254.4,107.72 253.18,99.06 252.18,91.92 252.07,81.67 254.59,71.74 253.15,67.52 257.35,66.03 257.39,66.05 257.54,65.8 257.69,65.55 256.88,64.98 258.65,62.35 260.62,59.86 261.44,60.44 262.48,59.28 263.57,58.17 260.58,55.14
GND on VCC: 15.91,50.87 8.87,57.91 6.04,57.91 6.04,58.21 1.62,58.21 1.62,58.64 1.65,58.68 2.2,58.83 2.2,59.4 2.35,59.6 2.35,62.85 5.32,62.85 5.32,61.95 9.46,61.95 9.46,62.85 11.89,62.85 13.43,63.89 13.06,65.71 13.06,76.73 13.43,78.55 11.89,79.59 9.46,79.59 9.46,80.49 5.32,80.49 5.32,79.59 3.7,79.59 3.7,80.83 10.71,80.83 12.53,80.45 13.57,82 13.57,95.65 12.56,97.18 10.76,96.87 1.92,96.87 1.92,100.78 2,100.78 3.18,101.27 3.67,102.45 3.67,102.73 9.75,102.73 10.11,102.77 10.45,102.88 10.77,102.88 10.77,103.08 11.42,104.3 10.92,105.59 10.92,117.71 11.42,119 10.77,120.22 10.77,120.42 10.45,120.42 10.11,120.53 9.75,120.57 1.17,120.57 1.17,127.73 14.01,127.73 18.73,117.85 19.53,116.95 20.69,116.61 24,116.61 25.33,115.28 24,113.95 22.09,113.95 20.45,113.2 19.94,111.48 21.18,102.65 21.91,101.31 23.33,100.78 24.63,100.78 24.63,96.82 24.5,96.82 22.86,96.07 22.35,94.35 23.87,83.6 23.85,83.59 22.58,83.59 20.66,81.66 20.66,51.18 20.35,50.87
GND on VCC: 185.98,54.5 185.78,54.7 185.78,58.54 187.76,60.52 188.09,60.52 189.3,59.31 224.31,59.31 228.26,55.36 228.26,54.81 227.96,54.5
GND on VCC: 132.16,29.59 131.5,30.25 98.97,30.25 98.63,30.58 98.63,46.94 98.2,47.37 74.48,47.37 74.27,47.58 74.27,48.19 91.73,58.46 101.83,76.02 101.91,76.1 102.59,76.1 103.23,75.46 110.93,75.46 111.46,75.99 111.46,82.34 114.61,85.49 117.41,85.49 118.06,86.15 118.06,89.83 118.3,90.07 162.66,90.07 163.81,88.92 167.36,88.92 167.74,88.54 168.5,88.54 170.03,87.02 171.43,87.02 174.58,83.86 174.58,83.36 176.25,81.68 177.9,81.68 181.82,77.77 181.82,68.96 177.75,64.9 177.75,51.82 173.46,47.52 173.46,43.94 172.82,43.3 172.82,37.39 170.82,35.39 170.82,34.39 169.3,32.88 169.3,31.93 166.96,29.59
GND on VCC: 157.29,119.53 156.4,120.42 132.94,120.42 132.56,120.04 132.01,120.04 131.65,120.4 131.65,121.79 128.61,124.84 128.61,126.49 127.34,127.76 127.34,129.2 127.95,129.82 155.68,129.82 156.31,129.18 156.57,129.18 156.67,129.08 156.67,127.3 157.33,126.64 162.03,126.64 162.26,126.41 162.26,123.87 162.51,123.62 162.51,119.76 162.28,119.53
GND on VCC: 284.82,4.57 284.68,4.71 284.69,25.15 283.27,26.57 276.92,26.57 276.59,26.9 276.59,29.2 275.6,30.19 265.05,30.19 264.55,30.68 264.55,41.25 264.86,41.56 312.26,41.56 312.43,41.39 312.43,4.57 ; 1 cut-out
GND on GND2: outline of 246 points within 0.2,0.2 313.4,137.62 ; 5 cut-outs
GNDA on GND1, VCC, GND2: 299.32,21.56 299.14,21.74 297.77,21.74 297.77,21.82 297.67,21.92 297.67,23.5 297.29,23.87 292.74,23.87 292.33,23.47 292.33,22.32 292.42,22.23 292.36,22.17 290.07,22.17 289.92,22.33 289.92,22.51 289.77,22.65 289.29,22.65 288.9,23.04 288.9,24.15 290.03,25.27 291.07,25.27 291.68,25.88 291.96,25.88 292.08,26.01 292.68,26.01 292.81,25.88 293.02,25.88 294.85,27.73 294.85,27.79 295.23,27.79 295.35,27.66 295.61,27.66 298.1,30.14 298.1,30.32 298.28,30.5 298.46,30.5 299.7,31.75 302.12,31.75 302.26,31.9 302.26,31.9 302.92,31.9 303.05,31.77 305.85,31.77 305.98,31.9 307.09,31.9 307.21,31.77 307.77,31.77 307.9,31.64 307.9,30.5 308.03,30.37 308.03,29.87 307.9,29.74 307.9,28.2 307.72,28.01 306.53,28.01 305.94,27.43 302.92,27.43 302.79,27.3 302.19,27.3 302.07,27.43 301.85,27.43 301.53,27.1 301.53,24.89 301.66,24.76 301.66,24.36 301.53,24.23 301.53,21.61 301.48,21.56
VCC_5V on BOTTOM (solid shape): 79.28,9.89 79.28,9.22 79.21,9.15 79.21,9.15 79.07,9.18 78.93,9.15 78.92,9.15 78.87,9.15 78.85,9.13 78.21,9.13 78.03,8.95 77.18,8.95 77.09,9.04 77.09,9.2 77.18,9.28 77.84,9.28 78.5,9.95 79.22,9.95
VIN_3V_LCDVDD on TOP (solid shape): 76.05,38.6 76.05,35.62 75.52,35.09 74.51,35.09 74.38,35.22 74.38,38.5 74.57,38.69 75.95,38.69
+2546PWR on TOP (solid shape): 22.62,80.14 22.62,79.74 23.8,78.57 23.8,76.16 23.71,76.08 20.53,76.08 20.46,76.15 20.46,77.51 20.09,77.88 20.09,78.72 20.21,78.83 20.21,80.17 22.6,80.17
+2546PWR on BOTTOM (solid shape): 22.04,78.01 23.1,78.01 23.75,77.36 23.75,76.77 23.68,76.7 20.38,76.7 20.34,76.74 20.34,77.26 20.41,77.33 20.41,79.01 20.47,79.07 20.97,79.07
+FB_PLLAVDD on TOP (solid shape): 211.57,97.87 211.57,97.61 211.84,97.33 211.84,96.54 211.79,96.49 211.54,96.49 211.33,96.7 211.33,96.8 211.39,96.86 211.39,97.22 211.12,97.5 211.12,97.86 211.18,97.92 211.52,97.92
+FB_PLLAVDD on BOTTOM (solid shape): 187.59,95.27 189.39,95.27 189.41,95.25 189.41,93.4 189.63,93.18 189.63,92.92 190.52,92.92 190.52,93.09 191.87,93.09 191.97,92.99 191.97,92.14 191.67,91.84 187.52,91.84 187.43,91.93 187.43,94.81 187.46,94.83 187.46,95.2 187.56,95.3
+FB_PLLAVDD on IN1 (solid shape): outline of 1605 points within 190.37,88.33 214.92,98.06
+GPU_PLLVDD on TOP (solid shape): 214.55,96.7 214.15,96.3 214.15,96.03 214.44,95.74 214.44,95.67 214.19,95.43 214.16,95.42 214.13,95.43 213.85,95.72 213.64,95.72 213.63,95.72 213.56,95.65 212.9,95.65 212.84,95.71 212.84,96.05 213.42,96.62 213.9,96.62 214.27,96.99
+GPU_PLLVDD on TOP (solid shape): 200.84,83.31 200.84,82.7 200.64,82.51 200.51,82.51 200.51,82.38 200.51,82.37 200.51,81.89 200.52,81.87 200.56,81.84 200.66,81.84 200.69,81.81 201.02,81.81 201.02,81.46 200.98,81.41 200.96,81.41 200.82,81.33 200.72,81.19 200.72,81.18 200.38,80.85 200.31,80.85 200.06,80.59 200.06,80.51 200.03,80.44 199.95,80.41 199.89,80.4 199.82,80.38 199.71,80.38 199.52,80.19 199.16,80.19 198.8,80.55 198.74,80.55 198.73,80.56 198.59,80.59 198.44,80.56 198.43,80.55 198.32,80.55 198.15,80.37 197.68,80.37 197.62,80.44 197.62,80.68 197.69,80.75 197.79,80.77 197.81,80.79 197.84,80.79 198.37,81.32 198.66,81.32 198.78,81.2 199.45,81.2 199.5,81.25 199.5,81.35 199.5,81.35 199.5,82.44 199.54,82.48 200.17,82.48 200.21,82.53 200.21,83.31 200.27,83.37 200.78,83.37
+GPU_PLLVDD on TOP (solid shape): outline of 229 points within 191.38,76.41 194.67,80.82
+GPU_PLLVDD on BOTTOM (solid shape): 199.81,82.23 201.88,82.23 202.51,81.6 202.51,81.03 202.47,80.95 202.39,80.93 202.34,80.93 202.22,81.05 202.22,81.07 202.11,81.3 201.88,81.39 201.81,81.41 201.77,81.48 201.52,81.73 201.21,81.55 201.2,81.54 201.06,81.4 201.04,81.4 200.72,81.07 201.04,80.73 201.06,80.73 201.19,80.61 201.2,80.56 201.21,80.53 201.2,80.44 201.11,80.39 200.08,80.39 200.08,80.5 200.09,80.51 199.83,80.93 199.57,80.51 199.58,80.5 199.58,80.39 198.88,80.39 198.75,80.52 198.58,80.56 198.51,80.59 198.47,80.66 198.42,80.81 198.29,80.91 198.26,80.92 198.26,81.21 198.34,81.3 198.37,81.41 198.37,81.42 198.49,81.54 198.55,81.53 198.58,81.52 198.66,81.5 198.69,81.43 199.11,81.18 199.17,81.66 199.17,82.22 199.22,82.27 199.77,82.27
+GPU_PLLVDD on IN1 (solid shape): outline of 716 points within 191.37,76.3 200.69,83.64
+LAN_REGOUT on BOTTOM (solid shape): 53.27,18.32 53.32,18.32 54,18.32 54.05,18.32 54.1,18.34 54.36,18.34 54.44,18.26 54.44,17.55 54.14,17.26 54.11,17.28 53.66,17.27 53.58,16.83 53.59,16.82 53.59,16.71 53.57,16.71 53.57,16.69 53.32,16.43 53.32,16 53.22,15.9 51.31,15.9 51.2,16.01 51.2,17.1 52.22,18.13 52.3,18.16 52.38,18.12 52.75,17.99 53.01,18.29 53.02,18.34 53.22,18.34
+LAN_VDD_1V0 on BOTTOM (solid shape): 55.25,18.29 55.25,17.5 55.34,17.4 55.34,16.76 55.41,16.7 55.41,16.67 55.41,16.55 55.45,16.44 55.45,16.43 55.45,16.33 55.43,16.33 55.43,14.1 55.27,13.95 55.26,13.94 55.09,13.8 55.03,13.59 55.03,13.57 54.18,12.72 52.69,12.72 52.69,12.82 52.5,13.01 52.02,13.01 51.97,12.96 51.31,12.96 51.18,13.09 51.14,13.14 51.09,13.18 51.01,13.26 51.01,15.39 51.26,15.64 53.04,15.64 53.29,15.39 53.29,14.37 53.42,14.25 54.69,14.25 54.95,14.5 54.95,18.29 55,18.34 55.2,18.34
+LAN_VDD_1V0 on IN2 (solid shape): outline of 180 points within 50.91,14.85 54.84,24.33
+LAN_VDD_3V3 on TOP (solid shape): outline of 198 points within 50.99,14.61 54.94,24.21
+LAN_VDD_3V3 on BOTTOM (solid shape): 54.82,18.29 54.82,15.16 54.74,15.09 53.5,15.09 53.42,15.16 53.42,15.92 53.45,15.95 53.57,16.08 54.18,16.08 54.23,16.13 54.23,16.91 54.25,16.99 54.24,17.07 54.24,17.09 54.59,17.45 54.59,18.29 54.64,18.34 54.77,18.34
+LAN_VDD_3V3 on IN2 (solid shape): 54.78,16.22 54.78,15.92 53.96,15.1 53.48,15.1 53.36,15.22 53.36,16.15 53.8,16.58 54.41,16.58
+LCDVDD on TOP (solid shape): 71.43,36.03 71.43,35.1 71.35,35.02 70.59,35.02 70.35,34.78 70.35,31.59 70.22,31.46 69.98,31.46 69.79,31.27 69.79,29.85 69.56,29.62 68.07,29.62 67.77,29.92 67.77,34.92 68.35,35.5 68.35,36.01 68.47,36.14 71.32,36.14
+LCDVDD on BOTTOM (solid shape): 69.3,33.97 69.3,31.26 69.16,31.13 69.16,29.91 69.11,29.86 68.98,29.86 68.94,29.89 68.94,31.07 68.87,31.13 68.71,31.13 68.66,31.08 68.66,29.9 68.61,29.85 68.49,29.85 68.44,29.89 68.44,31.08 68.39,31.13 68.21,31.13 68.16,31.08 68.16,29.91 68.11,29.86 68,29.86 67.93,29.92 67.93,31.1 67.9,31.13 67.72,31.13 67.67,31.08 67.67,29.9 67.63,29.86 67.47,29.86 67.43,29.9 67.43,31.44 67.26,31.61 67.26,32.19 67.41,32.34 67.41,33.62 67.89,34.1 69.17,34.1
+USB_VCC2 on TOP (solid shape): 22.56,92.1 22.56,91.16 22.52,91.15 22.26,90.89 22.37,90.54 22.4,90.48 22.39,90.41 22.35,90.17 22.48,89.95 22.51,89.88 22.48,89.8 22.35,89.5 22.52,89.22 22.56,89.16 22.56,89.09 22.6,88.72 22.95,88.59 23.03,88.57 23.06,88.49 23.06,87.53 23.2,87.4 23.2,86.96 23.15,86.96 22.85,86.61 23.15,86.25 23.2,86.25 23.2,85.24 22.81,84.86 21.42,84.86 21.31,84.97 21.31,86.29 21.43,86.41 21.66,86.41 22.05,86.57 22.01,87 21.99,87.07 22.01,87.13 22.09,87.4 21.96,87.64 21.93,87.72 21.96,87.8 22.09,88.04 22.01,88.3 21.99,88.37 22.01,88.43 22.01,88.88 21.58,88.98 21.57,88.98 21.46,88.98 21.32,89.11 21.3,89.15 21.26,89.2 21.26,89.35 19.66,90.96 14.76,90.96 14.11,91.61 14.11,93.17 14.31,93.37 21.29,93.37
+USB_VCC2 on BOTTOM (solid shape): 23.01,86.31 23.09,86.27 23.18,86.25 23.2,86.25 23.32,86.13 23.32,85.49 23.09,85.27 22.62,85.27 22.56,85.21 22.56,84.75 22.44,84.63 22.33,84.63 21.86,84.16 21.86,82.25 20.95,81.33 20.47,81.33 20.41,81.39 20.41,81.51 20.41,81.52 20.46,81.62 20.47,81.74 20.47,82.36 20.44,82.53 20.34,82.67 20.28,82.73 20.23,82.78 20.17,82.82 20.17,83.09 20.23,83.16 20.47,83.16 20.47,83.16 20.61,83.16 20.61,83.3 20.66,83.35 20.66,83.97 20.53,84.1 20.53,86 20.67,86.15 22.09,86.15 22.25,86.31
+USB_VCC2 on IN2 (solid shape): outline of 220 points within 19.89,84.99 23.32,92.34
+VGA_CORE on TOP (solid shape): 202.45,87.47 202.45,86.21 202.23,85.98 200.93,85.98 200.77,86.14 200.77,86.46 201.92,87.61 202.31,87.61
+VGA_CORE on TOP (solid shape): 203.08,90.91 203.08,90.09 202.98,89.99 201.24,89.99 201.02,90.21 201.02,90.55 201.15,90.68 202,90.68 202.31,90.99 203.01,90.99
+VGA_CORE on TOP (solid shape): 201.22,84.74 201.87,84.09 201.87,82.84 201.53,82.5 201.2,82.5 201.03,82.66 201.03,82.79 201.13,82.89 201.13,83.43 201.04,83.53 199.85,83.53 199.84,83.55 199.58,83.55 199.45,83.68 199.45,84.49 199.55,84.59 200.02,84.59 200.17,84.74 201.2,84.74
+VGA_CORE on TOP (solid shape): outline of 1468 points within 192.25,64.03 217.4,94.92
+VGA_CORE on BOTTOM (solid shape): outline of 3088 points within 189.45,65.29 215.57,96.5
+VGA_CORE on IN1 (solid shape): outline of 3778 points within 194.11,65.05 215.62,95.6
+VGA_CORE on IN2 (solid shape): outline of 3868 points within 193.17,65.12 216.59,96.37
+VGA_CORE on IN3 (solid shape): outline of 4042 points within 193.86,64.26 216.49,94.92
+VGA_CORE on VCC: 195.04,64.99 194.01,66.02 194.01,91.32 193.88,91.32 198.38,95.82 198.38,96.49 198.77,96.88 213.35,96.88 213.82,96.41 213.82,84.19 213.4,83.78 213.4,80.9 213.76,80.54 213.76,75.88 221.06,68.61 221.06,67.8 218.26,64.99
BST_1.35VSDGPUP on BOTTOM (solid shape): 240.56,52.56 240.56,51.8 239.5,50.74 239.5,50.25 239.35,50.09 238.49,50.09 238.44,50.15 238.44,50.75 240.31,52.62 240.49,52.62
BST_3V on BOTTOM (solid shape): 248.31,29.24 248.31,29.01 248.1,28.81 248.1,27.8 247.75,27.45 246.38,27.45 246.35,27.48 246.35,28.32 246.44,28.41 247.26,28.41 247.31,28.47 247.31,29.13 247.51,29.32 248.22,29.32
BST_3V_R on BOTTOM (solid shape): 245.98,28.37 245.98,27.56 245.93,27.5 244.67,27.5 244.61,27.56 244.61,28.29 244.75,28.42 245.92,28.42
BST_CHG on TOP (solid shape): 242.35,14.17 242.35,13.37 242.29,13.31 241.43,13.31 241.12,13.01 241.12,12.2 240.66,11.74 239.99,11.74 239.91,11.81 239.91,11.89 239.97,11.95 240.15,11.95 240.75,12.56 240.75,13.32 241.05,13.62 241.05,13.62 241.68,14.25 242.28,14.25
BST_DDR_R on BOTTOM (solid shape): 91.01,31.27 91.01,30.63 90.89,30.5 90.51,30.5 90.38,30.63 89.62,30.63 89.49,30.76 89.49,31.27 89.62,31.39 90.89,31.39
BST_GT on TOP (solid shape): 119.97,93.88 119.97,93.5 118.7,92.23 118.06,92.23 117.94,92.35 117.94,93.11 118.06,93.24 118.57,93.24 119.33,94 119.84,94
BST_PH1 on BOTTOM (solid shape): 151.85,136.1 151.85,135.15 151.78,135.09 151.53,135.09 151.08,135.53 150.13,135.53 150.07,135.6 150.07,136.36 150.13,136.42 151.53,136.42
BST_PH1_R on BOTTOM (solid shape): 151.08,135.02 151.08,133.63 150.83,133.37 150.2,133.37 150.07,133.5 150.07,135.02 150.15,135.1 151.01,135.1
BST_PH2 on BOTTOM (solid shape): 144.23,136.1 144.23,135.15 144.16,135.09 143.91,135.09 143.46,135.53 142.51,135.53 142.45,135.6 142.45,136.36 142.51,136.42 143.91,136.42
BST_PH2_R on BOTTOM (solid shape): 143.46,135.02 143.46,133.63 143.21,133.37 142.58,133.37 142.45,133.5 142.45,135.02 142.52,135.1 143.39,135.1
BST_PH3 on BOTTOM (solid shape): 136.61,136.1 136.61,135.15 136.54,135.09 136.29,135.09 135.84,135.53 134.89,135.53 134.83,135.6 134.83,136.36 134.89,136.42 136.29,136.42
BST_PH3_R on BOTTOM (solid shape): 135.84,135.02 135.84,133.63 135.59,133.37 134.96,133.37 134.83,133.5 134.83,135.02 134.91,135.1 135.77,135.1
BST_PH4 on BOTTOM (solid shape): 129.24,136.1 129.24,135.15 129.18,135.09 128.92,135.09 128.48,135.53 127.53,135.53 127.46,135.6 127.46,136.36 127.53,136.42 128.92,136.42
BST_PH4_R on BOTTOM (solid shape): 128.48,135.02 128.48,133.63 128.22,133.37 127.59,133.37 127.46,133.5 127.46,135.02 127.53,135.1 128.41,135.1
BST_VCCIOP on BOTTOM (solid shape): 187.7,104.36 187.7,103.79 187.65,103.74 185.74,103.74 185.72,103.76 185.72,104 186.11,104.39 187.67,104.39
BST_VCCSA on BOTTOM (solid shape): 159.47,133.75 159.47,132.99 159.4,132.93 159.28,132.93 158.45,133.75 157.56,133.75 157.43,133.88 157.43,134.39 157.56,134.52 158.7,134.52
CHG_DCIN on TOP (solid shape): 241.89,8.92 241.89,8.73 241.78,8.62 241.53,8.62 240.82,9.34 240.01,9.34 239.98,9.37 239.98,9.5 240.01,9.53 240.25,9.53 240.26,9.53 241.28,9.53
CHG_PHASE on TOP (solid shape): 254.72,10.03 254.72,8.64 254.61,8.53 253.79,8.53 253.66,8.66 251.18,8.66 251.15,8.69 251.15,9.61 251.2,9.66 253.59,9.66 253.72,9.8 253.72,10.03 253.83,10.14 254.61,10.14
CHG_PHASE on TOP (solid shape): 242.84,11.81 242.84,11.25 242.79,11.19 242.41,11.19 242.11,10.89 241.41,10.89 241.37,10.93 240,10.93 239.98,10.96 239.98,11.1 240,11.13 240.25,11.13 240.25,11.13 241.01,11.13 241.61,11.73 242.11,11.73 242.21,11.84 242.81,11.84
CHG_PHASE on BOTTOM (solid shape): 259.47,11.73 259.47,6.2 254.74,6.2 254.74,7.59 253.7,8.63 253.7,10.06 253.86,10.22 254.39,10.22 254.9,10.73 254.9,11.35 255.81,12.27 258.93,12.27
CHG_PHASE on IN3 (solid shape): 258.76,8.4 258.76,7.57 258.67,7.48 256.48,7.48 256.34,7.62 256.34,8.41 256.46,8.52 258.63,8.52
CHG_VDDP on TOP (solid shape): 242.4,10.03 243.55,10.03 243.81,10.29 244.63,10.29 244.85,10.06 245.79,10.06 245.85,10.01 245.85,9.31 245.82,9.28 244.77,9.28 244.56,9.49 242.28,9.49 241.78,9.98 240.91,9.98 240.76,10.14 240.03,10.14 239.99,10.17 239.99,10.29 240.03,10.33 240.25,10.33 240.26,10.33 240.89,10.33 241.01,10.21 241.68,10.21 241.83,10.36 242.07,10.36
DH_CHG on TOP (solid shape): 242.12,12.96 242.12,12.13 241.89,11.9 241.55,11.9 240.99,11.34 240,11.34 239.94,11.4 239.94,11.48 239.99,11.53 240.26,11.53 240.27,11.54 240.69,11.54 240.69,11.54 240.8,11.54 241.33,12.07 241.33,12.87 241.34,12.87 241.49,13.03 242.05,13.03
DH_CHG_R on TOP (solid shape): 254.54,11.73 254.54,10.87 254.45,10.78 253.26,10.78 253.15,10.89 253.15,11.67 253.28,11.8 254.48,11.8
DH_CHG_R on IN3 (solid shape): 254.5,11.67 254.5,10.88 254.38,10.76 252.47,10.76 252.09,11.15 252.09,11.66 252.19,11.77 254.4,11.77
DL_CHG on TOP (solid shape): 254.17,8.06 254.17,7.13 253.98,6.94 253.22,6.94 253.13,7.03 253.13,7.58 253.13,7.58 253.13,8.34 253.17,8.38 253.85,8.38
DL_CHG on IN3 (solid shape): 254.16,7.3 254.16,6.88 253.78,6.5 251.82,6.5 251.77,6.55 251.77,7.08 251.84,7.16 253,7.16 253.24,7.4 254.06,7.4
FB_CAL_PU_GND on TOP (solid shape): 213.88,98.13 213.88,97.66 213.72,97.5 213.56,97.5 213.52,97.54 213.52,97.56 213.16,97.56 213.09,97.63 213.09,97.99 212.83,98.26 212.83,98.29 212.92,98.38 212.99,98.43 213.04,98.5 213.21,98.67 213.33,98.67
HGATE_1.35VSDGPUP on BOTTOM (solid shape): 257.39,53.76 257.39,53.04 257.29,52.94 256.21,52.94 256.14,53.01 256.14,53.89 256.31,54.06 257.08,54.06
HGATE_1.35VSDGPUP on BOTTOM (solid shape): 241.07,52.55 241.07,51.23 240.45,50.61 240.28,50.61 240.1,50.8 240.1,51 240.83,51.73 240.83,52.54 240.89,52.61 241.01,52.61
HGATE_1.35VSDGPUP on IN3 (solid shape): 257.42,54.04 257.42,53.07 257.07,52.72 255.87,52.72 255.71,52.89 255.71,53.74 256.13,54.17 257.29,54.17
HGATE_1.35VSDGPUP on IN3 (solid shape): 241.74,52.01 241.74,51.79 241.33,51.38 241.32,51.38 241.03,51.2 240.86,50.92 240.86,50.91 240.54,50.6 240.24,50.6 240.04,50.8 240.04,51.41 241.03,52.4 241.34,52.4
IN_2.5V on TOP (solid shape): 107.11,18.85 107.11,17.65 106.9,17.44 105.89,17.44 105.51,17.06 104.32,17.06 104.22,17.16 104.22,18.01 103.85,18.38 103.85,19.26 103.88,19.28 105.13,19.28 105.39,19.54 106.42,19.54
INVPWR_B+ on TOP (solid shape): 88.6,34.91 88.6,34.21 88.57,34.18 88.57,34.06 88.5,33.99 88.11,33.99 87.87,33.75 87.87,33.24 87.73,33.1 87.35,33.1 87.04,32.79 87.04,32.72 87.03,32.71 86.99,32.54 87.03,32.37 87.04,32.36 87.04,31.96 87.03,31.95 86.99,31.78 87.03,31.61 87.04,31.6 87.04,31.48 87.67,30.85 87.67,29.86 87.04,29.23 87.04,27.8 86.99,27.75 84.65,27.75 84.64,27.79 84.37,28.07 84.01,27.94 83.94,27.9 83.86,27.93 83.81,27.97 83.81,31 83.95,31.14 85.12,31.14 85.5,31.52 85.5,33.82 85.55,33.87 85.55,33.88 85.65,33.95 85.73,34.05 85.73,34.06 86.19,34.52 86.47,34.52 86.98,35.02 88.49,35.02
INVPWR_B+ on BOTTOM (solid shape): 88.47,35.58 88.47,33.42 88.35,33.3 87.46,33.3 86.94,32.78 86.94,31.53 87.71,30.76 87.71,29.61 87.58,29.49 85.43,29.49 84.66,30.25 84.66,32.92 86.19,34.44 86.19,35.58 86.44,35.84 88.22,35.84
INVPWR_B+_R on TOP (solid shape): 83.06,30.82 83.06,27.89 82.89,27.72 79.61,27.72 79.12,28.21 79.12,31.86 79.31,32.05 81.83,32.05
INVPWR_B+_R on BOTTOM (solid shape): 80.93,31.98 80.93,31.35 80.75,31.17 80.75,31.17 80.67,31.09 80.67,29.9 80.62,29.84 80.48,29.84 80.43,29.89 80.43,31.08 80.39,31.11 80.2,31.11 80.17,31.09 80.17,29.91 80.1,29.85 79.99,29.85 79.92,29.91 79.92,31.09 79.87,31.14 79.72,31.14 79.67,31.09 79.67,29.88 79.62,29.84 79.49,29.84 79.42,29.9 79.42,31.34 79.1,31.66 79.1,31.9 79.26,32.06 80.85,32.06
KBL_ON_GND on BOTTOM (solid shape): 219.16,11.96 219.16,11.71 218.87,11.42 218.85,11.41 218.66,11.31 218.55,11.12 218.55,11.1 218.04,10.59 216.14,10.59 215.68,11.05 215.68,11.9 215.83,12.04 219.08,12.04
LANGND on TOP (solid shape): 12.22,79.14 13.04,79.14 14.53,77.64 14.64,77.37 14.91,77.26 16.26,75.91 16.26,65.66 12.9,62.3 3.71,62.3 3.48,62.53 3.48,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59 12.55,65.47 12.9,65.1 13.05,64.61 13.25,64.41 13.74,64.41 15.3,65.97 15.3,75.34 14.02,76.62 13.3,76.62 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.26,80.11
LANGND on BOTTOM (solid shape): 12.55,65.47 12.95,64.98 13.04,64.36 13.04,63.81 11.77,62.53 11.77,62.1 11.46,61.8 4.53,61.8 4.01,62.32 3.83,62.32 3.43,62.71 3.43,63.82 6.28,63.82 6.28,62.89 8.49,62.89 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.66 12.55,67.66
LANGND on BOTTOM (solid shape): 12.63,78.81 12.69,78.76 12.73,78.72 13.04,77.8 12.55,76.97 12.55,75.95 12.09,75.95 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.33,80.11
LANGND on IN1 (solid shape): 12.55,65.47 12.95,64.98 13.04,64.36 13.04,63.76 11.59,62.3 3.74,62.3 3.47,62.57 3.47,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59
LANGND on IN1 (solid shape): 12.73,78.72 13.04,77.8 12.55,76.97 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.34,80.11
LANGND on IN2 (solid shape): 12.55,65.47 12.95,65 13.04,64.39 13.04,63.76 11.59,62.3 3.71,62.3 3.43,62.58 3.43,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59
LANGND on IN2 (solid shape): 12.83,78.6 13.03,77.72 12.55,76.97 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.11 11.32,80.11
LANGND on IN3 (solid shape): 12.55,65.47 13.03,64.75 12.87,63.9 12.87,62.65 12.53,62.3 3.87,62.3 3.43,62.74 3.43,63.82 6.29,63.82 6.29,62.92 8.49,62.92 8.49,63.82 11.89,63.82 12.59,64.42 12.09,65.19 12.09,67.59 12.55,67.59
LANGND on IN3 (solid shape): 12.65,78.79 13.05,77.85 12.55,76.97 12.55,75.87 12.09,75.87 12.09,77.25 12.59,78.02 11.89,78.62 8.49,78.62 8.49,79.52 6.29,79.52 6.29,78.62 3.53,78.62 2.97,78.86 2.73,79.42 2.73,80.09 2.75,80.11 11.34,80.11
LDO_3V_VCCIOP on BOTTOM (solid shape): 183.02,106.2 183.02,105.48 183.16,105.34 183.98,105.34 184.28,105.04 184.28,104.14 184.18,104.04 183.67,104.04 183.62,104.09 183.62,104.15 183.57,104.2 183.57,104.25 182.31,105.51 182.31,106.16 182.45,106.3 182.92,106.3
LG_DDR on BOTTOM (solid shape): 90.51,28.09 90.51,27.71 89.74,27.71 89.36,28.09 89.36,28.55 89.54,28.73 89.87,28.73
LGATE_1.35VSDGPUP on BOTTOM (solid shape): 258.22,48.38 259.09,48.38 259.09,47.4 258.91,47.22 257.66,47.22 257.49,47.39 257.49,48.61 257.58,48.7 257.9,48.7
LGATE_1.35VSDGPUP on BOTTOM (solid shape): 243.27,52.23 243.27,51.32 242.94,50.99 242.45,50.99 242.34,51.1 242.34,51.38 242.33,51.38 242.33,52.52 242.44,52.63 242.86,52.63
LGATE_1.35VSDGPUP on IN3 (solid shape): 258.3,48.33 258.3,46.84 258.06,46.6 257.25,46.6 257.17,46.68 257.17,48.3 257.38,48.51 258.12,48.51
LGATE_1.35VSDGPUP on IN3 (solid shape): 243.46,51.46 243.46,49.92 243.3,49.76 243.01,49.76 242.4,50.37 242.4,50.93 242.27,51.05 242.27,51.41 242.5,51.64 242.51,51.64 242.68,51.8 243.12,51.8
LX_1.8V on BOTTOM (solid shape): 262.45,20.54 262.89,20.54 262.89,20.45 263.42,20.45 263.42,20.47 263.45,20.52 263.51,20.51 263.62,20.4 263.62,20.16 263.58,20.08 263.49,20.06 263.45,20.07 263.42,20.07 262.89,20.07 262.63,19.82 262.89,19.57 263.42,19.57 263.45,19.57 263.49,19.57 263.58,19.56 263.62,19.48 263.62,18.66 263.16,18.21 261.07,18.21 260.98,18.29 260.98,20.73 261.1,20.85 262.15,20.85
LX_1.35VSDGPUP on BOTTOM (solid shape): 241.57,52.56 241.57,51.04 241.78,50.83 241.78,48.87 241.73,48.82 241.04,48.82 240.99,48.88 240.99,50.88 241.33,51.22 241.33,52.54 241.4,52.62 241.51,52.62
LX_1.35VSDGPUP on BOTTOM (solid shape): 259.06,56.94 262.48,56.94 263.25,56.17 263.25,49.05 263.09,48.88 258.43,48.88 258.16,49.16 258.16,53.7 257.28,54.58 256.11,54.58 255.53,54.01 255.53,53.1 255.4,52.97 252.4,52.97 252.19,53.18 252.19,57.3 252.68,57.79 258.21,57.79
LX_1.35VSDGPUP on IN1 (solid shape): 253.7,54.79 253.7,54.23 253.6,54.13 246.54,54.13 244.61,52.19 244.61,51.53 244.61,51.53 244.5,50.79 244.56,50.05 244.57,50.02 243.86,49.31 241.75,49.31 241.13,49.93 241.13,50.71 241.28,50.81 241.4,50.95 241.64,50.95 241.76,50.82 241.76,50.32 241.96,50.12 243.25,50.12 243.74,50.62 243.74,52.65 244.78,53.69 244.9,53.78 244.99,53.9 246.19,55.1 253.38,55.1
LX_1V05 on TOP (solid shape): 240.28,28.81 240.28,27.94 240.14,27.8 235,27.8 234.78,27.59 234.78,26.84 234.5,26.55 233.59,26.55 233.19,26.96 231.58,26.96 231.51,27.02 231.51,28.79 231.63,28.91 240.18,28.91
LX_1V05 on BOTTOM (solid shape): 236,28.96 236,28.95 236.69,28.26 236.69,28.26 236.69,27.54 236.61,27.46 235.15,27.46 233.59,25.9 233.59,23.79 233.18,23.38 228.21,23.38 227.85,23.73 227.85,27.79 228.62,28.55 232.5,28.55 233.51,29.56 235.39,29.56
LX_2.5V on TOP (solid shape): 111.59,19.89 111.59,16.88 111.44,16.74 110.4,16.74 110.27,16.86 110.27,17.35 110.02,17.61 109.04,17.61 108.89,17.76 108.89,17.99 108.99,18.08 110.15,18.08 110.34,18.27 110.34,18.97 110.49,19.12 111.02,19.12 111.11,19.2 111.11,19.88 111.17,19.94 111.54,19.94
LX_3V on BOTTOM (solid shape): 248.7,31.98 248.7,31.21 248.8,31.11 248.8,29.24 249.13,28.91 249.13,27.82 249.09,27.67 249.13,27.52 249.13,25.35 249.51,24.96 251.54,24.96 251.58,24.92 251.58,23.65 251.24,23.3 243.93,23.3 243.47,23.77 243.47,28.29 243.63,28.45 244.25,28.45 244.38,28.32 244.38,27.51 244.77,27.12 248.06,27.12 248.41,27.46 248.41,28.85 248.49,28.94 248.49,31.08 248.41,31.16 248.41,31.99 248.52,32.1 248.57,32.1
LX_3V_LCDVDD on TOP (solid shape): 71.54,38.68 72.74,38.68 72.88,38.54 72.88,38.35 72.43,37.91 71.56,37.03 69.31,37.03 69.26,37.08 69.26,37.95 69.3,38 70.05,38 70.1,38.04 70.1,38.71 70.19,38.81 71.41,38.81
LX_5V on TOP (solid shape): 74.39,7.28 75.01,7.28 75.15,7.13 75.15,6.39 74.36,5.59 72.14,5.59 72.04,5.68 72.04,7.5 72.22,7.67 73.99,7.67
LX_5V on BOTTOM (solid shape): 73.19,7.97 73.44,7.72 73.95,7.72 73.97,7.7 77.11,7.7 77.34,7.47 77.11,7.24 74.24,7.24 73.95,6.95 73.95,6.7 73.7,6.45 70.9,6.45 70.65,6.7 70.65,10.89 70.77,11.02 73.19,11.02
LX_7237 on TOP (solid shape): 86.15,40.12 86.15,38.06 85.71,37.62 85.71,35.8 85.54,35.63 84.7,35.63 84.44,35.9 83.41,35.9 83.28,36.02 83.28,40.11 83.42,40.24 86.03,40.24
LX_7237 on BOTTOM (solid shape): 86.19,40.03 86.19,39.52 86.31,39.39 88.35,39.39 88.47,39.27 88.47,37.36 88.35,37.23 86.31,37.23 86.06,37.49 86.06,38.12 85.55,38.63 85.55,40.03 85.68,40.16 86.06,40.16
LX_+1.0VSDGP on BOTTOM (solid shape): 177.53,98.88 177.78,98.88 178.03,99.13 178.34,99.13 178.42,99.05 178.42,98.99 178.87,98.54 178.87,98.19 177.3,96.62 176.99,96.62 176.97,96.64 176.89,96.77 176.77,96.85 176.76,96.85 175.7,97.91 175.7,98.19 176.13,98.63 176.13,99.36 176.54,99.77 176.64,99.77
LX_DDR on TOP (solid shape): 92.51,36.73 92.51,35.86 92.38,35.74 92.13,35.74 91.98,35.58 91.98,32.84 92.16,32.66 92.54,32.66 92.66,32.54 92.66,31.65 91.39,30.38 90.89,30.38 90.76,30.25 90.76,29.23 90.63,29.11 90.38,29.11 90.12,29.36 90.12,32.15 90.96,32.99 90.96,35.51 90.89,35.58 90.89,37.11 91.01,37.23 92,37.23
LX_DDR on BOTTOM (solid shape): 94.44,35.33 94.44,33.04 94.32,32.92 92.79,32.92 92.66,32.79 92.66,31.65 92.54,31.52 92.28,31.52 92.16,31.65 91.52,31.65 91.14,32.03 90.51,32.03 90.38,32.15 90.38,36.09 90.89,36.6 90.89,37.11 91.27,37.49 92.28,37.49
LX_DDR on BOTTOM (solid shape): 90.25,30.25 90.63,30.25 90.76,30.12 90.76,29.2 90.95,29.01 90.95,28.5 90.85,28.4 90.75,28.5 90.75,28.92 90.69,28.98 90.51,28.98 89.74,29.74 89.62,29.74 89.49,29.87 89.49,30.25 89.62,30.38 90.12,30.38
LX_DDR on IN1 (solid shape): 92.66,37.11 92.66,32.28 92.54,32.15 92.16,32.15 92.03,32.03 92.03,31.77 91.9,31.65 91.65,31.65 90.76,30.76 90.76,29.23 90.63,29.11 90.38,29.11 90.25,29.23 90.25,29.61 90.12,29.74 90.12,31.77 90.38,32.03 90.38,32.41 90.89,32.92 90.89,37.11 91.01,37.23 92.54,37.23
LX_GT_R on BOTTOM (solid shape): 111.38,102.58 111.38,101.54 111.21,101.37 110.44,101.37 110.32,101.24 110.32,100.35 110.57,100.1 112.73,100.1 112.9,99.93 112.9,96.08 112.86,96.04 108.25,96.04 107.91,96.38 107.91,97.81 107.9,97.81 107.9,101.75 108.79,102.64 111.32,102.64
LX_PH1 on BOTTOM (solid shape): 152.35,133.63 152.35,132.36 151.85,131.85 151.85,131.15 151.78,131.09 151.15,131.09 151.08,131.15 151.08,131.66 150.26,132.48 150.26,133.06 150.32,133.12 150.83,133.12 151.27,132.67 151.91,132.67 152.1,132.87 152.1,133.63 152.16,133.69 152.29,133.69
LX_PH1_R on TOP (solid shape): 153.3,125.66 153.3,124.9 153.2,124.8 151.27,124.8 151.21,124.86 151.21,126.45 151.27,126.52 152.45,126.52
LX_PH1_R on BOTTOM (solid shape): 154.51,126.26 154.51,121.69 154.26,121.44 152.74,121.44 152.48,121.69 152.48,123.09 151.72,123.09 151.72,121.69 151.47,121.44 150.26,121.44 150.13,121.56 150.13,124.42 151.08,125.37 151.08,126.26 151.21,126.39 154.39,126.39
LX_PH2 on BOTTOM (solid shape): 144.73,133.63 144.73,132.36 144.23,131.85 144.23,131.15 144.16,131.09 143.53,131.09 143.46,131.15 143.46,131.66 142.64,132.48 142.64,133.06 142.7,133.12 143.21,133.12 143.65,132.67 144.29,132.67 144.48,132.87 144.48,133.63 144.54,133.69 144.67,133.69
LX_PH2_R on TOP (solid shape): 147.27,124.86 147.21,124.8 145.56,124.8 145.43,124.93 145.43,125.18 146.13,125.88 146.13,126.52 146.19,126.58 147.27,126.58
LX_PH2_R on BOTTOM (solid shape): 146.89,126.26 146.89,121.69 146.64,121.44 144.99,121.44 144.86,121.56 144.86,123.09 144.1,123.09 144.1,121.56 143.97,121.44 142.64,121.44 142.38,121.69 142.38,124.42 143.46,125.5 143.46,126.26 143.59,126.39 146.77,126.39
LX_PH3 on BOTTOM (solid shape): 137.11,133.63 137.11,132.36 136.61,131.85 136.61,131.15 136.54,131.09 135.91,131.09 135.84,131.15 135.84,131.66 135.02,132.48 135.02,133.06 135.08,133.12 135.59,133.12 136.03,132.67 136.67,132.67 136.86,132.87 136.86,133.63 136.92,133.69 137.05,133.69
LX_PH3_R on BOTTOM (solid shape): 140.04,125.37 141.5,125.37 141.56,125.31 141.56,124.29 141.5,124.23 139.4,124.23 139.27,124.1 139.27,121.69 139.02,121.44 137.5,121.44 137.24,121.69 137.24,123.09 136.48,123.09 136.48,121.69 136.23,121.44 134.96,121.44 134.7,121.69 134.7,124.36 135.84,125.5 135.84,126.26 135.97,126.39 139.02,126.39
LX_PH4 on BOTTOM (solid shape): 129.75,133.63 129.75,132.36 129.24,131.85 129.24,131.15 129.18,131.09 128.54,131.09 128.48,131.15 128.48,131.66 127.65,132.48 127.65,133.06 127.72,133.12 128.22,133.12 128.67,132.67 129.3,132.67 129.49,132.87 129.49,133.63 129.56,133.69 129.68,133.69
LX_PH4_R on TOP (solid shape): 127.08,126.01 126.95,125.88 126.95,124.86 127.08,124.74 128.1,124.74 128.73,125.37 128.99,125.37 129.11,125.25 129.11,124.86 128.35,124.1 126.19,124.1 125.43,124.86 125.43,127.02 127.08,127.02
LX_PH4_R on BOTTOM (solid shape): 131.91,126.26 131.91,121.69 131.65,121.44 129.75,121.44 129.62,121.56 129.62,123.09 128.86,123.09 128.86,121.56 128.73,121.44 127.34,121.44 127.08,121.69 127.08,124.1 128.48,125.5 128.48,126.26 128.61,126.39 131.78,126.39
LX_VCCIOP on TOP (solid shape): 187.07,109.07 187.07,108.16 185.4,106.5 184.47,106.5 182.47,108.5 182.47,109.05 184.21,110.79 185.35,110.79
LX_VCCIOP on BOTTOM (solid shape): 187.7,108.29 187.7,104.58 187.66,104.54 186.93,104.54 186.8,104.57 186.66,104.54 186.03,104.54 185.47,103.98 185.47,103.79 185.35,103.67 185.24,103.67 184.92,103.99 184.92,105.04 185,105.12 185,106.04 184.72,106.32 184.59,106.32 182.17,108.74 182.17,109.07 184.46,111.35 184.64,111.35
LX_VCCSA on BOTTOM (solid shape): 159.97,131.47 159.97,129.94 159.47,129.44 158.26,129.44 157.62,130.07 157.62,130.71 157.69,130.77 158.45,130.77 158.51,130.71 158.51,130.13 158.64,130.01 159.28,130.01 159.72,130.45 159.72,131.47 159.78,131.53 159.91,131.53
LX_VCCSA on BOTTOM (solid shape): 159.28,126.58 159.28,124.04 160.34,122.97 160.34,120.54 160.31,120.5 159.4,120.5 159.34,120.56 159.34,121.44 158.58,121.44 158.58,120.29 158.51,120.23 157.56,120.23 157.43,120.36 157.43,123.28 158.2,124.04 158.2,126.58 158.26,126.64 159.21,126.64
Net_31 on BOTTOM (solid shape): 232.16,30.95 224.16,30.95 224.16,38.95 232.16,38.95
NVVDD_BST1 on BOTTOM (solid shape): 225.48,54.81 225.48,54.38 224.07,52.96 223.45,52.96 223.38,53.03 223.38,53.81 223.43,53.87 224.13,53.87 224.4,54.14 224.4,54.56 224.75,54.91 225.38,54.91
NVVDD_BST1_R on BOTTOM (solid shape): 222.79,53.81 222.79,53.13 223.12,52.8 224.22,52.8 224.84,52.17 225.39,52.17 225.51,52.05 225.51,51.48 225.47,51.43 224.56,51.43 223.87,52.12 222.32,52.12 221.93,52.5 221.93,53.84 221.99,53.9 222.7,53.9
NVVDD_BST2 on BOTTOM (solid shape): 229.62,54.81 230.85,54.81 231.19,54.47 231.43,54.32 231.71,54.4 232.57,54.4 232.7,54.27 232.7,53.69 232.66,53.64 231.65,53.64 231.65,53.64 231.35,53.64 230.71,54.28 229.01,54.28 228.78,54.51 228.78,54.86 228.83,54.91 229.52,54.91
NVVDD_BST2_R on BOTTOM (solid shape): 232.65,52.96 232.65,52.45 232.54,52.33 230.38,52.33 230.31,52.41 230.31,52.9 230.39,52.99 232.62,52.99
NVVDD_BST3 on BOTTOM (solid shape): 219.08,58.02 219.08,57.28 218.84,57.04 218.84,56.7 219.31,56.23 219.31,55.36 219.29,55.34 218.65,55.34 218.62,55.36 218.62,56.09 218.5,56.21 218.5,57.15 218.72,57.37 218.72,58 218.82,58.09 219.01,58.09
NVVDD_BST3_R on BOTTOM (solid shape): 220.72,56.21 220.72,56 220.86,55.86 221.58,55.86 221.62,55.82 221.62,55.28 221.57,55.24 220.16,55.24 220.05,55.35 220.05,56.2 220.09,56.25 220.69,56.25
NVVDD_LG1 on BOTTOM (solid shape): 207.76,59.96 207.76,58.05 207.61,57.9 206.45,57.9 206.4,57.95 206.4,60.06 206.52,60.18 207.53,60.18
NVVDD_LG1 on BOTTOM (solid shape): 226.5,54.32 226.5,53.46 226.69,53.28 226.69,52.59 226.47,52.38 226.06,52.38 225.92,52.52 225.92,52.77 226.14,52.99 226.14,53.45 226.27,53.57 226.27,54.34 226.33,54.41 226.42,54.41
NVVDD_LG1 on IN3 (solid shape): 225.57,54.58 226.25,54.58 226.79,54.04 226.79,52.64 226.55,52.4 226.11,52.4 225.98,52.52 225.98,52.78 226.17,52.97 226.17,53.6 225.94,53.82 225.6,53.82 225.56,53.86 225.56,54.59
NVVDD_LG1 on IN3: 207.67,59.04 207.03,59.04 206.86,58.87 206.86,58.24 207.83,57.27 208.06,57.27 208.58,57.79 208.58,58.13
NVVDD_LG2 on BOTTOM (solid shape): 199.65,59.9 199.65,57.9 199.57,57.81 199.12,57.81 199.11,57.82 198.49,57.82 198.45,57.86 198.45,59.48 198.46,59.49 198.46,59.98 198.6,60.11 199.44,60.11
NVVDD_LG2 on BOTTOM (solid shape): 227.99,54.33 227.99,53.64 228.62,53.01 228.62,52.8 228.54,52.71 228.33,52.71 228.28,52.77 227.83,52.77 227.72,52.89 227.72,53.54 227.77,53.59 227.77,54.35 227.82,54.4 227.92,54.4
NVVDD_LG2 on IN1 (solid shape): 228.63,53.01 228.63,52.8 228.53,52.7 228.1,52.7 227.49,52.09 227.44,52.09 226.95,52.58 226.95,52.65 227.74,53.44 228.2,53.44
NVVDD_LG2 on IN1: 199.37,58.91 198.94,58.49 198.94,58.15 199.76,57.34 200.09,57.34 200.62,57.87 200.62,57.99 199.69,58.91
NVVDD_LG3 on BOTTOM (solid shape): 219.97,60.83 219.98,60.83 220.11,60.7 220.11,59.5 220.04,59.43 219.93,59.43 219.85,59.51 219.85,60.15 219.63,60.37 218.55,60.37 218.41,60.24 217.49,60.24 216,58.75 215.2,58.75 215.09,58.64 215.09,58.22 214.97,58.1 214.38,58.1 214.32,58.16 214.32,59.86 214.35,59.88 216.05,59.88 217.04,60.88 219.93,60.88
NVVDD_LX1 on BOTTOM (solid shape): 206.05,54.29 206.05,53.18 206.01,53.15 205.16,53.15 205.12,53.18 205.12,54.32 205.16,54.36 205.98,54.36
NVVDD_LX1 on BOTTOM (solid shape): 226,54.34 226,53.62 225.89,53.51 225.89,53.23 225.51,52.85 225.51,52.4 225.46,52.35 224.95,52.35 224.88,52.42 224.88,53.56 225.72,54.4 225.94,54.4
NVVDD_LX1 on IN3 (solid shape): 206.96,53.79 206.96,52.91 206.81,52.76 205.32,52.76 205.17,52.91 205.17,53.77 205.32,53.91 206.85,53.91
NVVDD_LX1 on IN3 (solid shape): 225.95,53.24 225.95,53.18 224.78,52.01 224.63,52.01 224.23,52.41 224.23,52.6 224.48,52.85 224.48,52.86 225.14,53.51 225.67,53.51
NVVDD_LX1_1 on BOTTOM (solid shape): 207.26,63.23 207.26,61.13 207.12,60.98 206,60.98 205.79,60.77 205.79,59.29 205.72,59.22 202.55,59.22 202.5,59.28 202.5,63.21 202.6,63.32 204.38,63.32 204.39,63.3 204.43,63.26 204.43,62.42 204.47,62.39 205.24,62.39 205.3,62.44 205.3,63.24 205.38,63.32 207.17,63.32
NVVDD_LX2 on BOTTOM (solid shape): 197.99,54.25 197.99,53.14 197.95,53.11 197.1,53.11 197.06,53.14 197.06,54.28 197.1,54.32 197.92,54.32
NVVDD_LX2 on BOTTOM (solid shape): 228.51,54.3 228.51,53.91 228.99,53.44 229.3,53.44 229.87,54 230.71,54 231.14,53.57 231.14,53.26 231.01,53.13 230.15,53.13 230.01,52.99 230.01,52.48 229.92,52.4 229.51,52.4 228.28,53.62 228.28,54.32 228.34,54.38 228.43,54.38
NVVDD_LX2 on IN1 (solid shape): 198.93,53.54 198.93,52.91 198.8,52.78 197.09,52.78 196.94,52.93 196.94,53.47 197.07,53.6 197.86,53.6 197.88,53.62 198.85,53.62
NVVDD_LX2 on IN1 (solid shape): 231.7,53.13 231.7,52.25 231.53,52.07 230.97,52.07 230.89,52.14 230.89,52.86 230.33,53.41 230.33,53.95 230.51,54.13 230.71,54.13
NVVDD_LX2_1 on BOTTOM (solid shape): 196.74,63.29 196.74,62.42 196.8,62.36 197.56,62.36 197.62,62.43 197.62,63.25 197.7,63.33 199.35,63.33 199.54,63.14 199.54,61.44 199.11,61.01 198.05,61.01 197.87,60.83 197.87,59.27 197.79,59.19 192.47,59.19 192.17,59.49 192.17,60.45 192.23,60.51 194.32,60.51 194.53,60.72 194.53,63.02 194.84,63.34 196.7,63.34
NVVDD_LX3 on BOTTOM (solid shape): 213.86,54.29 213.86,53.19 213.83,53.15 212.98,53.15 212.94,53.19 212.94,54.33 212.97,54.36 213.8,54.36
NVVDD_LX3 on BOTTOM (solid shape): 220.1,58 220.1,57.31 220.32,57.09 220.71,57.09 220.85,57.23 221.11,57.23 221.63,56.71 221.63,56.08 221.57,56.02 220.94,56.02 220.86,56.1 220.86,56.38 220.82,56.42 220.29,56.42 220.21,56.49 220.21,56.69 219.86,57.04 219.86,57.99 219.93,58.05 220.05,58.05
NVVDD_LX3_1 on BOTTOM (solid shape): 213.37,63.33 214.29,63.33 214.29,63.33 214.9,63.33 215.13,63.1 215.13,61.59 215.12,61.49 215.13,61.39 215.13,60.87 214.65,60.39 214.14,60.39 214.11,60.37 214.1,60.37 213.9,60.16 213.9,60.15 213.82,60.07 213.82,59.22 210.63,59.22 210.54,59.31 210.54,63.22 210.66,63.33 212.11,63.33 212.2,63.24 212.2,62.41 212.96,62.41 213.03,62.48 213.03,63.35 213.36,63.35
NVVDD_UG1 on BOTTOM (solid shape): 210.04,54.43 210.04,53.12 209.96,53.05 209.14,53.05 209.08,53.11 209.08,54.44 209.13,54.49 209.97,54.49
NVVDD_UG1 on BOTTOM (solid shape): 225.45,55.36 225.45,55.21 225.41,55.17 224.75,55.17 224.18,54.61 224.18,54.51 224,54.32 223.83,54.32 223.69,54.45 223.69,55.06 223.81,55.17 224.17,55.17 224.41,55.41 225.4,55.41
NVVDD_UG1 on IN3 (solid shape): 210.81,53.35 210.81,52.75 210.74,52.68 209.15,52.68 209.02,52.8 209.02,53.32 209.16,53.47 210.69,53.47
NVVDD_UG1 on IN3 (solid shape): 224.54,55.05 224.54,54.89 223.78,54.13 223.49,54.13 223.26,53.91 223.16,53.91 222.75,54.32 222.75,54.55 223.33,55.13 224.1,55.13 224.18,55.2 224.39,55.2
NVVDD_UG1_R on BOTTOM (solid shape): 208.46,54.52 208.46,53.64 208.43,53.62 206.55,53.62 206.41,53.75 206.41,54.3 206.46,54.35 207.6,54.35 207.77,54.53 208.45,54.53
NVVDD_UG2 on BOTTOM (solid shape): 202.17,54.35 202.17,53.1 202.09,53.03 201.27,53.03 201.21,53.09 201.21,54.18 201.21,54.18 201.21,54.42 201.27,54.48 202.04,54.48
NVVDD_UG2 on IN1 (solid shape): 202.19,53.39 202.19,52.01 202.19,52.02 202.19,52.04 202.12,51.97 201.58,51.97 201.07,52.48 201.07,53.33 201.22,53.48 202.11,53.48
NVVDD_UG2 on IN1 (solid shape): 230.76,55.37 230.76,55.04 230.61,54.89 230.33,54.89 229.85,54.4 229.85,53.87 229.77,53.79 229.16,53.79 229.06,53.9 229.06,54.79 229.77,55.5 230.64,55.5
NVVDD_UG2_R on BOTTOM (solid shape): 200.54,54.44 200.54,53.6 200.51,53.57 198.6,53.57 198.46,53.71 198.46,54.26 198.51,54.31 199.65,54.31 199.82,54.48 200.49,54.48
NVVDD_UG3_R on BOTTOM (solid shape): 216.37,54.22 216.37,53.38 216.35,53.36 215.79,53.36 215.52,53.63 214.51,53.63 214.38,53.77 214.38,54.32 214.43,54.37 216.22,54.37
QPCN on TOP (solid shape): 238.59,15.27 238.59,12.14 238.55,12.1 238.45,12.1 238.4,12.15 238.4,13.32 237.66,14.06 237.66,15.26 237.72,15.33 238.54,15.33
QPCP on TOP (solid shape): 239.86,15.22 239.86,13.97 239.77,13.88 239.48,13.88 238.98,13.39 238.98,12.13 238.95,12.1 238.83,12.1 238.8,12.13 238.8,15.18 238.89,15.28 239.8,15.28
