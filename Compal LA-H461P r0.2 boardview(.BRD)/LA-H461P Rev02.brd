# Allegro board LA-H461P Rev02.brd (continued)
## Nets (continued)
USB3_DPE_MTX_C_DRX_N2: CT282.1 DU2.2 DU2.9 JUSBC1.B3
USB3_DPE_MTX_C_DRX_P1: CT279.1 DU1.1 DU1.10 JUSBC1.A2
USB3_DPE_MTX_C_DRX_P2: CT281.1 DU2.1 DU2.10 JUSBC1.B2
USB3_DPE_MTX_DRX_N1: CT280.2 UT11.34
USB3_DPE_MTX_DRX_N2: CT282.2 UT11.36
USB3_DPE_MTX_DRX_P1: CT279.2 UT11.33
USB3_DPE_MTX_DRX_P2: CT281.2 UT11.37
USB3_PRX_C_MTX_N4: CT286.1 UT11.4
USB3_PRX_C_MTX_P4: CT285.1 UT11.5
USB3_PRX_DTX_N1: RS34.1 UH1.D11
USB3_PRX_DTX_N2: JIO1.13 UH1.B9
USB3_PRX_DTX_N3: JIO1.19 UH1.B10
USB3_PRX_DTX_P1: RS32.1 UH1.C11
USB3_PRX_DTX_P2: JIO1.14 UH1.C9
USB3_PRX_DTX_P3: JIO1.20 UH1.C10
USB3_PRX_MTX_N4: CT286.2 UH1.K16
USB3_PRX_MTX_P4: CT285.2 UH1.J15
USB3_PRX_R_DTX_N1: DS6.1 DS6.9 JUSB3.5 RS34.2
USB3_PRX_R_DTX_P1: DS6.2 DS6.8 JUSB3.6 RS32.2
USB3_PTX_C_DRX_N1: CS34.1 RS27.1
USB3_PTX_C_DRX_P1: CS29.1 RS28.1
USB3_PTX_C_MRX_N4: CT288.1 UT11.7
USB3_PTX_C_MRX_P4: CT287.1 UT11.8
USB3_PTX_DRX_N1: CS34.2 UH1.F9
USB3_PTX_DRX_N2: JIO1.10 UH1.C3
USB3_PTX_DRX_N3: JIO1.16 UH1.F11
USB3_PTX_DRX_P1: CS29.2 UH1.F7
USB3_PTX_DRX_P2: JIO1.11 UH1.D4
USB3_PTX_DRX_P3: JIO1.17 UH1.G12
USB3_PTX_MRX_N4: CT288.2 UH1.B14
USB3_PTX_MRX_P4: CT287.2 UH1.C14
USB3_PTX_R_DRX_N1: DS6.4 DS6.7 JUSB3.8 RS27.2
USB3_PTX_R_DRX_P1: DS6.5 DS6.6 JUSB3.9 RS28.2
USB20_N1: UH1.J3 US2.2
USB20_N1_C: DS5.2 JUSB3.2 LS9.3
USB20_N2: JIO1.23 UH1.N13
USB20_N3: JIO1.26 UH1.K4
USB20_N4: ML11.4 UH1.M10 UU4.53
USB20_N4_L: DU3.5 DU3.6 JUSBC1.A7 JUSBC1.B7 ML11.3
USB20_N5: L1.1 UH1.M1
USB20_N5_R: D507.3 JEDP1.10 L1.2
USB20_N6: TH146.1(TP-1) UH1.K7
USB20_N9: TH148.1(TP-1) UH1.M6
USB20_N14: JWLAN1.5 UH1.E5
USB20_P1: UH1.J2 US2.3
USB20_P1_C: DS5.3 JUSB3.3 LS9.2
USB20_P2: JIO1.22 UH1.N15
USB20_P3: JIO1.25 UH1.K3
USB20_P4: ML11.1 UH1.L9 UU4.50
USB20_P4_L: DU3.4 DU3.7 JUSBC1.A6 JUSBC1.B6 ML11.2
USB20_P5: L1.4 UH1.L2
USB20_P5_R: D507.2 JEDP1.9 L1.3
USB20_P6: TH145.1(TP-1) UH1.K6
USB20_P9: TH147.1(TP-1) UH1.N8
USB20_P14: JWLAN1.3 UH1.F6
USB_CHARGE_EN: RS16.1 UK1.36
USB_CHARGE_EN_R: RS16.2 US2.5
USB_CTL1: RS41.2 UK1.84 US2.6
USB_CTL2: RS42.2 UK1.72 US2.7
USB_CTL3: RK28.2 UK1.38 US2.8
USB_IN_STATUS#: RS43.2 UK1.108 US2.9
USB_OC0#: RH217.1 RS10.1 UH1.AH36
USB_OC1#: RH215.1 UH1.AL40
USB_OC2#: RH214.1 UH1.AJ44
USB_OC3#: RH216.1 UH1.AL41
USB_OC4#: RH218.1 UH1.AV47
USB_OC5#: RH219.1 UH1.AR35
USB_OC6#: RH220.1 UH1.AR37
USB_OC7#: RH221.1 UH1.AV43
USB_ON#: JIO1.27 UK1.121
VCIN0_PH: PH1.1 PR9.2 UK1.109
VCIN1_AC_IN: R4960.1 UK1.27
VCIN1_AC_IN_R: R4960.2 R5094.2 UK1.110
VCIN1_ACOK: PRB23.2 PRB25.1 PUB01.2 R5094.1
VCIN1_PH: PR10.2 PR13.1 UK1.102
VGA_ALERT: RG397.2 UG1.M2
VGA_CORE_EN: CG197.2 DG4.1 PRV14.2 RG105.2
VGA_GATE: CG46.1 QG1.5 UG8.4
VGA_I2CS_SCL: QG2.4 RG36.1 UG1.T4
VGA_I2CS_SDA: QG2.1 RG35.1 UG1.T3
VGA_OVERT#: QG1.4 RG396.2 UG1.M1
VR_HOT#: CK11.2 PRZ5.2 PRZ14.2 RK8.1
VR_ON: PRZ26.2 UK1.85
VR_PWRGD: PRZ18.2 PUZ1.45 UK1.71
VRAM_VDD_CTL: PRW12.1 PRW14.1 UG1.L3
VRAM_VREF_CTL: QG3.2 QG4.2 RG401.2 UG1.L1
VREF: CA19.1 CA20.1 UA1.38
VSN_1PH: PCZ1.2 PRZ10.2 PUZ1.51
VSN_2PH: PCZ15.1 PRZ32.1 PUZ1.37
VSN_4PH: PCZ13.2 PRZ28.2 PUZ1.2
VSP_1PH: PCZ7.2 PRZ12.2 PUZ1.52
VSP_2PH: PCZ14.1 PRZ31.1 PUZ1.38
VSP_4PH: PCZ12.2 PRZ25.2 PUZ1.1
VTTREF_DDR: PCM15.1 PUM1.4
WAKE#: QR2.1 QWL1.1 RH171.1 UH1.BB47
WL_OFF#: JWLAN1.48 RH180.2 UH1.AW24
WL_PWREN_EC#: RWL30.2 UK1.98
WL_WAKE#: JWLAN1.47 QWL1.3 RWL4.2
XCLK_BIASREF: RH20.2 UH1.T3
XDP_BPM#0: TC295.1(TP-1) UC1.BR27
XDP_BPM#1: TC296.1(TP-1) UC1.BT27
XDP_BPM#2: TC101.1(TP-1) UC1.BM31
XDP_BPM#3: TC100.1(TP-1) UC1.BT30
XDP_ITP_PMODE: RC383.2 UH1.AL3
XDP_PRDY#: UC1.BP27 UH1.AM5
XDP_PREQ#: UC1.BL30 UH1.AL2
XGND: RL55.1 TSL1.25
XTAL_24M_PCH_IN: CH5.1 RH16.2 RH18.1 YH1.1
XTAL_24M_PCH_IN_R: RH18.2 UH1.U10
XTAL_24M_PCH_OUT: CH4.1 RH16.1 RH17.1 YH1.3
XTAL_24M_PCH_OUT_R: RH17.2 UH1.U9
XTAL_OUTBUFF: RG9.1 UG1.J4
XTAL_SSIN: RG11.1 UG1.H1
XTALIN: CG2.1 UG1.H3 YG1.3
XTALOUT: RG80.2 UG1.H2
XTALOUT_R: CG1.1 RG80.1 YG1.1
XTLI: CL25.2 RL7.2 UL1.28 YL1.1
XTLO: CL24.2 RL7.1 RL57.2 YL1.3
XTLO_R: RL57.1 UL1.29
N15156561: PCV26.1 PCV92.1 PCV93.1 PRV27.2 PUV2.8
N15160747: PCV18.1 PRV16.1 PRV18.2
N16789346: TC55.1(TP-1) UC1.BP1
N16789364: TC57.1(TP-1) UC1.B38
N16789382: TC59.1(TP-1) UC1.B2
N16789430: TC25.1(TP-1) UC1.E2
N16789448: TC26.1(TP-1) UC1.E1
N16789466: TC24.1(TP-1) UC1.D1
N16789484: TC27.1(TP-1) UC1.BR1
N16865170: TC94.1(TP-1) UC1.AU13
N16865242: TC95.1(TP-1) UC1.AY13
N16884472: TC51.1(TP-1) UC1.C38
N16884473: TC52.1(TP-1) UC1.C1
N16884474: TC53.1(TP-1) UC1.BR2
N16884482: TC29.1(TP-1) UC1.BT2
N16886077: TH1.1(TP-1) UH1.Y14
N16886097: TH2.1(TP-1) UH1.Y15
N16889098: TH4.1(TP-1) UH1.U35
N16889099: TH5.1(TP-1) UH1.N32
N16889100: TH6.1(TP-1) UH1.R32
N16889101: TH7.1(TP-1) UH1.AH15
N16889102: TH8.1(TP-1) UH1.AH14
N16889103: TH3.1(TP-1) UH1.U37
N16892256: TH11.1(TP-1) UH1.AN35
N16892639: TH19.1(TP-1) UH1.AW48
N16925558: TH74.1(TP-1) UH1.BE33
N16937432: CWL1.1 JWLAN1.6 RWL3.1
N16940119: TH122.1(TP-1) UH1.AL15
N16957386: C407.1 U11.6
N16995670: PCV16.1 PRV7.2 PRV10.2 PRV11.1
N16995962: PRV29.2 PUV1.16
N17092107: PRV13.2 PRV15.1
N17105073: TH101.1(TP-1) UH1.AL35
N17435076: QH2.1 RH117.2
N17571862: PCW5.1 PQW3.2 PRW14.2
N17571879: PQW3.1 PRW8.2
N17571903: PRW7.2 PRW9.2 PRW10.1 PRW15.1
N17572010: PCW2.1 PRW2.2
N17572050: PCW4.2 PRW7.1
N17572133: PRW3.1 PRW16.1 PUW1.5
N17825974: TH4942.1(TP-1) UH1.AH47
N17825990: TH4943.1(TP-1) UH1.AH48
N18049479: TH4954.1(TP-1) UH1.BB24
N18049493: TH4956.1(TP-1) UH1.AP24
N18049500: TH4957.1(TP-1) UH1.BA24
N18051110: TH4968.1(TP-1) UH1.AV6
N18051113: TH4969.1(TP-1) UH1.AR13
N18402678: QG7.5 QG7.6 RG106.2
N19357453: QWL3.1 RWL7.1 RWL30.1 RWL31.2
N19377972: QWL2.2 RWL7.2
N19897204: PQ1.2 PQ2.5 PQ2.6 PR18.2 PR20.1
N19897238: PQ2.3 PR19.2
N20648577: PC1010.1 PU1001.16 PU1001.17
N20648709: PC1008.2 PR1020.1
N21429485: PCH6.2 PRH6.1
N21761451: CV49.1 RV48.2
N21819668: QV7.6 RV52.2
N21917236: PCZ1.1 PCZ4.2 PRZ9.2 PRZ10.1
N21917296: PCZ4.1 PRZ11.2 PRZ12.1 PRZ16.1
N21981722: PDB02.2 PRB17.2
N21981818: PDB02.3 PRB43.2
N22086953: PHZ5.1 PRZ75.2 PRZ78.1
N22096717: PHZ4.1 PRZ74.2 PRZ77.1
N22407346: PLZ2.3 PRZ84.1
N22407630: PLZ1.3 PRZ81.1
N22480039: PLZ3.3 PRZ87.1
N22480324: PLZ4.3 PRZ90.1
N22481576: PCA7.1 PRA3.2
N22481729: PLG1.3 PRG3.1
N23058063: QG55.2 RG114.1 UG28.4
N23083473: PJPB1.7 PR21.1
N23083645: PJPB1.5 PR14.1
N23083647: PJPB1.8 PR17.1
N23083649: PJPB1.6 PR15.1
N23235753: PQ1.1 PR22.2 PR24.2
N23773631: RV19.1 UV2.35
N24329755: RR10.1 UR1.9
N24329881: RR11.1 UR1.28
N24337743: CA29.1 RA19.2 RA20.1
N24338104: QA2.2 RA25.2
N24338139: RA56.2 UA1.4
N24626028: CD82.2 RD29.2
N24676202: PQB02.2 PRB01.2 PRB02.1
N25261682: QC11.5 RH252.1
N25355771: R5798.1 U9.2
N25359800: CS108.1 QS1.6 RS39.1 US3.4
N25359816: RS10.2 US2.13
N25359920: RS14.2 US2.16
N25359932: RS13.2 US2.15
N25488166: CG335.1 UG27.12
N25488171: CG336.1 UG27.10
N25488216: QG17.6 RG391.1
N25528173: QG56.2 RG395.1 UG29.4
N25943161: CD15.2 RD11.2
N26573576: RG404.2 UG1.AD6
N26746335: R5807.2 U12.3
N26747017: R5804.1 U12.5
N26747180: R5806.1 U12.4
N27182711: PCZ22.1 PRZ42.2
N27734948: T165.1(TP-1) UU4.21
N27734950: T166.1(TP-1) UU4.22
N27734952: T167.1(TP-1) UU4.23
N27734954: T162.1(TP-1) UU4.31
N27734984: T155.1(TP-1) UU4.42
N27734986: T156.1(TP-1) UU4.43
N27734988: T158.1(TP-1) UU4.49
N27734990: T161.1(TP-1) UU4.48
N27735020: T154.1(TP-1) UU4.41
N27735022: T153.1(TP-1) UU4.40
N27735038: T159.1(TP-1) UU4.54
N27735040: T160.1(TP-1) UU4.55
N27740851: UU4.8 UU4.15 UU4.19 UU4.58
N27779968: D513.1 JSSD1.10
N27801570: UU4.7 UU4.52 UU4.56 UU4.57
N28152235: PCZ14.2 PCZ15.2 PRZ32.2 PRZ33.1
N28152401: PCZ31.2 PRZ55.2 PUZ1.15
N28152437: PCZ18.2 PRZ37.2 PUZ1.3
N28152465: PCZ23.1 PRZ40.1 PUZ1.36
N28152469: PRZ57.1 PUZ1.24
N28152784: PCZ33.1 PRZ56.2 PUZ1.16
N28152958: PHZ1.2 PRZ46.2 PRZ50.1
N28153073: PHZ2.2 PRZ2.1
N28153589: PRZ26.1 PUZ1.43
N28153954: PCZ19.1 PRZ38.2
N28154016: PCZ12.1 PCZ13.1 PRZ27.2 PRZ28.1
N28154283: PHZ3.2 PRZ45.2 PRZ49.1
N28180064: PCZ10.1 PRZ22.2
N28185893: PCZ20.1 PRZ39.2
N28185971: PCZ17.1 PRZ35.2
N28452300: RV135.1 UC3.4
N28452491: RV136.2 UC3.6
N28587479: RA55.1 UA1.5
N28622063: D517.2 U4019.3
N28622074: R125.1 U4019.6
N28622080: Q32.1 R13.1 U4019.7
N28622090: R124.1 U4019.2
N28781721: QG16.1 RG40.2
N29227301: PCZ7.1 PRZ16.2
N41203682: CC392.1 UC4.12
N41203729: CC393.1 UC4.10
N52218840: PRZ47.2 PUZ1.27
N64749181: RV18.1 UV2.36
N64766033: RV11.2 UV2.37
N65230032: RV31.2 RV33.1 UV3.6
N80922351: PCF1.2 PJF1.2 PUF1.4
N80922387: PCF6.1 PRF3.2
N99531586: JKB1.29 R5238.2
N99531588: JKB1.28 R5237.2
N100118189: CL2.2 DL1.3 RL58.2 RL59.2 RL60.2 RL61.2
N104325131: JWLAN1.42 RWL5.1
N108444806: C404.1 U10.10
N108444906: C403.1 U10.12
N113120205: RG5.1 UG1.R2
N113120207: RG6.1 UG1.R3
N113123308: RG14.2 RG99.2 UG2.4
N113204452: RG59.1 UG4.J1
N113204609: RG57.1 UG4.J10
N113204711: RG60.1 UG5.J10
N113205003: RG55.2 UG5.J1
N113272266: RG73.1 UG6.J10
N113272493: RG75.1 UG6.J1
N113273868: RG71.1 UG7.J10
N113274261: RG69.2 UG7.J1
N121190088: RG86.1 UG1.R7
N121190090: RG85.1 UG1.R6
N121269248: CG190.1 RG63.2 RG95.2
N121271262: CG191.1 RG62.2 RG96.2
N121271857: CG192.1 RG97.2 RG98.2
N121272457: CG193.1 RG76.2 RG77.2
N121863790: QG8.5 QG8.6 RG111.2
N125363899: RG381.2 UG1.AF8

Pads without a net: D3 2; DV1 5 6; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 162 165; JEDP1 19 26 37; JHDD1 4 5; JHDMI1 13 14; JKB1 30 31; JPWR1 6; JSSD1 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 59 60; JWLAN1 8 12 13 16 19 20 34 36 38 40 50 52 54 58 60 62; PJP1 7; PU301 10 15; PU1001 9 10 12; PU1801 5; PUB01 8; PUH1 9 10 12; U9 11; U4019 5; UA1 1 6 7 8 9 10 11 12 29 35 36; UC1 A19 A21 A23 A25 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AJ8 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AP14 AP29 AT3 AT5 AT7 AT11 AT13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 B18 B19 B20 B21 B22 B23 B24 B25 B27 B30 B33 B34 B36 BA1 BA2 BA3 BA4 BA5 BH30 BJ28 BK28 BL31 BL34 BM19 BN22 BN23 BN27 BN28 BN33 BN35 BP19 BP22 BP23 BR19 BR22 BR23 BR31 BR35 BT19 BT22 BT23 C18 C20 C22 C24 C30 C33 C34 D19 D21 D23 D25 D27 D34 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E30 E33 E36 E37 F18 F20 F22 F24 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; UC2 1; UG1 A9 A26 A27 A30 AC6 AC28 AD4 AD5 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF30 AF32 AG1 AG7 AG10 AG12 AG20 AG23 AG26 AH6 AH8 AH9 AH20 AH23 AH31 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ20 AJ21 AJ23 AJ24 AJ26 AJ28 AJ31 AJ32 AJ33 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK20 AK21 AK22 AK23 AK24 AK25 AK26 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AL22 AL25 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM21 AM23 AM24 AM26 AM27 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AN21 AN23 AN24 AN26 AN27 AP3 AP5 AP6 AP8 AP9 AP20 AP21 AP23 AP24 AP26 AP27 B2 B6 B23 C6 C15 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F26 G14 G20 H6 H30 H31 J30 J31 J32 J33 K3 K4 L2 M4 M5 M6 M30 M34 N4 N8 P1 P2 P3 P8 R4 R5 R28 V32; UG4 A5 A10 U5 U10; UG5 A5 A10 U5 U10; UG6 A5 A10 U5 U10; UG7 A5 A10 U5 U10; UH1 A17 A22 A25 A42 A44 AA1 AA45 AB48 AC6 AC7 AC9 AC11 AC14 AC15 AC39 AC41 AC43 AC44 AC48 AD47 AD48 AE9 AE11 AE39 AE41 AE44 AE47 AE48 AF47 AF48 AG45 AH41 AH46 AJ6 AJ7 AK47 AM7 AM43 AM46 AM48 AN4 AN18 AN37 AN40 AN47 AP2 AP3 AP21 AP41 AP47 AP48 AR18 AR42 AR48 AT10 AU46 AU47 AV7 AV13 AV16 AV18 AW2 AW3 AW15 AW18 B15 B17 B18 B19 B21 B23 B24 B25 B26 B27 B42 B44 BA20 BB16 BB20 BC1 BC17 BC33 BD8 BD17 BD34 BD38 BE8 BE9 BE14 BE15 BE17 BE18 BE19 BE29 BE34 BF8 BF9 BF14 BF17 BF18 BF19 BF29 BF31 BF32 BF36 BG8 C15 C16 C17 C18 C19 C20 C21 C23 C24 C26 C27 C42 C44 D20 D21 D29 D42 D43 E28 F14 F16 F20 F24 F26 F46 G1 G2 G4 G5 G14 G17 G20 G24 G26 G45 G46 G47 G48 G49 H2 H3 H47 H48 J13 J18 J21 J24 K13 K18 K21 K29 K43 K44 L3 L4 L24 L26 L46 L47 L48 M26 M29 M44 M45 N2 N3 N18 N42 N47 N48 P9 P21 P24 P41 P47 P48 R10 R13 R15 R18 R21 R24 R35 R37 R40 R44 R46 T1 T2 T43 T45 T46 U2 U3 U13 U40 U41 U47 U48 V2 V3 V47 V48 W3 W4 W6 W7 W43 W44 W46 W47 Y2 Y35 Y36 Y40 Y41 Y46 Y47 Y48; UK1 125; UL2 3; UR1 13 22 23 24 25 26 31; UT1 3 4 5 10 11 12 13 15 25 26 27 28 29 30 31; UU4 29; UV1 5; UV2 2 4 9 10 12 25 26; UV3 5; YG1 2 4; YL1 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 720 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8362 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 208 vias
v4: diameter 0.757, hole 0.378, TOP to BOTTOM, 103 vias
v5: diameter 0.884, hole 0.442, TOP to BOTTOM, 17 vias
v6: diameter 0.508, hole 0.254, TOP to BOTTOM, 69 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VSDGP_ON:
  vias: v1(179.37,101)
1.0VSDGPU_EN: length 125.2
  TOP w0.127: v2(238.52,46.18) v3(239.18,46.18)
  IN1 w0.127: v2(178.82,104.09) 178.92,103.99 182.13,103.99 v2(188.23,97.89) ; v2(238.52,46.18) 238.64,46.18 239.02,46.55 239.02,47.67 238.15,48.54 237.76,48.54 236.65,47.44 234.59,47.44 233.99,46.84 v2(232.1,46.84)
  IN3 w0.127: v2(232.1,46.84) 232.09,46.85 231.58,46.85 231.21,46.48 231.21,44.42 230.23,43.44 224.88,43.44 222.24,46.08 210.09,46.08 204.23,51.95 201.39,51.95 200.81,52.52 195.44,52.52 192.85,55.12 192.85,68.61 193.96,69.72 193.96,70.21 194.42,70.67 194.42,76.81 195.6,78 195.6,82.99 196.07,83.46 196.07,83.97 197.16,85.06 197.16,86.24 196.91,86.49 195.29,86.49 195.06,86.72 191.4,86.72 189.28,88.84 189.28,92.86 187.87,94.27 187.87,97.53 v2(188.23,97.89)
  BOTTOM w0.127: DG5.2 238.77,43.25 239.05,43.54 RG103.2 CG196.2 239.05,45.65 v2(238.52,46.18) ; PRF1.1 v2(178.82,104.09)
1.8VSDGPU_MAIN: length 11.5
  BOTTOM w0.127: RG108.2 235.7,46.57 235.67,46.53 UG10.1 ; RG108.2 235.23,47.41 233.89,47.41 232.95,46.47 232.95,43.66 231.73,42.45 231.52,42.45 231.12,42.06 QG7.3 ; RG108.2 235.71,46.94 236.14,47.37 236.53,47.37 v1(236.67,47.23)
1.8VSDGPU_MAIN_EN: length 87.7
  TOP w0.102: 214.48,74.07 214.11,74.44 214.11,74.74 213.59,75.26 211.91,75.26 210.43,76.73 210.43,77.46 210.3,77.6 210.3,78.13 209.6,78.83 209.6,79.81 209.81,80.03 209.81,80.72 v2(209.44,81.1)
  TOP w0.127: v2(224.53,62.06) 224.37,61.91 RG403.2 223.91,62.12 224.25,62.45 225.36,62.45 226.27,63.36 226.27,67.08 222.86,70.48 219.15,70.48 218.93,70.71 v3(218.03,70.71) 216.52,70.71 214.48,72.75 214.48,74.07
  IN1 w0.127: v2(224.53,62.06) 225.24,62.06 227.09,60.21 232.45,60.21 234.05,58.62 236.03,58.62 v2(237.04,57.61)
  BOTTOM w0.127: QG7.2 229.8,42.33 230.11,42.64 231.34,42.64 231.41,42.71 231.62,42.71 232.68,43.77 232.68,46.58 235.29,49.19 ; 235.29,49.19 235.84,49.19 237.32,47.71 238.4,47.71 239.5,46.6 239.5,43.43 239.02,42.95 239.02,42.19 239.43,41.78 239.43,38.88 239.72,38.59 241.94,38.59 242.24,38.89 242.24,39.72 242.6,40.08 243.04,40.08 RG179.2 ; 235.29,49.19 235.29,50.2 235.44,50.34 235.44,53.71 236.51,54.77 236.51,55.48 237.25,56.22 237.25,57.4 v2(237.04,57.61) ; UG1.P7 v2(209.44,81.1)
  BOTTOM w0.203: UG27.5 243.62,41.09 243.32,40.79 RG179.2
1.35VS_DGPU_EN: length 3.9
  BOTTOM w0.254: PRW5.1 PRW6.1 240.73,57.86 241.44,57.15 PCW1.1 241.45,56.96 v2(241.45,56.32) PUW1.3
1.35VS_DGPU_FB: length 6.3
  BOTTOM w0.254: PUW1.4 241.95,55.8 v2(242.79,56.64) 243.78,56.64 244,56.87 PRW11.1 243.18,57.29 PCW4.1 PRW10.2 242.27,57.31 242.21,57.31 PRW8.1
1.35VSDGPU_PWR_EN: length 9.6
  TOP w0.127: v2(238.95,58.68) v3(238.95,57.9) 238.95,56.93 237.62,55.59 237.62,52.17 RG12.1 237.31,51.86 237.31,51.51 DG3.1
  BOTTOM w0.127: PRW5.2 v2(238.95,58.68)
1V8_AON_EN_R: length 3.9
  BOTTOM w0.127: UG27.3 244.42,41.18 v2(244.9,40.69) 245.17,40.43 CG269.1 245.86,39.87 DG1.1 245.95,38.89 RG148.2
1VSDGPU_PG: length 121.3
  TOP w0.127: DG3.3 238.82,49.36 v1(238.82,48.07) 238.82,46.98 v2(238.6,46.76)
  IN2 w0.127: v2(238.6,46.76) 237.78,46.76 237.2,47.34 235.99,47.34 235.59,46.94 232.7,46.94 232.29,47.35 231.33,47.35 231.17,47.5 223.69,47.5 220.77,50.41 194.94,50.41 190.97,54.38 190.97,69.2 190.65,69.53 190.65,73.42 189.79,74.29 189.79,77.57 v2(190.15,77.92) ; v2(180.9,79.8) 180.79,79.92 180.79,88.52 175.25,94.06 175.25,102.25 v6(174.1,103.41)
  BOTTOM w0.127: PUF1.5 174.84,102.53 PRF2.2 174.2,103.52 v6(174.1,103.41) ; v2(190.15,77.92) 188.93,76.71 186.24,76.71 185.44,75.91 UG11.1 185.44,75.81 185.05,75.41 183.3,75.41 180.9,77.81 v2(180.9,79.8)
3V_FB: length 1.8
  BOTTOM w0.254: PC312.1 252.32,29.83 252.06,30.09 PU301.13
3V_FB_1: length 1.9
  BOTTOM w0.127: PR304.1 253.77,28.85 v1(254.59,28.85)
  BOTTOM w0.254: PC312.2 253.63,29.83 PR304.1
3V_SN: length 1.3
  BOTTOM w0.508: PR302.2 250.12,21.21 PC311.1
5V_3V_EN: length 208.1
  IN2 w0.127: v2(255.18,29.16) 254.49,29.16 252.15,31.5 247.02,31.5 246.33,32.19 242.68,32.19 241.82,33.05 230.28,33.05 221.84,24.61 221.84,22.88 220.15,21.18 218.25,21.18 217.7,20.64 215.75,20.64 213.78,18.67 210.31,18.67 209,17.36 209,15.92 208.05,14.96 197.85,14.96 197.68,14.79 194.16,14.79 192.92,13.56 190.62,13.56 190.01,12.95 187.83,12.95 187.07,13.71 183.28,13.71 182.36,14.63 182.36,16.09 181.26,17.2 169.26,17.2 168.38,16.32 154.53,16.32 152.27,14.07 151.97,14.07 150.99,13.09 145.9,13.09 145.31,12.5 133.08,12.5 132.43,13.15 126.07,13.15 124.42,11.51 119.45,11.51 118.9,12.06 110.24,12.06 109.49,12.82 101.8,12.82 98.64,15.97 79.5,15.97 v2(79.37,15.84)
  BOTTOM w0.127: v2(79.37,15.84) 79.16,15.84 v1(78.37,15.04) 78.15,15.04 76.39,13.27 76.39,11.33 75.63,10.57 PU302.6 ; PU301.12 251.58,30.54 251.73,30.69 PC328.1 253.39,30.69 PR313.1 253.53,30.55 PR311.2 PR310.2 254.62,29.72 v2(255.18,29.16)
5V_FB: length 2.3
  BOTTOM w0.254: PC327.1 76.98,11.8 76.98,11.3 v2(76.79,11.12) 76.74,11.12 76.08,10.46 PU302.7
5V_FB_1: length 1.9
  BOTTOM w0.127: v1(77.67,13.73) 77.82,13.57 PR312.1
  BOTTOM w0.254: PC327.2 77.82,12.73 PR312.1
5V_SN: length 2.8
  TOP w0.127: PC325.1 v1(69.98,9.33)
  TOP w0.508: PC325.1 69.98,6.5 PR307.2
+0.6V_A_VREFDQ: length 4.4
  BOTTOM w0.102: UC1.BP13 128.57,90.54 128.2,90.17 127.18,90.17 126.98,90.37 126.12,90.37
  BOTTOM w0.135: TC286.1 124.85,90.37 126.12,90.37
+0.6V_B_VREFDQ: length 124.6
  TOP w0.508: RD27.2 139.89,28.16 CD82.1 139.24,28.5 138.89,28.15 134.53,28.15 133.72,27.34 122.41,27.34 v2(121.81,27.94)
  IN1 w0.508: v2(121.81,27.94) 120.94,28.81 117.58,28.81 117.22,29.17 102.37,29.17 98.56,32.98 98.56,35.43 99.56,36.44 99.56,42.08 98.03,43.62 98.03,45.49 97.06,46.46 97.06,52.11 100.01,55.06 100.01,63.31 109.58,72.88 109.58,74.9 110.15,75.47 110.15,79.99 arc(110.67,82.57) 112.13,84.76 114.24,86.88 115.44,86.88 119.2,90.63 120.11,90.63 122.62,93.14 125.4,93.14 126.75,91.79 v2(126.75,91.74)
  BOTTOM w0.254: UC1.BR13 127.55,90.93 127.08,90.93 126.81,91.2 126.81,91.68 v2(126.75,91.74)
+0.6V_DDR_VREFCA: length 8
  TOP w0.381: RD8.1 RD9.1 145.52,42.42 RD10.2 146.28,42.44 CD14.2 CD11.2 147.07,41.5 CD12.2 146.68,40.79 146.15,40.25 v2(145.85,40.25)
  BOTTOM w0.356: v2(145.85,40.25) 146.31,40.25 146.77,40.72 JDIMM1.164
+0.6V_DDRB_VREFCA: length 10.9
  TOP w0.381: v2(145.9,31.17) 145.9,31.17 v1(145.52,30.79) 145.52,30.65 145.24,30.38 CD70.2 144.81,29.69 CD69.2 CD72.2 144.89,28.44 144.44,27.99 143.35,27.99 142.83,28.51 RD28.2 142.8,28.85 RD26.1
  TOP w0.508: RD27.1 140.39,29.08 CD81.2 141.58,29.08 141.81,28.85 RD26.1
  BOTTOM w0.305: v2(145.9,31.17) 145.9,31.17 145.67,30.94 145.67,30.92 145.28,30.53 JDIMM2.164
+0.6V_VREFCA: length 140.1
  TOP w0.508: v2(128.91,90.94) 128.91,90.59 129.3,90.21 CD15.1 ; v2(144.1,40.16) 143.76,40.16 143.39,40.52 143.39,41.93 143.9,42.44 RD9.2
  IN1 w0.508: v2(128.91,90.94) 128.79,91.06 126.47,91.06 125.18,92.35 122.74,92.35 120.38,89.99 119.46,89.99 115.71,86.23 114.51,86.23 112.58,84.31 arc(111.26,82.33) 110.8,79.99 110.8,73.19 100.65,63.04 100.65,54.8 97.7,51.85 97.7,46.73 98.67,45.76 98.67,43.88 100.21,42.35 100.21,33.59 99.75,33.14 99.75,32.69 102.64,29.81 117.49,29.81 117.85,29.45 121.21,29.45 v2(122.71,27.95)
  IN3 w0.508: v2(122.71,27.95) 124.75,29.99 125.71,29.99 127.05,31.34 127.05,37.02 131.52,41.48 138.06,41.48 139.39,40.16 v2(144.1,40.16)
  BOTTOM w0.254: UC1.BN13 v2(128.91,90.94)
+0.6VS_VTT: length 78.4
  TOP w0.127: v3(171.73,42.52) 172.17,42.52 172.93,41.76 CD8.1
  IN2 w1.524: 167.25,36.89 166.53,37.61 158.66,37.61 158.52,37.75 151.07,37.75 150.75,37.44 142.62,37.44 141.97,36.79 127.33,36.79 126.64,37.48 101.48,37.48 96.87,32.87
  BOTTOM w0.305: 170.58,40.63 170.27,40.94 JDIMM1.258
  BOTTOM w0.381: v2(171.73,41.27) 171.79,41.22 v2(171.79,40.63) 170.58,40.63
  vias: v2(95.33,32.92) v2(95.33,32.28) v2(95.33,31.65) v2(169.31,31.27) v2(169.76,31.6) v2(170.13,32.02)
+0.6VSP: length 3.2
  BOTTOM w0.203: 94.63,27.71 94.37,27.45 93.88,27.45 93.78,27.35 PUM1.2 ; 93.65,29 92.61,29 92.45,28.84 PUM1.20
  vias: v1(94.32,28.66)
+0.95VS_VCCIO: length 52.5
  TOP w0.381: RC1.2 165.15,105.36 165.67,105.87 168.12,105.87 170.26,108.01 v6(170.97,108.01)
  TOP w0.508: CC35.1 162.8,94.95 v2(162.97,95.12)
  IN1 w0.381: 162.39,91.06 161.4,90.07 150.88,90.07 150.47,90.47 149.76,90.47 v2(149.24,89.96)
  IN1 w0.508: v2(174.68,83.16) 174.92,83.4 174.92,85.14 169.33,90.73 168.17,90.73 167.59,91.3 167.59,93.74 167,94.33 164.9,94.33 164.32,93.76 v2(164.32,93.55)
  BOTTOM w0.254: UC1.G17 v2(164.32,93.55) ; UC1.H19 v2(163.62,95.12) ; UC1.AG12 149.07,89.96 v2(149.24,89.96) ; v2(162.97,95.91) 162.66,96.22 UC1.J20 ; UC1.H21 v2(163.62,96.7) ; UC1.H17 v2(163.62,93.55) ; v2(163.62,95.91) 163.31,96.22 UC1.H20 ; v2(164.32,96.7) 164.01,97.07 UC1.G21 ; UC1.J19 v2(162.97,95.12) ; UC1.J21 v2(162.97,96.7)
  BOTTOM w0.406: v2(174.68,83.16) 174.68,82.84 171.24,79.4 RC9.1
  vias: v2(162.12,100.07) v2(162.12,99.43) v2(162.13,96.67) v2(162.13,95.91) v2(162.13,95.15) v2(162.13,93.62) v2(162.13,92.73) v3(162.65,98.83) v6(170.35,108.64) v6(170.99,108.64) v6(171.61,108.63) v6(171.62,107.99) v6(171.68,107.38) v6(172.26,108.53) v6(172.27,107.89) v6(172.29,107.27) v6(172.89,108.54) v6(172.9,107.9) v6(172.92,107.28)
+0.95VS_VCCIOP: length 6.5
  BOTTOM w0.127: 174.6,109.54 174.41,109.54 v1(172.95,111)
  BOTTOM w0.203: PRH4.1 180.29,105.25 PCH6.1 179.88,105.29 177.78,107.39
+1.0VSDGPU: length 94.9
  IN2 w0.508: 190.89,86.6 190.37,86.08 190.37,84.47 189.54,83.65 189.54,78.01 189.33,77.79 189.33,73.41 189.83,72.91 189.83,71.04 189.5,70.71 189.5,69.87 190.51,68.85 190.51,54.12 194.68,49.95 215.99,49.95 222.17,43.77 238.12,43.77 238.95,42.94 238.95,41.53 v2(238.98,41.5)
  BOTTOM w0.254: v2(197.64,81.1) 197.97,81.44 UG1.AG8 ; UG1.AC8 201.43,81.44 v2(201.06,81.07) UG1.AC7
  BOTTOM w0.305: UG1.AG9 UG1.AG8
  BOTTOM w0.356: UG1.AF6 198.59,80.18 198.59,80.2 ; UG1.AG24 198.08,94.88 v2(198.46,95.26) ; UG1.AH25 197.28,95.69 v2(197.65,95.32) ; 198.59,80.2 UG1.AG6 ; 198.59,80.2 v2(198.59,80.23)
  BOTTOM w0.508: RG391.2 238.63,40.43 238.98,40.78 v2(238.98,41.5)
  vias: v2(197.68,92.81) v2(198.46,96.12) v2(198.57,92.6) v2(198.82,91.81) v2(198.87,93.13) v2(198.92,90.54) v2(199.06,91.16) v3(198.3,92.09) v6(183.01,97.52) v6(183.04,96.91) v6(183.06,96.3) v6(183.65,96.89) v6(183.67,97.55) v6(183.67,96.24)
+1.0VSDGPUP: length 12.6
  IN3 w0.254: v2(181.6,98.23) 180.62,99.21 180.62,103.68 v2(179.31,105)
  BOTTOM w0.127: v1(177.27,95.44) 177.88,95.44 178.93,96.49 PLF1.2
  BOTTOM w0.305: PRF4.1 177.76,104.26 PCF2.1 178.56,105 v2(179.31,105)
+1.2V_HDMI: length 7.3
  BOTTOM w0.135: UV2.46 24.46,57.62 v2(24.14,57.3) ; v2(25.74,57.36) 25.66,57.43 UV2.43
  BOTTOM w0.191: UV2.11 22.29,63.08 22.15,63.22 22.15,63.77 22.32,63.94 v2(22.69,63.94)
  BOTTOM w0.203: UV2.30 29.71,61.48 v2(29.88,61.64) ; UV2.6 v2(21.97,61.08) ; UV2.18 v2(25.66,65.1) ; v2(24.46,65.1) UV2.15
  vias: v3(21.19,62)
+1.2V_VCCPLL_OC: length 52.9
  TOP w0.381: CC37.1 131.62,90.41 v2(131.88,90.16) ; v2(163.67,88.83) 163.71,88.87 CC36.1
  TOP w0.508: RC375.2 RC374.2 CC401.1 v3(120.87,90.78) 121.97,90.78 123.04,91.85 124.88,91.85 125.26,91.47 v2(125.26,91.21)
  IN1 w0.381: v2(131.88,90.16) 128.51,90.16 128.15,90.52 126.12,90.52 125.44,91.21 v2(125.26,91.21)
  IN2 w0.381: v2(132.77,90.04) 133.79,90.04 134.73,90.98 141.46,90.98 141.69,91.21 142.35,91.21 143.59,89.96 145.39,89.96 146.18,90.75 150.14,90.75 150.8,90.09 163.17,90.09 163.67,89.59 v2(163.67,88.83)
  BOTTOM w0.254: UC1.BJ13 v2(131.88,90.16) UC1.BH13 v2(132.77,90.04) ; v2(163.67,88.83) 163.97,89.19 UC1.G11
+1.2V_VCCSFR_OC_OUT:
  vias: v1(117.11,88.36)
+1.2V_VDDQ: length 189.9
  TOP w0.254: 164.39,27.47 164.86,27.01 164.86,25.01 165.69,24.17 v2(165.69,23.59)
  TOP w0.305: v2(117.48,40.82) 117.18,41.12 CD31.1 ; CD25.1 131.65,40.9 131.71,40.83 v2(131.71,40.82) ; CD80.1 116.16,28.34 v2(115.88,28.06)
  TOP w0.381: CD90.1 143.97,38.53 144.1,38.66 v2(144.1,38.86) ; v2(144.1,39.49) 144.56,39.49 145.12,38.94 CD76.1 ; v2(139.43,51.66) 139.53,51.56 CD24.1 ; CD29.1 143.97,51.41 v2(144.05,51.48) ; RD26.2 142.07,29.84 v2(141.28,30.63)
  TOP w0.508: CD95.1 147.15,51.2 147.66,51.71 v2(148.42,51.71) ; v2(128.48,40.57) 128.29,40.57 127.72,41.14 CD16.1 ; CD75.1 v2(120.99,38.76) ; RD8.2 144.58,41.32 v2(144.1,40.84) ; CD92.1 134.45,51.59 v2(134.57,51.71) ; CD19.1 145.5,51.48 v2(145.52,51.51) ; CD91.1 142.58,51.46 v2(142.52,51.51) ; v2(131.44,51.62) 131.61,51.46 CD23.1
  IN2 w0.508: v2(101.66,31.93) 99.19,29.46 96.03,29.46 96,29.44 v2(92.41,29.44)
  BOTTOM w0.203: v2(92.41,29.44) 92.41,29.31 92.05,28.95 PUM1.19
  BOTTOM w0.254: v2(105.36,30.53) 105.28,30.44 JDIMM2.12 ; v2(145.85,40.84) 145.77,40.92 JDIMM1.160 ; v2(165.69,23.59) 166.37,23.59 167.53,24.76 172.03,24.76 176.58,20.2 180.34,20.2 183.24,17.3 183.85,17.3 183.96,17.41 185.28,17.41 185.32,17.37 RH39.2 ; v2(137.73,38.86) 137.53,38.65 JDIMM2.141 ; v2(105.62,40.79) 105.62,40.79 106.46,40.79 106.77,41.11 JDIMM1.12 ; v2(126.54,28.06) 126.28,28.33 JDIMM2.96 ; v2(163.58,40.05) 163.59,40.04 164.13,40.04 164.53,39.64 JDIMM2.241
  BOTTOM w0.305: v2(148.78,30.63) 148.78,30.62 JDIMM2.178 ; JDIMM1.241 166.02,51.82 v2(165.8,52.04) ; v2(137.37,52.22) 136.91,52.22 136.02,51.33 JDIMM1.129 ; v2(137.73,38.86) 136.38,38.86 136.03,38.5 JDIMM2.135 ; v2(144.81,31.95) 144.81,30.96 144.28,30.42 JDIMM2.160 ; v2(113.09,52.58) 112.93,52.58 112.02,51.67 JDIMM1.33 ; JDIMM1.130 136.28,41.09 135.87,40.69 134.74,40.69 v2(134.68,40.75) 134.77,40.85 JDIMM1.124 ; JDIMM1.96 127.77,41.07 128.28,40.57 v2(128.48,40.57) ; v2(135.53,31.7) 135.93,31.29 135.93,30.74 136.28,30.4 JDIMM2.136 ; v2(137.37,51.59) 137.52,51.43 JDIMM1.135 ; JDIMM1.148 142.79,42.04 142.79,40.95 v2(142.65,40.82) ; v2(131.76,38.86) 131.76,38.86 132.72,38.86 133.03,38.55 JDIMM2.123 ; v2(131.76,38.86) 130.26,38.86 130.03,38.63 JDIMM2.111 ; v2(131.76,38.86) 131.53,38.63 JDIMM2.117 ; v2(144.1,40.84) 144.28,41.02 JDIMM1.154 ; v2(131.28,27.99) 131.47,27.99 131.78,28.3 JDIMM2.118 ; v2(159.39,27.99) 159.39,28.04 159.28,28.16 JDIMM2.220 ; JDIMM2.54 115.78,28.47 115.88,28.36 v2(115.88,28.06) ; v2(131.44,51.62) 131.53,51.54 JDIMM1.111 ; JDIMM2.129 134.53,38.71 v2(134.7,38.89) ; JDIMM1.118 133.27,40.67 133.83,40.12 v2(134.68,40.12) ; JDIMM1.220 160.77,41.06 160.38,40.67 v2(160.38,40.56) ; JDIMM2.147 141.03,38.53 140.65,38.91 v2(139.69,38.91) ; JDIMM1.159 v2(145.52,51.51) ; v2(142.52,51.51) JDIMM1.147 ; v2(154.63,51.75) 154.87,51.51 155.22,51.51 155.52,51.2 JDIMM1.199 ; JDIMM1.141 139.02,51.34 139.35,51.66 v2(139.43,51.66) ; JDIMM2.154 v2(142.78,30.66) ; JDIMM1.136 137.77,41.14 137.77,41.14 137.77,40.66 v2(137.73,40.62) 137.76,40.6 138.79,40.6 139.28,41.08 JDIMM1.142 ; v2(142.64,38.78) 142.53,38.67 JDIMM2.153 ; JDIMM1.153 144.02,51.46 v2(144.05,51.48) ; JDIMM1.163 146.52,51.13 146.83,51.43 147.63,51.43 147.91,51.71 v2(148.42,51.71) ; v2(109.42,39.43) 109.7,39.43 110.53,38.6 JDIMM2.33 ; JDIMM1.117 133.02,51.14 133.6,51.71 v2(134.57,51.71) 134.53,51.66 JDIMM1.123 ; v2(124.52,52.12) 122.98,52.12 122.53,51.67 JDIMM1.75 ; v2(149.84,40.53) 150.28,40.96 JDIMM1.178 ; v2(130.42,28.05) 130.28,28.19 JDIMM2.112 ; JDIMM2.163 145.03,38.97 144.51,39.49 v2(144.1,39.49) ; v2(144.1,38.86) 144.1,38.66 144.03,38.58 JDIMM2.159 ; v2(120.99,38.76) 121.03,38.72 JDIMM2.75 ; JDIMM2.130 134.78,28.33 134.47,28.02 v2(133.53,28.02) 133.28,28.28 JDIMM2.124 ; JDIMM2.199 154.03,38.59 v2(153.43,39.19) ; JDIMM1.112 131.77,40.88 v2(131.71,40.82) ; v2(141.28,30.63) JDIMM2.148 ; JDIMM1.54 117.27,41.02 v2(117.48,40.82)
  BOTTOM w0.33: JDIMM2.142 137.78,30.45 v2(137.92,30.59)
  BOTTOM w0.508: v2(107.57,72.56) 106.63,73.5 106.63,73.99 108.01,75.36 118.41,75.36 121.21,78.17 121.21,81.77 119.56,83.42 119.56,84.71 119.64,84.79 CC41.2 119.64,85.71 119.95,86.03 UC2.5
  vias: v2(98.53,39.3) v2(98.53,38.54) v2(98.53,37.8) v2(98.53,37.02) v2(98.94,38.92) v2(98.95,38.17) v2(98.93,37.41) v2(107.11,71.27) v2(107.17,72.11) v2(107.5,71.67) v2(107.9,72.06) v2(108.13,72.99) v2(108.29,72.46) v2(108.69,72.85) v2(137.73,39.42) v3(161.63,54.33)
+1.2V_VDDQ_CPU: length 19.5
  BOTTOM w0.203: v2(154.74,89.39) 154.6,89.39 154.31,89.68 UC1.Y12 ; v2(149.26,85.43) 149.6,85.77 UC1.AF6 ; v2(149.26,85.43) 148.95,85.12 UC1.AG5 ; v2(149.26,85.43) 149.57,85.12 UC1.AF5 ; UC1.AA6 153.95,85.76 v2(154.33,85.38) 154.35,85.38 154.73,85.77 UC1.W6 ; UC1.L6 161.49,85.77 161.68,85.95 162.14,85.95 UC1.K6 ; UC1.K12 162.25,89.86 161.78,89.86 UC1.L12 ; v2(139.29,85.38) 138.9,85.77 UC1.AY6 ; v2(141.77,85.4) 141.85,85.4 UC1.AR6 UC1.AP6 143.31,86.03 UC1.AP7 ; v2(146.53,89.4) 146.51,89.4 146.14,89.03 UC1.AL11 ; v2(149.24,88.16) 149.23,88.16 UC1.AG9
  BOTTOM w0.254: UC1.T6 156.94,85.41 v2(156.86,85.41) ; UC1.T6 UC1.R6 ; UC1.T6 157.3,86.14 157.49,86.34 v2(157.49,87.51) ; v2(150.18,89.28) 150.22,89.32 150.31,89.32 150.62,89.63 UC1.AE12 ; v2(142.83,89.89) 142.6,89.89 UC1.AR12 ; UC1.AR12 142.07,89.35 v2(141.94,89.35) 141.8,89.35 UC1.AT12 ; UC1.AR12 142.02,90.05 v2(141.95,90.05) ; UC1.AJ12 147.02,89.68 v2(147.38,89.32) ; v2(162.91,89.48) UC1.K12 ; UC1.K6 162.33,85.73 v2(162.69,85.44) 163.13,85.77 UC1.J6 v2(163.59,85.46) UC1.J5
  BOTTOM w0.305: v2(139.28,86.11) 139.63,85.77 UC1.AW6
  vias: v1(131.72,73.89)
+1.2VP: length 20.4
  BOTTOM w0.203: PUM1.5 93.53,26.15 94.23,25.45 PRM6.2
  BOTTOM w0.254: PCM10.1 97.03,40.15 97.03,26.46 96.6,26.02 95.24,26.02 94.98,25.76 PRM6.2
  vias: v1(94.23,42.56) v2(93.05,41.68) v2(93.68,41.68) v2(94.82,40.79) v2(94.82,40.03) v2(94.82,39.27) v2(94.82,38.5) v2(94.82,37.87) v2(95.33,40.28) v2(95.33,39.65) v2(95.33,38.89) v2(95.33,38.25) v2(95.33,37.62) v2(95.33,36.98) v2(95.33,36.35)
+1.05V_BCLKPLL2: length 8.2
  BOTTOM w0.254: UH1.B3 UH1.B2 UH1.B1
  BOTTOM w0.305: UH1.B1 214.51,40.25 214.51,40.96
  BOTTOM w0.508: 214.51,40.96 214.51,41.34 213.82,42.03 CH23.1 213.8,43.61 213.8,44.3 214.05,44.55 v1(214.22,44.55) CH106.1 215.65,44.55 215.7,44.5 RH88.2
+1.05V_CNV_HVLDO: length 2.6
  TOP w0.127: RH57.2 v1(208.45,29.59)
  TOP w0.508: RH57.2 207.12,29.59 v2(206.75,29.22)
  BOTTOM w0.305: v2(206.75,29.22) 206.74,29.21 206.74,28.75 UH1.AE17
+1.05V_FHV0: length 11.1
  TOP w0.508: RH120.2 191.37,30.88 191.98,30.27 v1(192.79,30.27) 195.25,30.27 195.83,29.7 196.48,29.04 199.02,29.04 199.29,28.77 v2(199.84,28.77)
  BOTTOM w0.254: UH1.AF31 v2(199.84,28.77)
+1.05V_FHV1: length 11.1
  TOP w0.508: RH119.2 191.27,30.12 191.73,29.66 v1(194.35,29.66) 195,29.66 196.23,28.43 198.71,28.43 199.09,28.06 v2(199.79,28.06)
  BOTTOM w0.254: UH1.AG31 199.4,27.67 v2(199.79,28.06)
+1.05V_FUSE: length 11
  TOP w0.508: RH56.2 191.47,31.65 v1(191.81,31.3) 192.23,30.88 195.5,30.88 196.26,30.13 196.71,29.68 199.6,29.68 v2(199.79,29.49)
  BOTTOM w0.254: v2(199.79,29.49) UH1.AD31
+1.05V_OC: length 2.9
  TOP w0.127: v2(205.23,31.83) v1(204.82,31.42)
  TOP w0.508: RH87.2 CH22.1 205.68,32.28 v2(205.23,31.83)
  BOTTOM w0.254: v2(205.23,31.83) UH1.V19
+1.05V_OCPLL1: length 6
  BOTTOM w0.254: UH1.C1 214.21,39.59 213.9,39.4 UH1.C2
  BOTTOM w0.305: UH1.C1 214.4,39.56 215.07,40.23
  BOTTOM w0.508: RH86.2 CH105.1 217.81,41.35 CH21.1 217.33,40.87 216.96,40.87 216.38,40.29 215.13,40.29 215.07,40.23
+1.05V_PCH: length 12.2
  TOP w0.508: RH119.1 RH120.1 RH56.1 189.31,33.21 v2(189.54,33.44) ; v2(186.87,35.08) v1(188.08,35.08) RH59.1
  BOTTOM w0.508: RH86.1 218.52,43.08 218.81,42.79 218.81,40.5 219.33,39.98 RH84.1 219.56,38.68 219.95,38.29 RH83.1
  vias: v2(186.87,34.44) v2(207.94,33.02) v2(209.6,30.34) v2(215.35,41.07) v2(215.93,41.07)
+1.05V_PCH_PRIM: length 21
  TOP w0.127: v1(206.06,36.64) 205.57,36.14 v2(205.46,36.14)
  TOP w0.381: v2(202.21,28.71) 202.18,28.74 CH62.1
  BOTTOM w0.254: UH1.AB23 203.63,29.52 v2(203.63,29.46) ; UH1.AB23 203.52,30.12 v2(203.66,30.26) ; UH1.AB23 v2(202.89,30.26) UH1.AA23 203.52,30.41 v2(203.66,30.26) ; v2(203.66,30.26) UH1.AA22 ; v2(203.66,30.26) UH1.AB22 ; UH1.AD27 v2(202.21,28.71) UH1.AF27 ; UH1.AD27 v2(201.34,29.49) ; UH1.AD27 v2(202.16,29.44) UH1.AB27 ; UH1.AB28 v2(201.34,29.49) ; UH1.AB28 v2(200.56,30.26) 200.39,30.08 UH1.AB30 v2(200.56,29.56) ; UH1.AB28 200.95,29.9 201.32,30.26 v2(201.34,30.26) UH1.AB27 ; UH1.AB28 200.88,29.87 v2(200.56,29.56) ; v2(201.34,29.49) UH1.AD28 ; v2(201.34,29.49) 201.35,29.5 UH1.AB27 ; v2(204.43,29.42) UH1.AB20 v2(205.17,29.45) UH1.AD20 v2(204.43,29.42) ; v2(204.43,29.42) UH1.AB22 ; UH1.AF30 v2(200.48,28.72) ; v2(200.48,28.72) UH1.AD30 v2(200.56,29.56) ; v2(200.48,28.72) UH1.AD28 ; UH1.AB22 v2(203.63,29.46) ; v2(200.56,29.56) UH1.AD28 ; UH1.AF23 203.52,28.57 v2(203.66,28.71) 203.52,28.86 UH1.AD23 203.28,29.1 v2(203.63,29.46)
  vias: v2(203.79,37.41) v2(203.92,36.78) v2(203.94,35.88) v2(204.24,35.4) v2(204.27,36.33) v2(204.35,37.47) v2(204.47,36.93) v2(204.91,36.03) v2(205.17,36.62) v2(205.31,37.49) v2(205.58,37)
+1.05V_SRC: length 2.9
  TOP w0.127: RH85.2 v1(205.92,30.29)
  TOP w0.508: v2(205.21,31.04) 205.38,31.04 205.61,31.27 RH85.2
  BOTTOM w0.254: UH1.W20 v2(205.21,31.04) 205.25,31.08 UH1.W19
+1.05V_VCCAMPHYPLL:
  vias: v1(186.42,35.79)
+1.05V_VCCAZPLL: length 5.3
  BOTTOM w0.254: UH1.E1 UH1.D1
  BOTTOM w0.406: UH1.D1 215.11,39.06
  BOTTOM w0.508: 215.11,39.06 216.66,39.06 217.2,39.6 CH17.1 217.68,39.6 218.42,38.86 RH84.2
+1.05V_VCCCLPLLEBB: length 11.9
  TOP w0.508: RH59.2 190.35,35.2 CH15.1 v1(193.07,35.2) 193.35,35.2 195.17,33.38 195.17,32.61 195.51,32.28 195.84,32.28 197.08,31.03 198.68,31.03 v2(198.93,30.79)
  BOTTOM w0.305: UH1.W31 199.4,31.26 v2(198.93,30.79)
+1.05V_VCCDSW: length 4.5
  BOTTOM w0.305: UH1.BG45 UH1.BG46 191.98,17.72 191.98,17.46
  BOTTOM w0.381: 191.98,17.46 190.9,16.38 190.9,15.2 191.47,14.63 CH16.1
+1.05V_VCCMPHY: length 14.9
  BOTTOM w0.254: UH1.V30 199.96,31.98 v2(199.79,31.81) UH1.V31 ; UH1.V30 199.96,32.41 v2(199.79,32.59) ; UH1.V30 200.39,31.99 200.56,31.81 UH1.V28 ; UH1.V30 200.39,32.52 UH1.U29 ; v2(202.45,33.36) 202.46,33.35 v2(202.46,32.76) ; UH1.V28 UH1.U29 ; UH1.V28 v2(201.34,32.59) ; UH1.V28 v2(201.34,31.81) UH1.V27 ; UH1.U29 v2(199.93,33.16) v2(199.79,32.59) ; UH1.U29 v2(201.33,33.23) ; v2(202.46,32.76) UH1.V25 v2(202.11,31.81) UH1.V27 ; v2(202.46,32.76) 202.43,32.73 UH1.U26 UH1.V27 ; UH1.V27 v2(201.34,32.59) ; v2(198.86,32.27) UH1.V31 ; UH1.V31 v2(198.89,31.63) ; UH1.V31 v2(199.79,32.59) ; v2(201.34,32.59) 201.34,33.22 v2(201.33,33.23) ; v2(201.33,33.23) v2(201.33,33.82)
  vias: v1(200.49,32.19) v2(199.61,35.46) v2(200.1,36.05) v2(200.17,35.43) v2(200.47,38.29) v2(200.57,37.07) v2(201.13,37.07) v2(201.07,36.51) v2(201.07,35.95) v2(201.25,38.18) v2(201.25,37.63) v2(201.32,35.45)
+1.05V_VCCSFR: length 14.4
  TOP w0.508: RC143.2 173.63,101.06 172.85,100.28 CH102.1 165.31,100.53 v1(164.05,100.53) 163.62,100.53 162.72,101.43 CH103.1
  BOTTOM w0.203: UC1.J28 162.76,102.49 163.22,102.49 UC1.H28
  BOTTOM w0.254: UC1.H28 163.31,102.76 163.1,102.97 v2(163.05,102.97)
+1.05V_VCCST: length 449.4
  TOP w0.254: v2(137.7,16.62) 137.7,16.05 137.39,15.75 137.39,14.83 136.78,14.22 UK1.117
  TOP w0.381: RH166.1 v1(221.46,29.38) v2(222.56,29.38)
  TOP w0.508: RC140.2 173.57,99.41 v2(172.84,99.41) ; v2(164.06,104.81) 164.01,104.86 164.01,106.09 CC38.1 163.91,106.6 163.96,106.65 163.96,109.75 165.99,111.78 v2(169.5,111.78) 169.75,112.04 169.75,114.23 168.81,115.17 v2(168.81,120.11) ; v2(171.91,132.81) 171.91,133.53 172.39,134.01 PCZ3.2 172.98,133.84 PRZ5.1 PRZ6.2 PRZ7.1 PRZ8.1
  IN1 w0.381: v2(233.12,49.64) 232.98,49.64 230.82,47.49 220.95,47.49 219.91,48.52 194.34,48.52 194.11,48.75 193.69,48.75 193.21,49.22 v2(188.83,49.22)
  IN1 w0.508: v2(125.73,102.97) 124.85,102.97 124.46,102.59 121.39,102.59 120.99,102.99 v2(120.99,107.72)
  IN2 w0.254: v2(102.1,74.2) 103.34,74.2 104.14,75.01 112.62,75.01 113.43,75.82 118.97,75.82 121.12,77.98 121.12,86.26 123.28,88.42 123.28,99.5 121.04,101.75 121.04,107.67 v2(120.99,107.72)
  IN2 w0.381: v2(177.97,82.7) 178.04,82.7 178.98,81.75 178.98,79.22 180.7,77.51 180.7,72.64 176.45,68.39 176.45,61.03 177.29,60.18 177.29,54.03 180.76,50.57 185.42,50.57 186.77,49.22 v2(188.83,49.22)
  IN2 w0.508: v2(177.97,82.7) 177.97,82.87 172.84,88 v2(172.84,99.41)
  IN3 w0.127: v2(164.06,104.81) 164.06,105.49 163.56,105.98 163.21,105.98 162.94,105.71 162.94,104.51 163.09,104.36
  IN3 w0.254: v2(120.42,19.87) 120.42,21.19 118.17,23.44 112.95,23.44 111.53,22.02 100.72,22.02 98.74,24.01 98.74,24.81 97.94,25.61 97.49,25.61 97.05,26.06 95.38,26.06 86.96,17.63 82.98,17.63 78.47,22.14 78.47,27.14 76.21,29.4 76.21,45.75 78.72,48.26 81.32,48.26 81.94,48.88 82.79,48.88 86.14,52.23 87.56,52.23 91.53,56.2 94.07,56.2 95.11,57.24 95.11,59.78 96.47,61.14 96.47,64.02 97.38,65.4 98.03,66.51 98.78,67.87 99.4,69.08 100.11,70.66 101.14,73.11 101.99,74.19 v2(102.1,74.2)
  IN3 w0.381: v2(164.06,104.81) 163.61,104.36 163.09,104.36 ; v2(233.12,49.64) 233.12,49.38 232.34,48.6 232.34,47.9 232.89,47.35 232.89,44.7 231.18,42.98 229.21,42.98 225.14,38.91 225.14,31.96 v2(222.56,29.38)
  IN3 w0.508: v2(172.84,99.41) 173.41,99.98 173.41,104.11 172.94,104.59 172.94,105.02 169.5,108.46 169.5,108.51 169.6,108.61 169.6,109.11 169.5,109.22 v2(169.5,111.78) ; v2(168.81,120.11) 168.81,121.03 170.16,122.37 170.75,122.37 171.43,123.06 171.43,124.58 171.07,124.94 171.07,125.78 171.63,126.34 171.63,129.94 171.91,130.22 v2(171.91,132.81) ; v2(125.73,102.97) 126.6,102.11 132.74,102.11 132.78,102.14 134.18,103.54 157.86,103.54 158.03,103.37 159.43,103.37 160.62,102.18 161.9,102.18 162.42,102.7 162.42,103.7 163.09,104.36
  BOTTOM w0.254: v2(164.06,104.81) UC1.H30 ; v2(137.7,16.62) 137.24,16.16 136.66,16.16 134.46,18.35 132.85,18.35 131.71,19.49 121.63,19.49 121.53,19.39 120.65,19.39 120.42,19.62 v2(120.42,19.87)
  BOTTOM w0.356: RC41.2 RC40.1 120.45,107.69 CC406.1 v2(120.99,107.72)
  BOTTOM w0.508: RC20.2 177.97,83.55 v2(177.97,82.7)
+1.05V_VCCSTU: length 133.9
  TOP w0.127: CC391.1 251.96,41.69 v3(251.43,42.22)
  TOP w0.508: RC143.1 175.35,100.28 RC140.1 175.35,100.22 v2(175.9,99.67)
  IN2 w0.508: v2(253.01,41.43) 252.85,41.59 244.74,41.59 243.83,40.68 242.99,40.68 241.96,39.65 240.13,39.65 239.45,40.33 238.49,40.33 238,40.82 232.11,40.82 231.81,41.11 230.44,41.11 229.8,40.48 222.17,40.48 214.46,48.19 193.94,48.19 188.1,54.03 188.1,67.84 186.04,69.89 186.04,80.59 185.68,80.95 185.68,84.55 188,86.87 188,93.61 187.1,94.51 185.48,94.51 184.87,93.9 178.16,93.9 176.56,95.5 176.56,97.09 175.9,97.75 v2(175.9,99.67)
+1.05V_VCCUSB: length 3.5
  TOP w0.127: v1(203.31,31.42) 203.66,31.77 v2(203.66,31.81)
  TOP w0.508: RH58.2 204.91,32.66 CH14.1 203.79,32.41 203.79,31.94 v2(203.66,31.81)
  BOTTOM w0.254: UH1.W23 203.28,31.42 v2(203.66,31.81) 203.98,31.49 204.05,31.42 UH1.W22
+1.05V_XTAL: length 7.1
  BOTTOM w0.508: 214.45,34.33 214.8,34.33 215.31,34.84 215.31,35.21 215.73,35.63 215.87,35.63 216.27,36.03 v1(216.93,36.03) 217.8,36.03 218.2,36.43 CH101.1 CH20.1 219.09,36.94 RH83.2
+1.05VALW: length 120.4
  TOP w0.508: RC383.1 218.27,30.28 v2(218.37,30.39)
  IN2 w0.508: v2(176.7,108.06) 176.7,104.63 178.19,103.15 178.19,98.04 181.06,95.16 184.37,95.16 184.96,95.76 187.62,95.76 189.66,93.71 189.66,86.78 188.89,86.01 188.89,81.46 187.29,79.86 187.29,70.4 189.34,68.35 v2(189.34,57.5)
  IN3 w1.016: 251.29,37.16 250.17,36.04 235.95,36.04 226.96,27.05
  BOTTOM w0.508: v2(203.22,43.12) 203.22,43.37 199.2,47.39 195.06,47.39 192.68,49.77 192.68,53.88 192.2,54.36 189.84,54.36 189.34,54.86 v2(189.34,57.5)
  vias: v2(203.22,42.54) v2(203.22,41.91) v2(203.8,43.12) v2(203.8,42.54) v2(203.8,41.91) v2(204.38,43.12) v2(204.38,42.54) v2(204.38,41.91) v2(204.97,43.12) v2(204.97,42.54) v2(204.97,41.91) v2(205.55,43.12) v2(205.55,42.54) v2(205.55,41.91) v2(225.68,24.73) v2(225.68,24.15) v2(225.68,23.57) v2(225.68,22.98) v2(225.68,22.4) v2(225.68,21.81) v2(225.68,21.23) v2(226.28,25.29) v2(226.26,24.73) v2(226.26,24.15) v2(226.26,23.57) v2(226.26,22.98) v2(226.26,22.4) v2(226.26,21.81) v2(226.26,21.23) v2(226.88,25.28) v2(252.37,37.63) v2(252.95,37.63) v3(206.71,42.68)
+1.05VALWP: length 8.5
  BOTTOM w0.254: PC1005.1 235.45,17.8 237.19,17.8 237.94,18.56 237.94,21.53 237.83,21.64 PC1008.1 237.83,22.5 237.93,22.6 PR1006.1
  vias: v1(233.23,19.07) v2(231.31,22.68) v2(231.31,22.1) v2(231.31,21.51) v2(231.31,20.93) v2(231.89,22.68) v2(231.89,22.1) v2(231.89,21.51) v2(231.89,20.93) v2(232.5,22.73) v2(232.5,22.15) v2(232.5,21.56) v2(232.5,20.98) v2(233.09,22.73) v2(233.09,22.15) v2(233.09,21.56) v2(233.09,20.98)
+1.05VS_VCCSTG: length 66.5
  TOP w0.508: v2(163.68,103.75) 163.97,103.75 164.74,104.52 CC40.1 166.36,104.52 166.93,105.08 168.11,105.08 169.85,103.35 170.7,103.35 171.21,103.86 171.21,104.54 v3(171.85,105.18) 172.41,105.74 CC398.1
  IN1 w0.508: v2(126.9,98.85) 126.29,99.46 123.58,99.46 122.71,100.33 v2(121.11,100.33)
  IN3 w0.508: v2(163.68,103.75) 163.68,102.7 162.5,101.53 160.35,101.53 159.16,102.72 157.76,102.72 157.59,102.89 134.45,102.89 132.87,101.32 132.87,100.1 132.26,99.49 130.08,99.49 129.34,100.23 127.28,100.23 126.9,99.85 v2(126.9,98.85)
  BOTTOM w0.254: RC384.2 RC380.2 RC381.2 v2(121.11,100.33) 121.14,100.36 RC18.2 ; UC1.G30 v2(163.68,103.75) UC1.H29
+1.8V_PG: length 41.3
  TOP w0.254: v2(241.83,22.92) 241.83,26.26 242.01,26.44 242.85,26.44 243.16,26.75 243.16,27.55 243.36,27.76 v3(245.37,27.76) 248.45,27.76 250.7,25.51 250.7,24.8 v2(252.09,23.41)
  IN2 w0.254: v2(268.65,21.35) 268.65,21.56 267.21,22.99 252.8,22.99 252.38,23.41 v2(252.09,23.41)
  BOTTOM w0.254: v2(241.83,22.92) 241.83,23.44 PR1003.1 ; PU1801.2 266.59,20.82 266.81,20.6 268.15,20.6 268.65,21.09 v2(268.65,21.35) 268.65,21.64 267.8,22.49 PR1801.2
+1.8V_PHVLDO: length 2.2
  TOP w0.127: v1(206.3,28.17) 205.96,28.51 v2(205.96,28.69)
  BOTTOM w0.305: v2(205.96,28.69) UH1.AF19 205.55,28.33 v2(205.19,28.69) 204.83,28.33 UH1.AF20
+1.8V_PRIM: length 162.7
  TOP w0.508: RH147.2 195.53,28.24 v2(194.8,28.96) ; RWL12.1 307.8,16.91 RWL13.1 v2(309.4,17.68) ; v2(194.39,33.02) 193.9,32.53 RH146.2 ; RH150.2 202.33,25.55 202.71,25.93 202.71,27.24 203.28,27.81 RH172.2 205.07,27.81 v2(205.19,27.93)
  IN2 w0.508: 220.27,22.33 221.11,23.18 221.11,25.17 229.73,33.78 242.13,33.78 242.99,32.92 246.63,32.92 247.33,32.23 252.45,32.23 252.58,32.1 254.55,32.1 258.91,27.74 273.24,27.74 273.41,27.91 280.52,27.91 281.23,28.62 282.53,28.62 283.97,27.18 283.97,19.64 285.34,18.27 286.46,18.27 288.58,16.15 295.34,16.15 295.78,16.59 296.8,16.59 297.08,16.3 297.08,10.31 v2(300.45,6.94)
  IN3 w0.508: v2(309.4,17.68) 310.2,16.87 310.2,11.97 309.03,10.8 307.51,10.8 306.75,11.56 306.08,11.56 305.47,10.95 305.47,10.27 304.36,9.16 303.7,9.16 302.29,7.75 300.94,7.75 300.45,7.26 v2(300.45,6.94) ; v2(207.42,24.2) 207.01,24.2 205.88,25.33 205.88,27.24 v2(205.19,27.93) 200.53,27.93 200.05,27.45 199.54,27.45 199.15,27.84 199.15,28.1 198.72,28.53 195.24,28.53 v2(194.8,28.96) 194.49,29.28 194.49,31.6 194.27,31.82 194.27,32.91 v2(194.39,33.02)
  BOTTOM w0.127: v2(219.38,22.32) v1(220.01,22.32)
  BOTTOM w0.254: v2(208.52,21) 208.52,20.91 209.12,20.3 UH1.BB11 ; v2(207.42,23.16) UH1.AR15 ; UH1.AG19 205.25,27.87 v2(205.19,27.93) UH1.AG20 ; v2(207.42,24.2) UH1.AN15
  BOTTOM w0.508: RH167.2 218.67,21.23
  vias: v2(218.83,22.31)
+1.8V_TBTC_PDLDO: length 5.5
  TOP w0.203: UU4.35 51.39,43.26
  TOP w0.254: CU69.1 52.37,43.65 51.79,43.65 v1(51.56,43.43) 51.39,43.26
  TOP w0.508: CU74.1 55.12,44.69 53,44.69 52.74,44.42 CU69.1
+1.8VALW: length 51.3
  TOP w1.016: 221.58,22.71 224.2,25.33 224.2,29.85 223.22,30.83 223.22,32.34
  IN2 w1.016: 224.65,34.63 225.32,34.63 227.37,36.68 243.17,36.68 244.12,35.73 246.57,35.73 247.61,36.77 253.51,36.77 253.53,36.79
  BOTTOM w1.524: 256.8,35.78 256.8,33.13 259.94,30 259.94,27.47
  vias: v2(223.14,33.88) v2(223.14,33.24) v2(246.96,40.71) v2(247.52,40.72) v2(255.91,38.1) v2(256.47,38.1) v2(257,37.91) v3(221.11,22.98) v6(240.39,40.29) v6(241.05,40.29) v6(241.66,40.29)
+1.8VALWP: length 6.3
  BOTTOM w0.254: 261.35,24.57 261.94,25.17 v1(263.54,25.17) 264.34,25.17 265.19,24.32 PR1803.1 265.19,23.05 265.21,23.03 PC1802.1
+1.8VS: length 129.8
  TOP w0.254: 255.84,42.52 255.83,42.53 255.83,43.27 255.43,43.67 254.25,43.67 253.02,44.9 249.23,44.9 248.93,44.6 248.93,43.97 248.02,43.06 248.02,41.88 247.44,41.3 243.67,41.3 243.39,41.02 238.34,41.02 233.63,45.73 233.63,46.17 v3(230.99,48.82) 230.99,50.98 230.64,51.33 228.01,51.33 227.24,52.1 227.24,53.7 226.78,54.15 225.8,54.15 PRV5.1
  TOP w0.508: LA3.2 305.01,21.99 305.64,22.63 305.64,25.4 307.22,26.97 309.55,26.97 310.24,27.66 310.24,30.3 v2(309.35,31.19)
  IN3 w0.508: v2(309.35,31.19) 308.7,31.84 308.7,43.72 305.99,46.42 275.21,46.42 272.69,48.94 266.41,48.94 262.08,44.61 259.86,44.61 259.29,44.03 259.29,43.08 258.31,42.1 257.49,42.1 257.28,41.9 v6(255.74,41.9)
+1.8VS_AVDD: length 3.4
  TOP w0.203: UA1.20 299.2,21.83 299.28,21.76 299.46,21.76 299.57,21.87 CA13.1
  TOP w0.381: CA13.1 300.23,21.87 300.33,21.97 CA14.2
  TOP w0.508: CA14.2 301.3,21.97 LA3.1
+1.8VSDGPU_AON: length 312.2
  TOP w0.381: RG400.1 220.76,64.11 v2(220.68,64.18) ; v2(218.22,62.93) 218.22,64.46 218.78,65.01 218.78,65.68 219.5,66.4 RG86.2 219.51,66.65 RG85.2 219.53,67.45 RG399.1
  TOP w0.508: v2(191.68,83.61) 191.12,84.17 188.49,84.17 188.28,84.38 186.68,84.38 185.6,83.3 ; 185.6,83.3 v3(183.85,83.3) 183.39,83.3 v2(182.39,84.3) ; 185.6,83.3 185.6,81.62 186.02,81.2 v2(186.69,81.2) ; RG403.1 223.68,60.99 223.13,61.54 RG34.1 222.92,61.83 222.51,61.83 v2(222.48,61.85) 221.94,61.85 RG38.1 ; v2(226.54,61.95) 226.54,61.71 225.98,61.15 RG37.1 ; RV36.2 19.5,69.06 QV2.5 QV2.2 19.5,66.11 19.18,65.79 19.18,65.61 18.77,65.19 v2(18.57,65.19) 17.84,65.93 RV37.2
  IN1 w0.381: v2(220.68,64.18) 219.1,64.18 218.22,63.3 v2(218.22,62.93)
  IN1 w0.508: v2(86.1,51.36) 86.1,52.08 91.88,57.86 92.29,57.86 93.6,59.17 93.6,59.92 v2(93.53,59.99) ; v2(191.68,83.61) 192.27,84.2 192.27,87.76 189.55,90.48 189.55,92.99 190.8,94.24 191.27,94.24 191.71,94.68 198.7,94.68 199.05,95.02 199.05,96.5 198.54,97.01 v2(198.54,97.83)
  IN2 w0.508: v2(18.57,65.19) 18.42,65.04 18.42,64.35 21.35,61.42 21.35,57.55 21.82,57.07 22.69,57.07 24.11,55.65 24.38,55.65 27.48,52.55 30.31,52.55 30.58,52.29 32.93,52.29 33.84,51.38 34.73,51.38 35.47,50.65 35.47,49.87 38.6,46.73 39.02,46.73 43.36,42.39 43.82,42.39 ; 48.76,41.84 49.11,41.49 56.22,41.49 57.22,42.49 67.63,42.49 68.3,43.17 77.82,43.17 78.03,43.37 80.36,43.37 81.64,44.65 82.8,45.82 84.59,45.82 86.1,47.32 v2(86.1,51.36)
  IN3 w0.381: v2(242.71,39.54) 240.19,39.54 239.53,40.2 239.53,41.73 239.01,42.24 239.01,43.03 239.48,43.49 242.34,43.49 242.54,43.69
  IN3 w0.508: 213.06,93.7 211.16,95.59 200.3,95.59 198.54,97.35 v2(198.54,97.83) ; 213.29,87.87 213.01,87.59 213.01,83.66
  BOTTOM w0.381: RG132.2 227.76,62.73 RG127.2 ; UG28.5 v2(236.94,63.77) 236.94,64.14 237.19,64.4 CG340.1 236.43,64.79 RG180.1 ; RG394.1 v2(240.39,63.78) ; RG100.1 236.24,58.68 236.1,58.82 UG13.5 235.64,58.82 v2(235.07,59.39) ; RG35.2 218.22,62.59 v2(218.22,62.93) 218.22,63.28 RG36.2 ; v2(240.32,61.74) UG29.5 240.9,61.77 CG563.1 ; v2(236.17,56.23) 235.71,55.77 RG398.1 234.77,55.77 RG396.1 233.93,55.77 RG397.1 ; UG8.5 186.14,80.65 v2(186.69,81.2) ; RG129.2 220.54,69.1 220.54,67.76 RG124.2 ; v2(242.71,39.54) 242.81,39.44 RG179.1
  BOTTOM w0.508: v2(233.13,61.59) RG131.2 232.25,61.45 231.87,61.45 RG125.2 RG130.2 230.66,61.4 230.17,61.4 RG126.2 ; 181.53,82.65 179.55,82.65 178.43,81.53 174.58,81.53 159.34,66.29 101.06,66.29 94.76,59.99 v2(93.53,59.99) ; 181.53,82.65 181.53,78.81 182.2,78.14 RG83.2 ; 181.53,82.65 181.59,82.71 RG7.1 181.59,83.93 181.96,84.3 v2(182.39,84.3) ; RG128.2 225.92,61.95 v2(226.54,61.95) 226.54,62.33 RG132.2 ; v2(220.68,64.18) 220.36,64.5 RG5.2 RG6.2 220.36,66.75 RG39.1 220.37,67.16 220.35,67.18 RG124.2
  vias: v2(212.49,82.53) v2(212.49,81.97) v2(213.05,82.61) v2(213.08,81.97) v2(224.23,67.12) v2(224.62,66.73) v2(245.13,44.92) v2(245.69,44.92) v2(246.27,44.92) v2(246.83,44.92) v2(247.42,44.92)
+1.8VSDGPU_MAIN: length 38.9
  IN2 w0.508: v2(211.02,81.98) 211.71,81.29 211.71,76.33 212.29,75.75 212.29,75.73 212.32,75.7 212.32,72.6 217.19,67.73 217.19,65.42 218.27,64.35 218.54,64.35 218.83,64.05 v2(218.83,62.93)
  BOTTOM w0.254: v2(198.95,88.09) 198.85,88.19 UG1.AG16 197.7,87.81 v2(197.7,87.73) ; UG1.AH18 197.28,89.91 v2(197.68,90.31) 198.08,89.91 UG1.AG18 ; v2(197.7,87.73) 197.3,87.34 UG1.AH15 ; v2(197.7,87.73) 197.7,87.73 UG1.AG15 ; v2(198.96,85.49) 198.77,85.69 UG1.AG13 ; v2(197.7,84.42) UG1.AH12
  BOTTOM w0.356: v2(211.02,81.98) 211.11,81.87 UG1.L8 ; v2(210.38,81.98) 210.44,81.87 UG1.M8
  BOTTOM w0.381: v2(191.65,81.49) 190.94,80.79 189.29,80.79 189.18,80.89 188.6,80.89 187.73,80.02 185.76,80.02 184.77,79.04 UG8.2 ; QG2.5 v2(220.7,63.17) ; v2(218.83,62.93) 218.92,62.93 219.16,63.17 QG2.2
  vias: v2(193.59,96.95) v2(194.41,96.93) v2(195.15,96.95) v2(195.99,96.97) v2(196.8,96.97) v2(197.7,96.09) v2(198.95,89.1) v2(198.96,86.21) v2(240.01,44.48) v2(240.3,44.96) v2(240.55,44.34) v2(240.84,44.82) v2(241.11,44.31) v2(241.4,44.86) v2(241.67,44.37) v3(193.26,95.01) v6(189.77,97.05) v6(190.48,96.99) v6(190.8,96.45) v6(191.19,95.92)
+1.24V_PRIM_DPHY: length 5
  TOP w0.508: v2(203.65,27.12) 203.79,26.99 v1(205.43,26.99) 205.66,26.99 205.82,26.82 205.82,25.93 205.57,25.68 RH174.1
  BOTTOM w0.254: UH1.AJ23 203.52,27 v2(203.65,27.12) UH1.AJ22
+1.24V_PRIM_MAR: length 3.2
  TOP w0.127: v2(213.37,16.57) 213.82,16.57 214,16.39 v1(214,16.22)
  TOP w0.508: v2(213.37,16.57) 212.72,16.57 CH36.1
  BOTTOM w0.254: UH1.BG5 212.46,17.48 v2(213.37,16.57)
+1.24V_VCCLDOSRAM_IN: length 3
  TOP w0.127: v1(203.28,25.73) 203.28,26.17 203.5,26.4 v2(203.63,26.4)
  TOP w0.508: RH174.2 203.91,26.04 203.91,26.12 v2(203.63,26.4)
  BOTTOM w0.254: UH1.AK23 203.63,26.31 v2(203.63,26.4) 203.63,26.39 UH1.AK22
+1.35VRAMP: length 6
  TOP w0.127: v2(251.7,57.97) 252.39,57.97 v1(253.32,57.05)
  BOTTOM w0.254: PRW9.1 244.12,60.08 245,60.96 245,62.77 v2(245.4,63.17)
  vias: v2(245.93,62.92) v2(246.17,62.4) v2(246.3,63.34) v2(246.51,61.94) v2(246.71,62.93) v2(246.92,62.35) v2(246.92,61.52) v2(247.33,61.94) v2(247.54,61.28) v2(247.95,61.69) v2(247.95,60.87) v2(248.36,61.28) v2(248.78,60.87) v2(249.19,60.45) v2(249.6,60.04) v2(249.6,59.21) v2(250.02,59.63) v2(250.02,58.8) v2(250.43,59.21) v2(250.43,58.39) v2(250.84,58.8) v2(250.86,57.97) v2(251.28,58.38) v2(251.29,57.52)
