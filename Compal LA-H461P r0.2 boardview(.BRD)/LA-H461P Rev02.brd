# Allegro board LA-H461P Rev02.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TC26  PAD~D  [TPC12]  173.7 82.75 180 bottom
TC27  PAD~D  [TPC12]  122.72 78.78 180 bottom
TC29  PAD~D  [TPC12]  123.59 80.92 180 bottom
TC51  PAD~D  [TPC12]  166.58 112.16 180 bottom
TC52  PAD~D  [TPC12]  172.31 81.6 180 bottom
TC53  PAD~D  [TPC12]  122.61 80.03 180 bottom
TC55  PAD~D  [TPC12]  124.07 77.72 180 bottom
TC57  PAD~D  [TPC12]  168.08 112.27 180 bottom
TC59  PAD~D  [TPC12]  171.14 82.8 180 bottom
TC92  PAD~D  [TPC12]  163.12 91.79 0 top
TC93  PAD~D  [TPC12]  161.73 92.17 0 top
TC94  PAD~D  [TPC12]  140.54 90.9 0 top
TC95  PAD~D  [TPC12]  138.71 89.08 0 top
TC96  PAD~D  [TPC12]  129.67 103.6 0 top
TC97  PAD~D  [TPC12]  125.48 76.81 180 bottom
TC100  PAD~D  [TPC12]  124.92 103.55 180 bottom
TC101  PAD~D  [TPC12]  130.16 105.42 0 top
TC102  PAD~D  [TPC12]  125.29 105.9 180 bottom
TC286  PAD~D  [TPC12]  124.54 90.07 180 bottom
TC287  PAD~D  [TPC12]  172.42 82.88 180 bottom
TC295  PAD~D  [TPC12]  125.04 102.11 180 bottom
TC296  PAD~D  [TPC12]  125.35 100.84 180 bottom
TC305  PAD~D  [TPC12]  213.15 30.74 0 top
TC306  PAD~D  [TPC12]  211.83 30.67 0 top
TG1  PAD  [TPC12]  208.74 106.58 180 bottom
TG2  PAD  [TPC12]  219 84.91 0 top
TG3  PAD  [TPC12]  201.55 102.37 0 top
TG4  PAD  [TPC12]  219.03 91.59 0 top
TG5  PAD  [TPC12]  188.43 81.63 180 bottom
TG6  PAD  [TPC12]  190.73 83.64 0 top
TG7  PAD  [TPC12]  190.24 84.77 180 bottom
TG8  PAD  [TPC12]  186.26 84.19 180 bottom
TG9  PAD  [TPC12]  221 72.41 180 bottom
TG10  PAD  [TPC12]  219.55 72.38 180 bottom
TG11  PAD  [TPC12]  208.16 79 0 top
TG12  PAD  [TPC12]  211.79 70.51 180 bottom
TG13  PAD  [TPC12]  213.1 70.51 180 bottom
TH1  PAD~D  [TPC12]  208.6 31.32 0 top
TH2  PAD~D  [TPC12]  207.78 32.32 0 top
TH3  PAD~D  [TPC12]  196.44 32.42 0 top
TH4  PAD~D  [TPC12]  197.81 31.94 0 top
TH5  PAD~D  [TPC12]  196.38 34.08 0 top
TH6  PAD~D  [TPC12]  197.5 33.22 0 top
TH7  PAD~D  [TPC12]  206.88 26.97 0 top
TH8  PAD~D  [TPC12]  208.13 26.55 0 top
TH11  PAD~D  [TPC12]  197.71 24.61 0 top
TH19  PAD~D  [TPC12]  187.95 23.26 180 bottom
TH48  PAD~D  [TPC12]  191.6 24.41 0 top
TH49  PAD~D  [TPC12]  188.35 26.64 180 bottom
TH52  PAD~D  [TPC12]  188.41 25.26 180 bottom
TH55  PAD~D  [TPC12]  216.32 23.78 180 bottom
TH56  PAD~D  [TPC12]  217 22.69 180 bottom
TH57  PAD~D  [TPC12]  212.36 23.14 0 top
TH74  PAD~D  [TPC12]  198.07 15.77 180 bottom
TH101  PAD~D  [TPC12]  197.25 25.83 0 top
TH119  PAD~D  [TPC12]  210.77 15.64 180 bottom
TH120  PAD~D  [TPC12]  208.89 14.65 180 bottom
TH121  PAD~D  [TPC12]  207.92 15.68 180 bottom
TH122  PAD~D  [TPC12]  206.81 24.98 0 top
TH124  PAD~D  [TPC12]  193.72 15.69 180 bottom
TH125  PAD~D  [TPC12]  200.08 15.71 180 bottom
TH128  PAD~D  [TPC12]  188.38 33.37 180 bottom
TH129  PAD~D  [TPC12]  199.31 24.47 0 top
TH131  PAD~D  [TPC12]  195.08 15.77 180 bottom
TH135  PAD~D  [TPC12]  216.37 21.03 180 bottom
TH138  PAD~D  [TPC12]  188.46 35.79 180 bottom
TH139  PAD~D  [TPC12]  188.89 34.57 180 bottom
TH145  PAD~D  [TPC12]  212.31 36.03 0 top
TH146  PAD~D  [TPC12]  211.68 37.39 0 top
TH147  PAD~D  [TPC12]  211.02 35.67 0 top
TH148  PAD~D  [TPC12]  213.3 35.2 0 top
TH4942  PAD~D  [TPC12]  186.86 30.57 180 bottom
TH4943  PAD~D  [TPC12]  188.21 30.45 180 bottom
TH4950  PAD~D  [TPC12]  196.36 15.73 180 bottom
TH4952  PAD~D  [TPC12]  195.23 25.8 0 top
TH4953  PAD~D  [TPC12]  210.6 22.1 0 top
TH4954  PAD~D  [TPC12]  203.36 21.54 0 top
TH4956  PAD~D  [TPC12]  202.01 23.39 0 top
TH4957  PAD~D  [TPC12]  204.49 22.17 0 top
TH4960  PAD~D  [TPC12]  200.86 20.74 0 top
TH4962  PAD~D  [TPC12]  193.25 27.84 0 top
TH4963  PAD~D  [TPC12]  187.46 29.32 180 bottom
TH4964  PAD~D  [TPC12]  188.74 29.28 180 bottom
TH4965  PAD~D  [TPC12]  197.06 15.77 180 bottom
TH4967  PAD~D  [TPC12]  198.71 15.77 180 bottom
TH4968  PAD~D  [TPC12]  211.87 21.91 0 top
TH4969  PAD~D  [TPC12]  205.14 20.71 0 top
TH4972  PAD~D  [TPC12]  201.6 15.76 180 bottom
TH4973  PAD~D  [TPC12]  199.39 20.42 0 top
TPV1  PAD~D  [TPC12]  31.32 62.86 0 bottom
TPV2  PAD~D  [TPC12]  30.47 62.51 180 top
TSL1  BOTH_GST5009-E-LF  [TAI-T_LAN-8100G_25P]  47.2 35.5 270 bottom
U7  TCS40DLR_SOT23F3  [APX8131AI-TRG_SOT23-3]  210.67 135.5 90 top
U9  -  [HP2DCTR_LGA12_2X2]  177.71 45.97 0 top
U10  -  [EM5209VF_DFN14_3X2]  267.6 41.68 90 top
U11  -  [AOZ1336DI_DFN8_2X2]  178.79 32.4 180 top
U12  -  [G517AH1TP1U_TSOT23-6]  64.6 35.84 0 top
U4019  NL17SZ74USG US 8P FLIP-FLOP  [SN74LVC1G123DCUR_VSSOP8]  108.88 22 0 top
UA1  -  [ALC3292-CG_MQFN48_6X6]  292.82 18.18 90 top
UC1  CFL-H_BGA1440  [CFL-H_BGA_1440P-T]  167.91 82.52 270 bottom
UC2  -  [74AUP1G07SE-7_SOT353-5]  119.95 88.48 0 bottom
UC3  G781P8F_MSOP8  [NCT7718W_MSOP8]  180.68 122.94 180 bottom
UC4  -  [EM5209VF_DFN14_3X2]  253.11 38.52 0 top
UC5  -  [EM5201V_DFN8_3X3]  178.65 104.97 90 top
UC6  -  [EM5201V_DFN8_3X3]  112.73 88.5 270 top
UG1  GP107-ES-A1_BGA908  [N17P-G1-A1_FCBGA_908P]  219.78 75.74 90 bottom
UG2  -  [MC74VHC1G09DFT2G_SC70-5]  234.94 52.98 180 bottom
UG4  H5GC2H24BFR-T2C_FBGA170  [K4G41325FC-HC04_FBGA_170P]  213.8 121.39 0 bottom
UG5  H5GC2H24BFR-T2C_FBGA170  [K4G41325FC-HC04_FBGA_170P]  197.55 134.2 180 bottom
UG6  H5GC2H24BFR-T2C_FBGA170  [K4G41325FC-HC04_FBGA_170P]  235.44 79.47 270 bottom
UG7  H5GC2H24BFR-T2C_FBGA170  [K4G41325FC-HC04_FBGA_170P]  248.24 92.89 90 bottom
UG8  -  [NL17SZ08DFT2G_SC70-5]  185.42 78.75 180 bottom
UG10  -  [NL17SZ08DFT2G_SC70-5]  235.67 46 0 bottom
UG11  -  [MC74VHC1G09DFT2G_SC70-5]  185.44 75.86 180 bottom
UG13  -  [NL17SZ08DFT2G_SC70-5]  233.89 58.82 90 bottom
UG27  EM5209VF_DFN14_2X3  [TPS22966DPUR_SON14_2X3]  245.22 41.56 180 bottom
UG28  -  [NL17SZ08DFT2G_SC70-5]  237.57 61.87 180 bottom
UG29  -  [NL17SZ08DFT2G_SC70-5]  240.87 59.84 180 bottom
UH1  CNP-H_BGA874  [CNP-H_BGA_874P-T]  214.31 40.41 180 bottom
UH2  W25Q128JVSIQ_SO8  [ACES_91960-0084L_8P-T]  191.63 53.54 90 bottom
UH3  -  [NL17SZ08DFT2G_SC70-5]  218.27 10.18 180 top
UK1  -  [KB9542Q-B_LQFP128_14X14]  137.24 8.19 90 top
UL1  RTL8118ASH-CG_QFN32_4X4  [RTL8118AS-CG_QFN32_4X4]  54.31 21.99 270 bottom
UL2  -  [G524B1T11U_SOT23-5]  56.91 12.85 90 bottom
UR1  -  [AK6627B81-MBF-GR_QFN32_4X4]  43.01 14.76 90 bottom
US2  -  [TPS2546RTER_QFN16_3X3]  20.53 78.64 180 bottom
US3  -  [AON7408L_DFN8-5]  22.31 81.3 180 top
UT1  SLB9670VQ1.2 FW6.40_VQFN32_5X5  [SLB9670VQ1P2-FW4P4X_VQFN32_5X5]  120.72 18.66 0 top
UT11  -  [TUSB1046-DCIRNQR_WQFN40_4X6]  30.15 47.93 90 top
UU4  -  [TPS65987DDHRSHR_VQFN56_7X7]  43.44 46.06 0 top
UU5  -  [W25X20CLSNIG_SO8]  57.02 24.6 90 bottom
UV1  -  [G5719CTB1U_SOT23-6]  72.32 40.34 0 top
UV2  PS8409AQFN48GTR2-A0_QFN48_6X6  [PS8409QFN48GTR2-A1_QFN48_6X6]  22.81 59.08 0 bottom
UV3  -  [RT9053AZQW_WDFN6_2X2]  25.48 55.48 90 top
UV4  -  [AP2330W-7_SC59-3]  17.74 113.63 180 top
YG1  27MHZ_10PF_XRCGB27M000F2P18R0  [Y_XRCGB27M000F2P18R0_4P]  221.57 66.06 0 bottom
YH1  24MHZ_18PF_XRCGB24M000F2P51R0  [Y_XRCGB24M000F2P51R0_4P]  219.51 32.6 90 bottom
YH2  32.768KHZ_9PF_X1A000141000400  [Y_X1A000141000200_2P]  184.99 18.57 90 bottom
YL1  25MHZ_10PF_XRCGB25M000F2P34R0  [Y_XRCGB25M000F2P18R0_4P]  47.96 18.57 90 bottom

## Library data of the parts
C365 C369-C376 C378-C382 C388-C391 C393 C394 C400 C403 C404 C406-C412 C5245 C5249 C5253 C5255-C5260 C5263 C5273-C5278 CA2 CA4 CA5 CA12 CA14 CA16-CA18 CA24 CA25 CA92 CC1-CC20 CC24-CC28 CC33-CC35 CC41 CC144 CC152-CC157 CC391-CC393 CC395 CC397 CC398 CC401 CC405 CD1 CD3 CD4 CD7 CD8 CD11 CD13-CD23 CD60 CD62 CD63 CD66 CD67 CD69 CD71-CD82 CD91-CD96 CE1 CE3 CE5-CE8 CG1 CG2 CG16 CG17 CG24 CG26-CG30 CG32 CG37 CG38 CG42 CG46 CG50 CG55 CG73-CG76 CG80-CG89 CG108-CG110 CG114-CG123 CG132 CG133 CG174 CG190-CG193 CG196 CG203-CG205 CG217 CG218 CG334-CG336 CG338 CG531-CG546 CG570-CG576 CH1-CH7 CH14 CH15 CH17 CH20 CH22 CH24 CH25 CH27 CH30 CH32-CH36 CH60 CH61 CH63-CH73 CH75-CH81 CH101-CH108 CK4 CK5 CK8 CK10-CK15 CL1 CL3 CL4 CL8 CL10 CL19 CL20 CL24 CL25 CL28 CL29 CR1-CR4 CR6 CR7 CR9-CR16 CS7 CS21 CS22 CS29 CS34 CS107 CS108 CS110 CS111 CS113 CT270 CTT1 CTT3 CTT4 CU57-CU60 CU62-CU64 CU66-CU74 CV2 CV5-CV41 CV45-CV47 CV49 CV52 CV54 CV273 CV274 CW1 CWL1-CWL3 PC1-PC6 PC8-PC11 PC301-PC303 PC310-PC313 PC316-PC318 PC325-PC329 PC1001 PC1002 PC1008 PC1010-PC1012 PC1014 PC1802 PC1805 PC1806 PC2502-PC2504 PCA3 PCA4 PCA6 PCA7 PCB01 PCB02 PCB03 PCB04 PCB05 PCB08 PCB09 PCB12 PCB14 PCB16 PCB17 PCB22-PCB24 PCB26 PCB27 PCB29-PCB32 PCF2 PCF5 PCF6 PCG1 PCG2 PCG5-PCG7 PCH1-PCH4 PCH6 PCH12-PCH14 PCM1 PCM4-PCM7 PCM14-PCM18 PCP1 PCP4 PCP7 PCP8 PCV1-PCV3 PCV8-PCV12 PCV15-PCV17 PCV19-PCV23 PCV27 PCV28 PCV42-PCV57 PCV62 PCV73-PCV91 PCW1 PCW4-PCW8 PCZ1 PCZ2 PCZ4-PCZ41 PCZ46-PCZ49 PCZ52-PCZ56 PCZ59-PCZ63 PCZ66-PCZ68 PCZ265-PCZ306 = C_0402
C366 C367 C395 C401 C402 C405 C5246 C5247 C5250 C5251 C5254 CA1 CA3 CA11 CA13 CA15 CA19-CA23 CA26-CA32 CA36-CA38 CA88 CA91 CA93-CA98 CC36-CC40 CC389 CC390 CC394 CC396 CC399 CC402 CC406 CC407 CD2 CD5 CD6 CD9 CD12 CD24-CD31 CD61 CD64 CD65 CD68 CD70 CD83-CD90 CD98-CD103 CE2 CE4 CG3 CG5-CG7 CG9 CG10 CG12-CG15 CG18-CG23 CG25 CG33 CG43 CG49 CG51-CG54 CG56-CG69 CG77-CG79 CG90-CG107 CG111-CG113 CG124 CG126-CG131 CG134-CG137 CG140-CG142 CG158-CG173 CG175-CG189 CG194 CG195 CG197 CG200 CG206-CG216 CG269 CG337 CG340 CG563-CG569 CH9 CH10 CH13 CH16 CH19 CH21 CH23 CH26 CH29 CH31 CH62 CH82-CH86 CK1-CK3 CK9 CL5 CL9 CL11-CL16 CL23 CL26 CL27 CR17 CS8 CS109 CT3 CT5 CT17 CT19-CT22 CT24 CT271-CT274 CT279-CT288 CT319-CT322 CTT2 CTT323 CV43 CV44 CV53 CWL5 CWL7 PCA23 PCG75-PCG86 PCP3 PCP327-PCP331 PCV26 PCV29-PCV41 PCV92 PCV93 PCW3 PCW12-PCW14 PCZ3 PCZ217-PCZ264 = C_0201
C368 CC29-CC32 CG4 CG11 CG31 CG34 CG36 CG39-CG41 CG70-CG72 CG138 CG139 CG143-CG157 CG202 CG219-CG223 CG339 CH12 CH18 CS114 CU61 CU65 CV1 CV3 CV4 CWL4 PC306-PC309 PC319-PC324 PC330-PC333 PC1003-PC1007 PC1801 PC1803 PC1804 PC2501 PC2505 PC2506 PCA5 PCA25-PCA34 PCB15 PCB18-PCB20 PCB33 PCB34 PCF1 PCF3 PCF4 PCG57-PCG74 PCH7-PCH11 PCM8-PCM13 PCV18 PCV63-PCV72 PCW2 PCZ175-PCZ193 = C_0603
CD10 CH11 EC11 = CK0402101V05_0402-2
CD32 = C_6P3X4P5
CD97 = C_D3
CL2 = C_1808
CLRP1-CLRP3 = SHORTPADS: User Part Number: PART#
CS9 LA4 = C_0805
D1 D3 = AZ5123-02SPR7G_SOT23-3
D506 D507 DL1 DM16 DS5 DT1 DU14 = AZC199-02SPR7G_SOT23-3
D508 D510 D511 D513 D514 D516 D517 DH2 DH3 DK2 = CH751H-40PT_SOD323-2
DA1 = AZ5125-01HPR7G_SOD523-2
DA3 = LRB521S-40T1G_SOD523-2-2
DA8 DA9 = L03ESDL5V0CC3-2_SOT23-3
DG1 DG2 DG4 DG5 DG7 DG243 = RB751S40T1G_SOD523-2
DG3 = BAV70W_SOT323-3
DH1 = BAT54C-7-F_SOT23-3
DM5 = AZC099-04SPR7G_SOT23-6
DM12 DM13 = YSUSB2P0-5_SOT-23-6-6
DS6 DV1-DV3 = AZ1045-04F_DFN2510P10E-10-9
DU1-DU3 = PUSB3FR4_DFN2510A-10-10
DU13 PD1 PD2 = L30ESD24VC3-2_SOT23-3
FD1-FD4 = FIDUCIAL_C40M80
FU1 = F_MF-MSMF050-2
H1 H2 H4 H7-H9 H11 H16 H17 H23 = H_2P3-G
H12-H15 H18-H20 = H_4P0
H22 = H_2P3X2P8
H25 = H_2P3N
H33 = H_4P0-G
JCR2 = T-SOL_5-531809001000-6_15P-T
JDIMM1 = ARGOS_D4AR0-26015-1P40_260P
JDIMM2 = ARGOS_D4AS0-26010-1P40_260P
JEDP1 = ACES_50203-0400C-002_40P-T
JFAN1 JFAN2 = ACES_50224-00401-001_4P
JHDD1 = HEFEN_AFC02-S12FRA-HF_12P
JHDMI1 = ACON_HMRA3-AK120C_19P
JIO1 = JXT_FP243A-036G1BM_36P
JKB1 = SDAN_606011-032241_32P
JKBL1 = ACES_51575-00401-001_4P
JL33 JP3 JP4 PJ301 PJ304 PJ1001 PJ1801 PJ1802 PJF1 PJF2 PJH1 PJM1 PJW5 = JUMP_43X79
JPHW8 PJ302 PJ305 PJ1002 PJB1 PJH2 PJM2 PJV1 PJW1 PJW2 PJZ1 = JUMP_43X118
JPWR1 = JXT_FP241AH-006GAAM_6P
JRJ45 = SDAN_601051-008041_8P
JSPK1 = ACES_50224-00601-001_6P
JSSD1 = ARGOS_NFSM0-S6715-TPH4_67P
JTP1 = TWVM_FPC1020-08RC-MA0HA_8P
JUSB3 = ACON_TCRAR-9U1391_9P-T
JUSBC1 = SINGA_2UB1688-C00111F_24P-T
JWLAN1 = LOTES_APCI0019-P003H_67P
L1 LS9 ML11 = MURAT_DLM0NSN900HY2D_4P
LA1 PH1 PHZ1-PHZ5 PR2-PR6 PR9 PR10 PR13-PR18 PR20 PR22 PR24 PR303 PR304 PR306 PR308-PR310 PR312-PR314 PR1002-PR1007 PR1020 PR1801 PR1803-PR1806 PR2501-PR2507 PRB01 PRB02 PRB06 PRB10 PRB12 PRB17 PRB18 PRB20 PRB23 PRB25 PRB27-PRB31 PRB35 PRB37-PRB39 PRB43 PRB44 PRF1-PRF6 PRG3 PRH4-PRH10 PRM1 PRM2 PRM6-PRM9 PRM11 PRM12 PRP2-PRP5 PRV5 PRV7 PRV10-PRV16 PRV20-PRV22 PRV26-PRV29 PRV31-PRV36 PRW1 PRW3-PRW12 PRW15 PRW16 PRZ2 PRZ4-PRZ8 PRZ10 PRZ12-PRZ14 PRZ16-PRZ18 PRZ20-PRZ22 PRZ24 PRZ26 PRZ28 PRZ32 PRZ35-PRZ47 PRZ49 PRZ50 PRZ52 PRZ55 PRZ57-PRZ67 PRZ69-PRZ73 PRZ76-PRZ78 PRZ81 PRZ84 PRZ87 PRZ90 R13 R23 R28 R124 R125 R295 R4960 R5202 R5216 R5219 R5220 R5237 R5238 R5242 R5243 R5247 R5284 R5285 R5287 R5798 R5801 R5802 R5804 R5806 R5807 RA37 RA56 RC1-RC5 RC8-RC13 RC15 RC16 RC18-RC22 RC31-RC36 RC39-RC43 RC81 RC82 RC369 RC375-RC377 RC380 RC381 RC383 RC384 RC390-RC393 RC934 RD1-RD11 RD19-RD29 RE1-RE4 RG5-RG7 RG9-RG12 RG14-RG16 RG34-RG39 RG42 RG43 RG45 RG47-RG77 RG80 RG83 RG85-RG100 RG103 RG105 RG106 RG108 RG111 RG113 RG114 RG118 RG122-RG138 RG148 RG179 RG180 RG214 RG381 RG391-RG406 RH1-RH4 RH6-RH8 RH13-RH29 RH31-RH39 RH41 RH44-RH48 RH50 RH52 RH53 RH64 RH67 RH76 RH78 RH79 RH81 RH82 RH92 RH93 RH96 RH98-RH100 RH117 RH118 RH141 RH146 RH147 RH150 RH155 RH156 RH158 RH164 RH166-RH173 RH175 RH176 RH178-RH181 RH191-RH193 RH195-RH199 RH204-RH223 RH226-RH247 RH252 RH254-RH259 RK2 RK4 RK7 RK12-RK14 RK17 RK20 RK21 RK23 RK26-RK34 RL7 RL11 RL15 RL30 RL31 RL56-RL61 RM6 RM11 RR2 RR4-RR12 RR15 RS9 RS10 RS13 RS14 RS17 RS39-RS43 RTT6-RTT10 RTT12 RTT35 RU51-RU53 RU57 RU58 RU61 RU63 RU65-RU73 RU78 RU79 RV2 RV3 RV5 RV7 RV11 RV14 RV16 RV18 RV21-RV29 RV31 RV33-RV38 RV41-RV51 RV56-RV61 RV135 RV136 RWL1-RWL5 RWL7 RWL12 RWL13 RWL18 RWL20-RWL22 RWL29-RWL33 = R_0402
LA2 R24 R5221 R5222 RA3 RK1 RT6 = R0603_0OHM
LA3 PR1 PR21 PR301 PR305 PR311 PR1009 PRB15 PRB16 PRB19 PRB22 PRB34 PRB40 PRB41 PRH3 PRV8 PRV19 PRV37 PRV38 PRW14 PRZ9 PRZ11 PRZ19 PRZ25 PRZ27 PRZ31 PRZ33 PRZ74 PRZ75 R1 R5094 R5217 R5236 R5253 R5799 R5800 RC37 RC38 RC45 RC140 RC143 RC370 RC371 RC373 RC374 RH40 RH56-RH59 RH61 RH65 RH83-RH88 RH90 RH91 RH119 RH120 RH125 RH138-RH140 RH143 RH148 RH161-RH163 RH174 RH186 RH187 RK8 RK9 RR1 RR3 RR14 RS16 RU54 RU55 RU62 RV4 RV19 RV30 RV39 RV40 = R0402_0OHM
LA8-LA10 = MURAT_BLM15AX601SN1D_2P
LED4 LED5 = LED_LTST-S482KFKT-SE_2P
LG1 LG3 = MURAT_BLM18PG330SN1D_2P
LK1 LK2 = MURAT_BLM15BD601SN1D_2P
LL2 LV3 = CHILI_MHCD252012A-2R2M-A8S_2P
LV1 PR19 RV52 = R_0805
LV2 = CHILI_PBY160808T-121Y-N_2P
PC305 PC314 PC1013 PCA1 PCA2 PCB10 PCB11 PCG3 PCG4 PCH5 PCM2 PCP2 PCP5 PCP6 PCP326 PCV4 PCV5 PCV13 PCV14 PCV24 PCV25 PCW9 PCW10 PCZ42 PCZ43 PCZ50 PCZ51 PCZ57 PCZ58 PCZ64 PCZ65 = C_0603-S3
PCG55 PCG56 = C_D2
PCV6 PCV7 PCW11 PCZ44 PCZ45 = C_6P3X6
PCV58-PCV61 PCZ173 PCZ174 = C_X
PD3 = LUDZS3P6BT1G_SOD323-2
PDB01 PDB02 = BAS40CW_SOT323-3
PDB03 PDM3 = D_SOD323-2
PDM1 PDM2 = RB751V-40_SOD323-2
PDP1 = SX34_SMA2
PJ303 PJ306 PJPP2 = JUMP_43X39
PJ2501 PJ2502 PJM3 = JUMP_43X39_0805
PJP1 = ACES_59012-0120N-005_12P-T
PJPB1 = ACES_50279-01201-001_12P-T
PL11-PL14 = TAI-T_HCB2012KF-121T50_2P
PL301 PL302 PLV1-PLV3 PLZ1-PLZ4 = L_7X7X3_M
PL1001 PLB02 PLM1 = L_7X7X3_M_2P
PL1801 PL2501 PLF1 = CHILI_MHCD252012A-1R0M-A8S_2P
PLA1 = L_5X5X3_M
PLG1 = MAG_MMD06BZER15MEM_4P
PLH1 = L_5X5X3_M_2P
PLP1 = TAI-T_TMPC0412HP-2R2MG-Z03_2P
PLW1 = CYNTE_PCMC063T-R82MN_2P
PQ1 PQB02 PQW3 = 2N7002KW_SOT323-3
PQ2 = 2N7002KDW_SOT363-6
PQA1 PQB05 PQM1 = AONH36334_DFN3X3A8-10
PQB01 PQW2 = Q_N_DFN56-8-5
PQB03 PQB04 = AON7380_DFN3X3-8-5
PQG1 PQV1-PQV3 PQZ1-PQZ4 = AOE6930_DFN5X6E8-10
PQW1 = AON6380_DFN5X6-8-5
PR302 PR307 PR1013 PRA3 PRB11 PRB21 PRG2 PRH2 PRM3 PRV3 PRV17 PRV30 PRW13 PRZ80 PRZ83 PRZ86 PRZ89 RC14 = R_1206
PR1802 PRA1 PRA2 PRB04 PRB07 PRB13 PRB14 PRG1 PRM4 PRM5 PRP6 PRV1 PRV2 PRV6 PRV9 PRV18 PRV23 PRV24 PRW2 PRZ3 PRZ48 PRZ51 PRZ53 PRZ54 PRZ56 PRZ79 PRZ82 PRZ85 PRZ88 RG40 RWL8 = R_0603
PRB03 PRB08 = R_1206_4P-D
PTPM1 T153-T156 T158-T167 TC1 TC24-TC27 TC29 TC51-TC53 TC55 TC57 TC59 TC92-TC97 TC100-TC102 TC286 TC287 TC295 TC296 TC305 TC306 TG1-TG13 TH1-TH8 TH11 TH19 TH48 TH49 TH52 TH55-TH57 TH74 TH101 TH119-TH122 TH124 TH125 TH128 TH129 TH131 TH135 TH138 TH139 TH145-TH148 TH4942 TH4943 TH4950 TH4952-TH4954 TH4956 TH4957 TH4960 TH4962-TH4965 TH4967-TH4969 TH4972 TH4973 TPV1 TPV2 = TPC12
PU301 = SY8284BRAC_QFN20_3X3
PU302 = SY8270CTMC_QFN13_4X3
PU1001 = SY8288RAC_QFN20_3X3
PU1801 = SY8003ADFC_DFN8_2X2
PU2501 PUF1 UV1 = G5719CTB1U_SOT23-6
PUA1 = NCP81253MNTBG_DFN8_2X2
PUB01 = ISL88739AHRZ-T_QFN32_4X4
PUG1 PUZ2-PUZ5 = NCP81151MNTBG_DFN8_2X2
PUH1 = SY8286RAC_QFN20_3X3
PUM1 = RT8207PGQW_WQFN20_3X3
PUP1 = APW7237QBI-TRG_TDFN6_2X2
PUV1 = RT8813DGQW_WQFN24_4X4
PUV2 = RT9610CGQW_WDFN8_2X2
PUW1 = RT8237EZQW-2_WDFN10_3X3
PUZ1 = NCP81215MNTXG_QFN52_6X6
Q7 QC7-QC11 QV7 = L2N7002DW1T1G_SC88-6
Q32 = 2N7002K_SOT23-3
Q73 = MMBF170-7-F_SOT23-3
Q79 QA3 QG16 QV1 QWL3 = L2N7002WT1G_SC-70-3
Q80 QR2 QWL1 = 2N7002H_SOT23-3
QA2 = MMBT3904WH_SOT323-3
QC12 = MMBT3904W_SOT323-3
QG1 QG2 QG7 QG8 = DMN66D0LDW-7_SOT363-6
QG3 QG4 QG55 QG56 = MESS138W-G_SOT323-3
QG17 QS1 = 2N7002DWH_SOT363-6
QH2 = AP2302GN-HF_SOT23-3
QK1 = 2N7002_SOT23-3
QT2 = LP2305LT1G_SOT23-3
QV2 = PJT138KA_SOT363-6
QWL2 = LP2301ALT1G_SOT23-3
R5178 RL6 RS27 RS28 RS32 RS34 RU64 RV6 = R0201_0OHM
R5218 RA4 RA9 RA11 RA12 RA14-RA17 RA19 RA20 RA22-RA26 RA54 RG200 RH11 RH12 RH63 RH94 RH95 RH97 RH153 RH154 RH177 RH182 RH194 RH200 RH202 RH203 RH224 RH225 RT799-RT801 RT803 RT807-RT810 RT812-RT818 RT838-RT841 RT845-RT860 RT1111-RT1114 RV8-RV10 RV12 RV13 RV15 RV17 RV20 = R_0201
RA30-RA33 = TAI-T_HCB1608KF-221T20_2P
RA55 RH253 = MURAT_BLM15AX221SN1D_2P
RH54 RH55 RH160 = R1206_0OHM
RL55 = R0805_0OHM
TSL1 = TAI-T_LAN-8100G_25P
U7 = APX8131AI-TRG_SOT23-3
U9 = HP2DCTR_LGA12_2X2
U10 UC4 = EM5209VF_DFN14_3X2
U11 = AOZ1336DI_DFN8_2X2
U12 = G517AH1TP1U_TSOT23-6
U4019 = SN74LVC1G123DCUR_VSSOP8
UA1 = ALC3292-CG_MQFN48_6X6
UC1 = CFL-H_BGA_1440P-T
UC2 = 74AUP1G07SE-7_SOT353-5
UC3 = NCT7718W_MSOP8
UC5 UC6 = EM5201V_DFN8_3X3
UG1 = N17P-G1-A1_FCBGA_908P
UG2 UG11 = MC74VHC1G09DFT2G_SC70-5
UG4-UG7 = K4G41325FC-HC04_FBGA_170P
UG8 UG10 UG13 UG28 UG29 UH3 = NL17SZ08DFT2G_SC70-5
UG27 = TPS22966DPUR_SON14_2X3
UH1 = CNP-H_BGA_874P-T
UH2 = ACES_91960-0084L_8P-T
UK1 = KB9542Q-B_LQFP128_14X14
UL1 = RTL8118AS-CG_QFN32_4X4
UL2 = G524B1T11U_SOT23-5
UR1 = AK6627B81-MBF-GR_QFN32_4X4
US2 = TPS2546RTER_QFN16_3X3
US3 = AON7408L_DFN8-5
UT1 = SLB9670VQ1P2-FW4P4X_VQFN32_5X5
UT11 = TUSB1046-DCIRNQR_WQFN40_4X6
UU4 = TPS65987DDHRSHR_VQFN56_7X7
UU5 = W25X20CLSNIG_SO8
UV2 = PS8409QFN48GTR2-A1_QFN48_6X6
UV3 = RT9053AZQW_WDFN6_2X2
UV4 = AP2330W-7_SC59-3
YG1 = Y_XRCGB27M000F2P18R0_4P
YH1 = Y_XRCGB24M000F2P51R0_4P
YH2 = Y_X1A000141000200_2P
YL1 = Y_XRCGB25M000F2P18R0_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002DWH_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
2N7002H_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002KDW_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
2N7002KW_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(0.65,1.85) 3(-0.65,1.85)
74AUP1G07SE-7_SOT353-5
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
ACES_50203-0400C-002_40P-T
  round 1.092 hole 1.092 unplated: (-2.3,-1.95) (21.8,-1.95)
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.549x3.404 smd: 41(23.625,-5.85) 46(-4.125,-5.85)
  rect 2.007x6.198 smd: 42(19,-7.65) 43(13.5,-7.65) 44(6,-7.65) 45(0.5,-7.65)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50224-00601-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0)
  rect 1.194x1.803 smd: 7(-1.3,-3.875) 8(6.3,-3.875)
ACES_50279-01201-001_12P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0) 11(12.5,0) 12(13.75,0)
  rect 1.295x3.353 smd: 13(-2.85,-4.925) 14(16.6,-4.925)
ACES_51575-00401-001_4P
  oval 0.406x0.838 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.787x2.007 smd: 5(-2.2,-3.175) 6(5.2,-3.175)
ACES_59012-0120N-005_12P-T
  round 1.168 hole 0.762: 1(0,0) 2(0,2) 3(-2,0) 4(-2,2) 5(-4,0) 6(-4,2) 7(-6,0) 8(-6,2) 9(-8,0) 10(-8,2) 11(-10,0) 12(-10,2)
ACES_91960-0084L_8P-T
  oval 0.889x1.346 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-3.81,-7.35) 6(-2.54,-7.35) 7(-1.27,-7.35) 8(0,-7.35)
ACON_HMRA3-AK120C_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-2.75,1.7) 21(-4.65,-6.5) 22(11.75,1.7) 23(13.65,-7.75)
ACON_TCRAR-9U1391_9P-T
  round 1.194 hole 0.787: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x2.997 hole 0.787x2.388: 10(4.35,-8.7) 11(-11.35,-8.7)
  oval 1.397x2.388 hole 0.787x1.803: 12(-9.9,-0.9) 13(2.9,-0.9)
AK6627B81-MBF-GR_QFN32_4X4
  oval 0.787x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.2,-2.8) 18(4.2,-2.4) 19(4.2,-2) 20(4.2,-1.6) 21(4.2,-1.2) 22(4.2,-0.8) 23(4.2,-0.4) 24(4.2,0)
  oval 0.203x0.787 smd: 9(0.7,-3.5) 10(1.1,-3.5) 11(1.5,-3.5) 12(1.9,-3.5) 13(2.3,-3.5) 14(2.7,-3.5) 15(3.1,-3.5) 16(3.5,-3.5) 25(3.5,0.7) 26(3.1,0.7) 27(2.7,0.7) 28(2.3,0.7) 29(1.9,0.7) 30(1.5,0.7) 31(1.1,0.7) 32(0.7,0.7)
  rect 2.692x2.692 smd: 33(2.1,-1.4)
ALC3292-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AOE6930_DFN5X6E8-10
  rect 0.61x0.61 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.5) 6(2.54,5.5) 7(1.27,5.5)
  rect 0.61x1.676 smd: 8(0,4.96)
  rect 4.191x1.041 smd: 9(1.905,1.215)
  custom 0.617x0.617 smd: 10(1.905,3.465)
AON6380_DFN5X6-8-5
  oval 0.508x0.838 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,3.69)
AON7380_DFN3X3-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7408L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AONH36334_DFN3X3A8-10
  oval 0.457x0.813 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3.18) 6(1.3,3.18) 7(0.65,3.18) 8(0,3.18)
  rect 2.388x0.991 smd: 9(0.975,2.025)
  rect 2.388x0.508 smd: 10(0.975,0.92)
AOZ1336DI_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2302GN-HF_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APW7237QBI-TRG_TDFN6_2X2
  oval 0.457x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.125) 5(0.65,2.125) 6(0,2.125)
  rect 1.295x0.787 smd: 7(0.65,1.062)
APX8131AI-TRG_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
ARGOS_D4AR0-26015-1P40_260P
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,-7.9) 262(67.175,-7.9)
ARGOS_D4AS0-26010-1P40_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,-16.1) 262(-67.175,-16.1)
ARGOS_NFSM0-S6715-TPH4_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.381x1.549 smd: 3(1,0.437)
AZ5123-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZC099-04SPR7G_SOT23-6
  oval 0.559x1.092 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.5) 5(0.95,2.5) 6(0,2.5)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40CW_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54C-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAV70W_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
C_6P3X4P5
  oval 3.505x1.6 smd: 1(0,0) 2(5.6,0)
C_6P3X6
  oval 3.505x1.6 smd: 1(0,0) 2(5.6,0)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0603-S3
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CFL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) B3(-1.382,0.699) B37(-25.909,0.703) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BN2(-0.65,38.642) BN37(-25.965,38.665) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E2(-0.65,2.474) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) B5(-2.743,0.65) B34(-24.443,0.67) BK1(0,37.037) BL2(-0.65,37.438) BL38(-26.628,37.176) BM2(-0.963,38.053) BM37(-25.978,37.986) BN3(-1.3,38.701) BN36(-25.314,38.638) BP3(-1.483,39.334) BP35(-24.561,39.328) BR5(-2.166,39.984) BR34(-23.774,39.978) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) C36(-25.145,1.388) D4(-1.894,1.655) D37(-25.603,1.985) E3(-1.3,2.474) E37(-25.978,2.604) F2(-0.65,3.16) G1(0,3.581) G38(-26.628,3.671)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA11(-6.512,14.548) AA12(-7.162,14.548) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB29(-20.725,15.203) AB30(-21.376,15.203) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC11(-6.512,15.463) AC12(-7.162,15.463) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD11(-6.512,16.377) AD12(-7.162,16.377) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE11(-6.512,17.291) AE12(-7.162,17.291) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF11(-6.512,18.206) AF12(-7.162,18.206) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG11(-6.512,19.12) AG12(-7.162,19.12) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH11(-6.512,20.035) AH12(-7.162,20.035) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK29(-20.725,21.502) AK30(-21.376,21.502) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL11(-6.512,21.863) AL12(-7.162,21.863) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM11(-6.512,22.778) AM12(-7.162,22.778) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN11(-6.512,23.692) AN12(-7.162,23.692) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP11(-6.512,24.607) AP12(-7.162,24.607) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR11(-6.512,25.521) AR12(-7.162,25.521) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT11(-6.512,26.435) AT12(-7.162,26.435) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU11(-6.512,27.35) AU12(-7.162,27.35) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW11(-6.512,28.264) AW12(-7.162,28.264) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY11(-6.512,29.179) AY12(-7.162,29.179) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA11(-6.512,30.093) BA12(-7.162,30.093) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB11(-6.512,31.007) BB12(-7.162,31.007) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC11(-6.512,31.922) BC12(-7.162,31.922) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD11(-6.512,32.836) BD12(-7.162,32.836) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE29(-20.725,33.313) BE30(-21.376,33.313) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF11(-6.512,33.751) BF12(-7.162,33.751) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG11(-6.512,34.665) BG12(-7.162,34.665) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH11(-6.512,35.579) BH12(-7.162,35.579) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BK13(-7.899,36.727) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K11(-6.512,5.48) K12(-7.162,5.48) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L11(-6.512,6.319) L12(-7.162,6.319) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M11(-6.512,7.233) M12(-7.162,7.233) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N11(-6.512,8.147) N12(-7.162,8.147) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P11(-6.512,9.062) P12(-7.162,9.062) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R11(-6.512,9.976) R12(-7.162,9.976) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T11(-6.512,10.891) T12(-7.162,10.891) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U29(-20.725,11.266) U30(-21.376,11.266) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V11(-6.512,11.805) V12(-7.162,11.805) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W11(-6.512,12.719) W12(-7.162,12.719) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y11(-6.512,13.634) Y12(-7.162,13.634) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
