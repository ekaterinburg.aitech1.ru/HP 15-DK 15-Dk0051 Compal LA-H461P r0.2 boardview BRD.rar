# Allegro board LA-H461P Rev02.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
SNB_1.35VSDGPUP on BOTTOM (solid shape): 261.85,59.19 261.85,58.51 261.6,58.25 260.92,58.25 260.49,57.82 259,57.82 258.89,57.93 258.89,59.24 258.99,59.34 261.71,59.34
SNB_PH1 on TOP (solid shape): 149.69,126.45 149.69,124.8 149.62,124.74 147.72,124.74 147.66,124.8 147.66,125.44 147.72,125.5 148.54,125.5 148.61,125.56 148.61,126.45 148.67,126.52 149.62,126.52
SNB_PH2 on TOP (solid shape): 142.96,126.58 144.61,126.58 144.67,126.52 144.67,124.93 144.61,124.86 143.65,124.86 142.38,126.13 142.38,126.26 142.77,126.64 142.89,126.64
SNB_PH3 on BOTTOM (solid shape): 140.54,128.93 140.54,128.36 140.86,128.04 141.43,128.04 141.5,127.98 141.5,126.96 141.37,126.83 139.97,126.83 139.84,126.96 139.84,128.86 139.97,128.99 140.48,128.99
SNB_PH4 on TOP (solid shape): 128.48,129.5 128.48,128.23 128.41,128.17 127.91,128.17 127.87,128.2 127.87,128.7 127.89,128.72 127.89,129.19 127.65,129.44 127.21,129.44 127.14,129.37 127.14,128.74 127.08,128.67 125.43,128.67 125.37,128.74 125.37,129.75 125.56,129.94 128.03,129.94
SPK_L+_CONN on TOP (solid shape): 298.93,45.25 298.93,42.87 298.43,42.37 296.57,42.37 296.45,42.49 296.45,43.25 296.68,43.48 297.21,43.48 297.53,43.48 297.83,43.78 297.83,45.38 297.9,45.45 298.73,45.45
SPK_L+_CONN on BOTTOM (solid shape): 299.17,45.18 299.02,45.03 299.02,44.46 298.84,44.29 298.03,44.29 297.84,44.48 297.84,44.82 298.4,45.38 298.4,46.69 298.45,46.73 299.17,46.73
SPK_L-_CONN on TOP (solid shape): 300.18,44.89 300.18,41.78 298.57,40.17 297.1,40.17 297.04,40.23 297.04,41.35 297.24,41.55 298.44,41.55 299.15,42.25 299.15,44.79 299.35,44.99 300.08,44.99
SPK_L-_CONN on BOTTOM (solid shape): 300.14,45.14 300.23,45.05 300.23,44.29 300.12,44.18 299.28,44.18 299.15,44.31 299.15,44.96 299.38,45.19 299.38,46.7 299.41,46.73 300.14,46.73
SPK_OUT_L+ on TOP (solid shape): 291.19,21.54 292.36,21.54 292.41,21.49 292.41,21.38 292.36,21.33 291.22,21.33 291.04,21.16 290.3,21.16 290.15,21.31 290.15,21.46 290.3,21.61 291.11,21.61
SPK_OUT_L+ on TOP (solid shape): 292.56,43.49 292.56,42.45 292.44,42.34 290.24,42.34 290.24,42.34 290.17,42.34 290.04,42.48 290.04,43.46 290.19,43.62 292.43,43.62
SPK_OUT_L+ on IN3 (solid shape): 292.98,43.42 292.98,42.62 292.88,42.51 290.68,42.51 290.42,42.77 290.42,43.39 290.62,43.58 292.82,43.58
SPK_OUT_L+ on IN3 (solid shape): 289.13,22.14 289.74,22.14 289.97,21.9 291.31,21.9 291.42,21.79 291.42,21.47 291.21,21.26 290.21,21.26 290.1,21.37 288.39,21.37 288.16,21.6 288.16,22.02 288.28,22.15 289.12,22.15
SPK_OUT_L- on TOP (solid shape): 292.56,41.63 292.56,40.64 292.38,40.46 290.23,40.46 290.04,40.65 290.04,41.58 290.2,41.74 292.45,41.74
SPK_OUT_L- on TOP (solid shape): 292.41,21.08 292.41,20.98 292.37,20.94 291.2,20.94 290.78,20.52 290.02,20.52 289.92,20.62 289.92,20.9 290.05,21.03 291.08,21.03 291.18,21.13 292.36,21.13
SPK_OUT_L- on IN3 (solid shape): 292.87,40.56 292.87,40.46 292.28,39.87 291.66,39.87 290.47,41.06 290.47,41.3 291.09,41.92 291.51,41.92
SPK_OUT_L- on IN3 (solid shape): 288.04,21.33 288.1,21.28 288.17,21.23 288.28,21.12 288.58,21.11 288.7,21.12 289.99,21.12 290.11,21.01 291.12,21.01 291.2,20.93 291.2,20.59 291.13,20.51 289.19,20.51 288.92,20.23 287.52,20.23 287.01,20.74 287.01,20.75 287.01,20.99 287.52,21.5 287.87,21.5
SPK_OUT_R+ on TOP (solid shape): 292.56,39.6 292.56,38.61 292.47,38.52 290.66,38.52 290.33,38.85 290.33,39.54 290.56,39.77 292.4,39.77
SPK_OUT_R+ on TOP (solid shape): 292.41,20.29 292.41,20.19 292.36,20.14 291.55,20.14 290.72,19.31 290.72,19.01 290.58,18.87 289.69,18.87 289.59,18.97 289.59,19.43 289.74,19.58 290.68,19.58 291.43,20.33 292.38,20.33
SPK_OUT_R+ on IN3 (solid shape): 290.68,19.36 290.68,18.09 289.82,17.22 288.48,17.22 288.21,17.49 288.21,18.03 289.28,19.1 289.28,19.25 289.51,19.47 290.56,19.47
SPK_OUT_R+ on IN3 (solid shape): 291.6,39.57 291.6,39.2 291.47,39.07 290.65,39.07 289.81,39.92 289.44,39.92 289.34,40.02 289.34,40.92 289.42,41.01 290.16,41.01
SPK_OUT_R- on TOP (solid shape): 289.98,39.53 289.98,38.67 290.74,37.92 292.43,37.92 292.56,37.79 292.56,36.8 292.48,36.72 290.21,36.72 288.78,38.16 288.78,39.59 288.9,39.71 289.8,39.71
SPK_OUT_R- on TOP (solid shape): 292.41,20.67 292.41,20.6 292.36,20.54 291.39,20.54 290.58,19.73 289.79,19.73 289.72,19.81 289.72,20.24 289.82,20.34 290.86,20.34 291.25,20.73 292.35,20.73
SPK_OUT_R- on IN3 (solid shape): 289.91,39.4 289.91,39.11 288.76,37.97 288.64,37.97 288.09,38.52 288.09,38.8 288.87,39.58 289.73,39.58
SPK_OUT_R- on IN3 (solid shape): 290.93,19.98 290.67,19.73 289.4,19.73 288.39,18.71 287.62,18.71 287.62,19.6 288,19.98 289.02,19.98 289.3,20.26 290.93,20.26
SPK_R+_CONN on TOP (solid shape): 301.49,44.82 301.49,43.63 301.29,43.43 300.58,43.43 300.39,43.62 300.39,44.81 300.55,44.97 301.35,44.97
SPK_R+_CONN on TOP (solid shape): 300.24,40.04 300.24,39.69 298.85,38.29 297.36,38.29 297.08,38.57 297.08,39.35 297.31,39.57 298.45,39.57 299.49,40.62 299.67,40.62
SPK_R+_CONN on BOTTOM (solid shape): 301.16,46.7 301.16,45.14 301.49,44.81 301.49,44.45 301.28,44.25 300.52,44.25 300.4,44.37 300.4,46.66 300.47,46.73 301.13,46.73
SPK_R-_CONN on TOP (solid shape): 302.86,44.88 302.86,43.66 302.7,43.51 301.9,43.51 301.68,43.74 301.68,44.84 301.83,44.99 302.74,44.99
SPK_R-_CONN on TOP (solid shape): 300.39,37.89 300.39,37.62 299.13,36.36 297.25,36.36 297.08,36.52 297.08,37.21 297.29,37.42 298.66,37.42 299.67,38.43 299.85,38.43
SPK_R-_CONN on BOTTOM (solid shape): 302.37,46.63 302.37,45.66 302.77,45.25 302.77,44.59 302.56,44.38 301.81,44.38 301.66,44.53 301.66,44.88 301.48,45.06 301.48,46.69 301.52,46.73 302.27,46.73
SPOK# on TOP (solid shape): 17.61,80.54 17.61,78.51 17.48,78.38 17.1,78.38 16.97,78.51 16.97,79.4 16.85,79.53 16.59,79.53 16.46,79.65 16.46,80.54 16.59,80.67 17.48,80.67
UG_DDR on TOP (solid shape): 94.19,33.3 94.19,32.41 94.06,32.28 93.17,32.28 93.05,32.41 93.05,33.17 93.3,33.42 94.06,33.42
N15156561 on BOTTOM (solid shape): 221.1,61.28 221.1,60.73 221.25,60.58 222.48,60.58 222.65,60.41 222.65,59.92 222.55,59.81 220.93,59.81 220.55,59.44 220.45,59.44 220.45,59.44 220.37,59.53 220.37,60.65 220.48,60.76 220.48,61.38 220.51,61.4 220.98,61.4
N17572010 on BOTTOM (solid shape): 240.42,49.72 240.42,48.75 240.38,48.71 238.47,48.71 238.38,48.79 238.38,49.65 238.5,49.77 240.37,49.77
N19897204 on TOP (solid shape): outline of 81 points within 274.07,13.12 276.54,18.85
N19897238 on TOP (solid shape): 272.13,16.05 272.13,15.43 272.28,15.28 273.37,15.28 273.45,15.2 273.45,14.71 273.36,14.62 271.25,14.62 271.22,14.65 271.22,16.07 271.27,16.13 272.05,16.13
N20648577 on BOTTOM (solid shape): 236.71,26.71 236.71,26.64 236.65,26.58 235.87,26.58 235.84,26.54 235.84,26.38 235.85,26.36 236.65,26.36 236.69,26.32 236.69,26.22 236.63,26.16 236.5,26.16 236.44,26.09 236.43,26.09 236.07,25.74 236.07,24.69 236.26,24.5 236.26,24.03 236.24,24.01 235.25,24.01 235.16,24.1 235.16,26.36 235.57,26.77 235.64,26.81 236.6,26.81
N23235753 on TOP (solid shape): 276.5,12.3 276.5,10.13 276.25,9.88 274.7,9.88 274.63,9.94 274.63,12.42 274.75,12.55 276.25,12.55
N27740851 on TOP (solid shape): 45.95,43.26 45.95,43.25 46.04,43.17 46.04,39.54 45.98,39.48 45.9,39.48 45.84,39.54 45.84,40.62 45.76,40.69 44.54,40.69 44.44,40.59 44.44,39.53 44.39,39.48 44.25,39.48 44.15,39.58 44.15,40.7 44.21,40.76 44.21,43.05 44.09,43.16 43.05,43.16 42.99,43.22 42.99,43.3 43.05,43.36 43.84,43.36 43.84,43.36 45.85,43.36
N27740851 on BOTTOM (solid shape): 46.06,43.22 46.06,41.01 45.72,40.66 44.46,40.66 44.22,40.9 44.22,43.25 44.35,43.38 45.91,43.38
N27801570 on TOP (solid shape): 44.38,47.43 44.43,47.38 44.43,46.4 44.57,46.26 45.7,46.26 45.85,46.4 45.85,47.37 45.88,47.41 46.01,47.41 46.04,47.37 46.04,46.2 45.95,46.11 45.95,43.6 45.91,43.56 43.03,43.56 42.99,43.6 42.99,43.72 43.03,43.76 44.04,43.76 44.19,43.91 44.19,47.37 44.26,47.44 44.38,47.44
N27801570 on BOTTOM (solid shape): 46.08,46.06 46.08,43.66 45.99,43.57 44.28,43.57 44.18,43.68 44.18,46.1 44.26,46.19 45.96,46.19
N80922351 on BOTTOM (solid shape): 173.74,103.07 173.74,102.66 175.21,101.19 175.21,100.94 173.92,99.64 173.11,99.64 173.01,99.72 172.9,99.76 172.88,99.77 171.3,101.34 171.3,101.85 171.46,102.01 171.47,101.99 171.8,102.32 172.19,101.93 172.22,101.93 172.57,102.28 172.57,102.31 172.19,102.69 172.19,102.71 172.35,102.87 172.39,102.87 172.78,102.49 173.13,102.84 173.13,102.87 172.74,103.26 173.01,103.53 173.28,103.53
N100118189 on TOP (solid shape): 40.07,34.96 40.07,26.22 39.91,26.06 38.44,26.06 38.31,26.19 38.31,35.84 38.44,35.96 39.07,35.96

Small or netless copper shapes (teardrops, artwork): 77 on TOP, 45 on BOTTOM, 80 on IN2

## Text on the board
User.Comments: LA-H461P | 2018-11-15 | Minjia | FPC52 | REV:0.2
COMPVAL_TYPE_BOTTOM: 1 | 2 | 3 | 0.75 | 1.5 | 12 | 0.8 | 0.528 | 3.6 | 3.157 | 0.89 | 0.208 | 3.3 | 32 | 128 | 11.1 | 0.2 | 6.4 | 0.32 | 66.784 | 2.91 | 13 | 1.2 | 4
COMPVAL_TYPE_TOP: +1.05V_VCCMPHY | +1.05V_PCH_PRIM | +1.8VSDGPU_MAIN | GNDA | +5V_TYPEC | GND | +5VALW | +3VS | +5VS | +3VALW | +2.5V | +VCC_GT | +VCC_CORE | +3V_PCH_PRIM | +1.05VALW | +19VB_CPU | +0.95VS_VCCIO | +VGA_CORE | +VCC_SA
USER_PART_NUM_TOP: GND | GNDA
DEVICE_TYPE_TOP: GND | GNDA
PAGE_OUTLINE: TOP LIMIT
User.7: BOT LIMIT
User.8: 313.60 | 3.40 | 134.42 | TOP
User.9: BOT
User.11: 149.00 | 104.00 | 120.00 | 30.00 | 36.80 | 96.00 | 0.00 | 1.000 | SCALE | 2.30 | n | 4.00 | 5.50 | 177.50 | 170.00 | 165.00 | 157.00 | 130.70 | 122.40 | 1.00 | BOT PAD
User.12: 0.00 | 120.00 | 5.50 | n | 7.20 | 5.30 | 1.00 | 5.94 | 6.00 | TOP PAD
User.16: 313.60 | 134.42 | 3.40 | TOP
User.17: 0.00 | 35.34 | 112.30 | 116.85 | 121.38 | 128.45 | 145.40 | 146.45 | 149.58 | 111.52 | 112.78 | 113.15 | 134.30 | 142.95 | 147.48 | 151.00 | 167.75 | 144.83 | 96.95 | 73.22 | 94.50 | 124.30 | 129.18 | 141.65 | 85.30 | 74.96 | 2.15 | 39.40 | 73.65 | 110.75 | 125.33 | BOT
User.18: TOP LIMIT
User.19: BOT LIMIT
User.20: 5.80 | 2.80 | 0.00 | 120.00 | n | 4.00 | 5.50 | 7.20 | 2.30 | 5.30 | 157.60 | 1.00 | 5.94 | 6.00
User.21: 149.00 | 30.00 | 36.80 | 0.00 | 96.00 | 104.00 | 120.00 | 1.000 | SCALE | 5.50 | n | 177.50 | 170.00 | 165.00 | 157.00 | 132.70 | 124.40 | 1.00 | 4.00
User.22: 174.50 | 174.00 | 165.50 | 161.56 | 153.50 | 128.45 | 84.50 | 60.32 | 55.90 | 1.90 | 1.48 | 0.00 | 1.50 | 3.03 | 23.80 | 52.00 | 54.37 | 70.26 | 78.50 | 90.00 | 118.20
User.23: 0.00 | 25.00 | 33.00 | 39.67 | 43.62 | 74.00 | 79.07 | 100.01 | 106.00 | 149.90 | 153.00 | 154.90 | 2.80 | 42.83 | 46.91 | 83.47 | 90.00 | 95.25 | 108.21 | 151.00 | 2.30
User.24: 0.00 | 21.08 | 50.01 | 111.00 | 155.50 | 30.00 | 41.12 | 46.12 | 56.95 | 63.25 | 64.01 | 72.00 | 76.00 | 150.10 | 158.90 | TOP
User.34: SILKSCREEN_TOP
User.42: 7.7 | 8.5 | 8 | 6.5 | 6.1 | 6 | 5 | 5.2/4.4 | 5.5/4.5 | 6/5.5 | 5.3/5.7 | 5/5.1 | 5/5.5 | 5/6 | 5.3/8.7 | 5/7.5 | 5/7 | 4/8 | L2/L4 | L4/L7 | ref | L2 | L7 | HR_1_4mm-6L and 8L and 10L(5mil 50 ohm)_170823
User.44: FIGURE | SIZE | 8.0 | 10.0 | 16.0 | 22.0 | 30.0 | 31.0 | 35.0 | 39.0 | 91.0 | 157.0 | 26.0 | 43.0 | 63.0 | 35.0x16.0 | 43.0x20.0 | 59.0x20.0 | 63.0x24.0 | 63.0x35.0 | 71.0x31.0 | 75.0x24.0 | 94.0x31.0 | 110.0x91.0 | 33.0x26.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 8361 | 69 | 10 | 19 | 12 | 9 | 8 | 11 | 1 | 6 | 4 | 2
User.45: Excess check:Oct 12 16:27:34 2018 | PadStack_Check:Oct 12 16:22:17 2018 | XY-Check acute:Oct 11 20:29:10 2018 | XY-Check rotation:Oct 12 16:18:12 2018 | XY-Check txt overlap:Oct 12 16:15:26 2018 | XY-Create nettxt:Oct 09 13:20:50 2018 | XY-Create plane:Oct 11 17:07:51 2018 | XY-Excess check:Oct 12 16:27:34 2018 | XY-Mask check:Oct 12 16:24:43 2018 | XY-Outline check:Oct 12 16:33:23 2018 | XY-PadStack_Check:Oct 12 16:22:17 2018 | XY-Plane net check:Oct 12 16:30:19 2018 | XY-bbvia check:Oct 12 16:23:15 2018 | XY-shape pin check:Oct 12 16:26:13 2018 | XY-via check:Oct 12 16:22:27 2018 | bbvia check:Oct 12 16:23:15 2018 | check rotation:Oct 12 16:18:12 2018 | check txt overlap:Oct 12 16:15:26 2018 | create nettxt:Oct 09 13:20:50 2018 | create plane:Oct 09 19:47:52 2018 | outline check:Oct 12 16:33:23 2018 | plane net check:Oct 12 16:30:19 2018 | shape pin check:Oct 12 16:26:13 2018 | via check:Oct 12 16:22:27 2018
