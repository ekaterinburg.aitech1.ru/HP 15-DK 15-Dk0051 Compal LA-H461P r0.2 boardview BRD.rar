# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_M1_DQS#3: length 69.7
  IN1 w0.076: 135.81,76.38 135.82,76.39 135.91,76.39 136.62,77.1 136.62,84.61 137.22,85.21 137.22,85.8 136.83,86.18 136.83,87.64 136.99,87.79 136.99,87.94 136.87,88.05 v2(136.45,88.05)
  IN1 w0.127: v2(121.49,32.4) 121.49,32.18 121.62,32.06 122.06,32.06 122.18,32.18 122.18,33.04 121.55,33.68 121.55,39.77 121.26,40.06 121.26,42.74 121.55,43.02 121.55,52.37 121.26,52.66 121.26,53.99 121.85,54.58 121.85,57.46 121.26,58.05 121.26,60.65 133.89,73.28 133.89,74.46 135.81,76.38
  BOTTOM w0.076: v2(136.45,88.05) 136.32,88.05 UC1.BC9
  BOTTOM w0.127: v2(121.49,32.4) 121.49,32.04 121.3,31.85 120.99,31.85 120.68,31.54 120.68,30.72 120.93,30.46 120.93,30.22 120.78,30.06 JDIMM2.74
DDR_M1_DQS#4: length 69
  IN1 w0.076: 158.78,74.75 158.82,74.79 158.82,75.08 153.29,80.61 153.29,87.68 v2(152.91,88.05)
  IN1 w0.127: 158.78,74.75 158.78,66.64 159.43,65.99 159.43,61.54 151.72,53.83 151.72,51.2 152.31,50.61 152.31,50.08 151.21,48.98 151.21,42.9 150.27,41.96 150.27,33.55 150.68,33.13 150.87,33.13 v2(151.08,32.92)
  BOTTOM w0.076: v2(152.91,88.05) 152.78,88.05 UC1.AC9
  BOTTOM w0.127: JDIMM2.177 148.53,36.67 148.65,36.55 148.65,35.02 150.42,33.24 150.76,33.24 v2(151.08,32.92)
DDR_M1_DQS#5: length 69.1
  IN1 w0.076: v2(155.67,88.06) 155.67,87.98 156.2,87.44 156.2,86.25 156.42,86.03 156.42,81.63 157.08,80.97 157.43,80.97 159.98,78.42 160.61,78.42 163.02,76.01 163.13,76.01
  IN1 w0.127: v2(156.93,33.28) 156.84,33.18 156.69,33.18 156.44,33.43 156.44,39.17 156.52,39.25 156.52,40.92 157.51,41.91 157.51,48.06 157.91,48.46 157.91,49.47 158.33,49.9 158.33,52.29 158.54,52.5 158.54,53.71 164.54,59.71 164.54,74.61 163.13,76.01
  BOTTOM w0.076: UC1.W9 155.52,88.06 v2(155.67,88.06)
  BOTTOM w0.127: v2(156.93,33.28) 156.81,33.16 156.39,33.16 155.49,32.25 155.49,32.11 153.88,30.5 153.88,30.25 153.78,30.15 JDIMM2.198
DDR_M1_DQS#6: length 72.2
  IN1 w0.076: v2(158.4,88.05) 158.63,87.82 158.63,87.7 158.76,87.57 158.76,84.01 159.16,83.61 160.06,83.61 160.09,83.59 160.4,83.59 164.51,79.47 165.63,79.47 167.86,77.25 167.86,77.24 167.84,77.22 167.84,77.2 167.84,77.2
  IN1 w0.127: v2(162.38,32.92) 162.2,33.09 161.91,33.09 161.54,33.46 161.54,37.72 162.88,39.06 162.88,49.83 164.16,51.11 164.16,52.62 165.22,53.68 166.56,53.68 168.79,55.9 168.79,76.25 167.84,77.2
  BOTTOM w0.076: UC1.R9 158.26,88.05 v2(158.4,88.05)
  BOTTOM w0.127: JDIMM2.219 159.03,36.74 159.16,36.6 159.16,36.18 160.53,34.81 160.53,33.92 160.76,33.68 160.76,33.67 161.34,33.09 161.45,33.09 161.46,33.1 162.19,33.1 v2(162.38,32.92)
DDR_M1_DQS#7: length 81.1
  IN1 w0.076: 168.43,83.52 168.43,83.61 167.48,84.56 165.23,84.56 163.58,86.2 162.48,86.2 162.36,86.32 161.79,86.32 161.49,86.62 161.49,87.56 161.3,87.75 161.03,87.75 160.95,87.67 160.95,87.48 v2(161.09,87.34)
  IN1 w0.127: v2(166.45,33.31) 166.55,33.2 167.11,33.2 167.39,33.49 167.39,33.79 167.2,33.99 167.2,36.21 168.25,37.26 168.25,38.83 168.7,39.28 168.7,40.5 169.51,41.31 169.51,48.43 171.91,50.82 172.11,50.82 174.06,52.77 174.06,58.05 174.21,58.21 174.21,68.92 179.34,74.05 179.34,76.81 177.39,78.76 173.19,78.76 168.43,83.52
  BOTTOM w0.076: v2(161.09,87.34) 161.06,87.34 UC1.M9
  BOTTOM w0.127: JDIMM2.240 164.28,30.19 164.38,30.29 164.38,30.47 164.39,30.48 164.39,31.35 165.17,32.13 165.17,32.32 164.67,32.82 164.67,33.36 165.02,33.71 165.47,33.71 166.09,33.1 166.25,33.1 v2(166.45,33.31)
DDR_M1_MA0: length 65.4
  IN1 w0.076: 148.66,75.04 148.66,75.27 148.06,75.87 148.06,79.48 147.67,79.87 147.67,84.19 147.49,84.37 147.49,86.13 147.07,86.55 147.07,87.7 v2(147.42,88.05)
  IN1 w0.203: 148.66,75.04 148.66,72.91 149.12,72.46 149.12,66.16 140.44,57.48 140.44,53.33 139.89,52.78 139.89,49.97 139.64,49.72 139.64,49.26 139.23,48.86 139.23,35.18 138.87,34.82 138.87,31.4 139.39,30.88 v2(139.4,30.88)
  BOTTOM w0.089: v2(147.42,88.05) 147.29,88.05 UC1.AJ9
  BOTTOM w0.196: v2(139.4,30.88) 138.58,30.44 138.28,30.14 JDIMM2.144
DDR_M1_MA1: length 63.4
  IN1 w0.076: v2(145.96,85.46) 145.95,85.46 145.55,85.06 145.55,81.33 145.52,81.3 145.52,81.07
  IN1 w0.203: 145.52,81.07 145.52,70.84 145.39,70.71 145.2,70.71 145.05,70.56 145.05,70.06 145.2,69.91 145.38,69.91 145.53,69.76 145.53,69.32 145.32,69.12 145.19,69.12 145.05,68.97 145.05,68.38 145.17,68.27 145.37,68.27 145.48,68.15 145.48,67.12 145.32,66.96 144.4,66.96 143.61,66.17 143.61,65.03 136.75,58.18 136.75,54.68 136.38,54.3 136.38,51.85 136.08,51.55 135.84,51.55 135.73,51.44 135.73,38.43 135.01,37.71 135.01,34.4 134.8,34.19 v2(134.45,34.19)
  BOTTOM w0.089: v2(145.96,85.46) 146.09,85.46 UC1.AK6
  BOTTOM w0.196: v2(134.45,34.19) 135.37,34.19 136.09,34.91 136.09,36.01 135.53,36.58 JDIMM2.133
DDR_M1_MA2: length 66.7
  IN1 w0.076: v2(145.98,84.8) 145.98,74.65 146.03,74.6 146.03,74.29
  IN1 w0.203: v2(134.45,32.92) 134.51,32.92 134.75,33.15 135.11,33.15 135.21,33.05 135.21,32.37 135.43,32.16 135.69,32.16 135.9,32.36 135.9,32.9 136.08,33.08 136.42,33.08 136.63,33.29 136.63,33.56 136.4,33.79 135.64,33.79 135.51,33.92 135.51,37.5 136.23,38.22 136.23,50.99 136.89,51.64 136.89,54.09 137.26,54.46 137.26,57.97 144.52,65.22 144.52,65.43 144.24,65.71 144.24,65.99 144.52,66.28 144.81,66.28 145.02,66.08 145.37,66.08 146.46,67.17 146.46,71.32 146.03,71.75 146.03,74.29
  BOTTOM w0.076: UC1.AK5 146.03,84.8 v2(145.98,84.8)
  BOTTOM w0.196: JDIMM2.132 135.28,30.34 134.97,30.64 134.97,32.64 134.7,32.92 v2(134.45,32.92)
DDR_M1_MA3: length 65.2
  IN1 w0.076: v2(145.18,84.83) 145.28,84.74 145.28,81.68 145.01,81.42 145.01,81.07
  IN1 w0.203: 145.01,81.07 145.01,71.24 144.54,70.77 144.54,67.82 142.87,66.15 142.87,65.74 143.1,65.51 143.1,65.24 142.84,64.98 142.55,64.98 142.27,65.26 141.98,65.26 141.69,64.97 141.69,64.69 141.97,64.41 141.97,64.12 141.69,63.83 141.4,63.83 141.12,64.11 140.83,64.11 140.54,63.82 140.54,63.54 140.82,63.26 140.82,62.97 136.24,58.39 136.24,54.89 135.87,54.51 135.87,52.37 135.22,51.71 135.22,51.25 135.01,51.05 134.58,51.05 134.38,50.85 134.38,50.54 134.58,50.34 135.01,50.34 135.22,50.14 135.22,49.83 135.01,49.63 134.58,49.63 134.38,49.43 134.38,49.12 134.58,48.92 135.01,48.92 135.22,48.71 135.22,42.69 135.01,42.49 134.55,42.49 134.33,42.27 134.33,41.98 134.53,41.78 135.01,41.78 135.22,41.57 135.22,38.65 134.88,38.31 134.53,38.31 134.33,38.1 134.33,37.45 134.5,37.28 134.5,36.66 134.33,36.49 134.33,35.58 v2(134.45,35.46)
  BOTTOM w0.089: UC1.AL5 145.55,85.12 145.26,84.83 v2(145.18,84.83)
  BOTTOM w0.196: JDIMM2.131 135.03,36.25 135.59,35.68 135.59,35.12 135.4,34.92 135.07,34.92 134.88,35.12 134.88,35.26 134.68,35.46 v2(134.45,35.46)
DDR_M1_MA4: length 66.5
  IN1 w0.076: v2(145.1,85.44) 144.68,85.02 144.68,83.41 144.49,83.22 144.49,81.62 144.5,81.61
  IN1 w0.203: v2(134.45,31.65) 134.45,31.65 134.23,31.87 133.4,31.87 133.2,32.07 133.2,32.48 133.32,32.61 133.66,32.61 133.82,32.76 133.82,42.63 134.21,43.01 134.21,46.33 133.87,46.67 133.87,51.06 134.12,51.31 134.12,52.02 134.54,52.44 135.1,52.44 135.36,52.7 135.36,54.72 135.74,55.1 135.74,58.6 137.48,60.35 137.48,60.63 137.2,60.92 137.2,61.2 137.49,61.49 137.78,61.49 138.06,61.21 138.35,61.21 138.63,61.5 138.63,61.78 138.35,62.07 138.35,62.35 138.64,62.64 138.93,62.64 139.21,62.36 139.5,62.36 139.78,62.65 139.78,62.93 139.5,63.22 139.5,63.5 144.03,68.03 144.03,70.98 144.5,71.45 144.5,81.61
  BOTTOM w0.089: v2(145.1,85.44) 145.23,85.44 UC1.AL6
  BOTTOM w0.196: JDIMM2.128 134.28,30.66 133.96,30.98 133.96,31.39 134.22,31.65 v2(134.45,31.65)
DDR_M1_MA5: length 64.1
  IN1 w0.076: v2(144.31,85.48) 144.31,83.53 143.99,83.2 143.99,82.01
  IN1 w0.203: v2(133.49,30.69) 133.49,30.12 133.25,29.89 132.83,29.89 132.69,30.03 132.69,32.8 133.31,33.42 133.31,42.83 133.7,43.22 133.7,46.12 133.36,46.46 133.36,52.59 134.85,54.08 134.85,59.58 143.52,68.25 143.52,71.19 143.99,71.66 143.99,82.01
  BOTTOM w0.076: v2(144.31,85.48) 144.44,85.48 UC1.AM6
  BOTTOM w0.196: JDIMM2.126 133.78,30.38 133.49,30.67 v2(133.49,30.69)
DDR_M1_MA6: length 66.1
  IN1 w0.076: 143.42,81.96 143.42,83.03 144.11,83.73 144.11,85.11 143.93,85.28 143.93,85.7 144.5,86.27 144.64,86.27 144.66,86.25 v2(144.68,86.25)
  IN1 w0.203: 143.42,81.96 143.42,73.2 143.02,72.8 143.02,68.46 134.35,59.79 134.35,56.34 134.14,56.13 133.78,56.13 133.58,55.94 133.58,55.53 133.79,55.32 134.14,55.32 134.35,55.12 134.35,54.29 132.85,52.8 132.85,46.25 133.19,45.91 133.19,43.43 132.8,43.04 132.8,33.78 132.19,33.17 v2(131.78,33.17)
  BOTTOM w0.076: v2(144.68,86.25) 144.4,86.25 UC1.AN7
  BOTTOM w0.196: v2(131.78,33.17) 131.91,33.17 133.81,35.08 133.81,35.7 134.03,35.91 JDIMM2.127
DDR_M1_MA7: length 67.1
  IN1 w0.076: 142.4,81.76 142.4,82.91 143.12,83.63 143.12,84.29 143.5,84.67 143.5,86.22 144.33,87.04 144.33,88.35 v2(144.68,88.7)
  IN1 w0.203: v2(131.78,31.9) 131.65,31.9 131.19,32.36 131.19,42.28 131.72,42.81 131.72,50.03 130.98,51.33 130.98,53.26 131.84,54.11 131.84,58.72 142,68.89 142,73.27 142.4,73.67 142.4,81.76
  BOTTOM w0.089: UC1.AN10 144.55,88.7 v2(144.68,88.7)
  BOTTOM w0.196: v2(131.78,31.9) 132.27,31.9 132.78,31.39 JDIMM2.122
DDR_M1_MA8: length 65
  IN1 w0.076: 142.91,81.89 142.91,82.91 143.87,83.87 143.87,85.04 143.68,85.23 143.68,85.87 v2(144.65,86.84)
  IN1 w0.203: 142.91,81.89 142.91,73.41 142.51,73.01 142.51,68.68 132.34,58.51 132.34,58.03 132.55,57.82 133.44,57.82 133.63,57.63 133.63,57.22 133.42,57.01 132.55,57.01 132.34,56.81 132.34,46.03 132.68,45.7 132.68,43.64 132.29,43.25 132.29,35.68 131.7,35.09 131.7,34.52 v2(131.78,34.44)
  BOTTOM w0.076: v2(144.65,86.84) 144.42,87.08 UC1.AN8
  BOTTOM w0.196: JDIMM2.125 133.53,36.14 133.2,35.81 133.2,35.19 132.45,34.44 v2(131.78,34.44)
DDR_M1_MA9: length 65.3
  IN1 w0.076: v2(142.84,88.65) 143.17,88.22 143.21,88.16 143.21,87.82 143.07,86.47 143.07,85.85 142.75,84.88 142.75,83.97 141.9,83.12 141.6,82.09 141.15,81.64 141.15,75.07 140.98,74.44
  IN1 w0.203: 140.98,74.44 140.98,69.32 130.82,59.15 130.82,54.6 129.83,53.61 129.83,50.56 130.11,48.87 130.11,46.73 129.97,45.62 129.97,35.58 130.11,34.91 130.11,34.04 v2(130.09,34.01)
  BOTTOM w0.089: v2(142.84,88.65) 142.46,89.03 UC1.AR11
  BOTTOM w0.196: v2(130.09,34.01) 131.54,35.21 132.53,36.2 JDIMM2.121
DDR_M1_MA10: length 66.3
  IN1 w0.076: 150.2,75.08 150.2,75.29 148.95,76.53 148.95,79.96 148.46,80.44 148.46,82.55 148.24,82.77 v2(148.24,86.75)
  IN1 w0.203: v2(139.4,32.15) 139.59,31.97 139.77,31.97 139.88,31.86 139.88,31.5 140.09,31.29 140.38,31.29 140.67,31.57 140.67,32.25 140.92,32.51 140.92,36.38 141.16,36.62 141.16,48.91 141.47,49.22 141.47,52.17 141.97,52.66 141.97,56.84 150.65,65.53 150.65,73.09 150.2,73.55 150.2,75.08
  BOTTOM w0.076: v2(148.24,86.75) 148.2,86.75 UC1.AH7
  BOTTOM w0.196: v2(139.4,32.15) 139.65,32.15 140.78,31.03 JDIMM2.146
DDR_M1_MA11: length 67.9
  IN1 w0.076: 141.49,74.58 141.46,74.62 141.46,81.52 142.06,82.13 142.06,82.86 142.96,83.75 142.96,84.79 143.3,85.13 143.3,86.3 144.16,87.17 144.16,88.75 144.68,89.27 v2(144.68,89.35)
  IN1 w0.203: 141.49,74.58 141.49,69.1 131.33,58.94 131.33,54.33 130.34,53.34 130.34,50.58 131.21,49.71 131.21,43.02 130.68,42.49 130.68,31.73 v2(131.78,30.63)
  BOTTOM w0.076: UC1.AN11 144.55,89.35 v2(144.68,89.35)
  BOTTOM w0.196: JDIMM2.120 132.28,30.13 v2(131.78,30.63)
DDR_M1_MA12: length 64.5
  IN1 w0.076: v2(142.85,88.04) 142.89,88 142.89,85.94 142.58,85.63 142.58,84.17 141.46,83.06 141.46,82.32 140.87,81.73 140.87,75.14 140.48,74.74 140.48,74.52
  IN1 w0.203: v2(129.59,34.31) 129.46,34.44 129.46,46.56 129.05,46.97 129.05,53.55 130.3,54.81 130.3,59.36 140.48,69.53 140.48,74.52
  BOTTOM w0.089: UC1.AR10 142.52,88.38 v2(142.85,88.04)
  BOTTOM w0.196: JDIMM2.119 132.03,36.67 129.67,34.31 v2(129.59,34.31)
DDR_M1_MA13: length 70.2
  IN1 w0.076: v2(150.17,88.05) 150.17,88.04 149.65,87.52 149.65,86.28 149.73,86.19 149.73,83.25 150.19,82.79 150.19,77.8 152.7,75.29 152.7,75.1
  IN1 w0.203: 152.7,75.1 152.7,64.69 144,55.99 144,52.21 144.51,51.7 144.51,50.25 144.23,49.98 144.23,49.06 143.64,48.47 143.64,45.27 144.05,44.86 144.05,41.8 143.64,41.39 143.64,38.42 143.24,38.02 143.24,33.29 142.78,32.83 142.78,31.38 143.73,30.43 144.95,30.43 145.2,30.69 145.2,31.05 144.97,31.29 v2(144.08,31.29)
  BOTTOM w0.076: UC1.AF9 150.03,88.05 v2(150.17,88.05)
  BOTTOM w0.196: JDIMM2.158 143.78,30.66 144.08,30.96 v2(144.08,31.29)
DDR_M1_MA14_WE#: length 64.8
  IN1 w0.076: 152.19,75.1 152.19,75.39 149.93,77.65 149.93,80.59 149.29,81.23 149.29,82.92 148.81,83.4 148.81,86.3 148.96,86.45 148.96,87.75 148.82,87.88 148.82,88.92 148.39,89.35 v2(148.34,89.35)
  IN1 w0.203: 152.19,75.1 152.19,64.9 143.49,56.2 143.49,49.04 143.13,48.68 143.13,45.06 143.53,44.67 143.53,44.26 143.13,43.86 143.13,43.46 143.54,43.05 143.54,42.01 143.13,41.6 143.13,38.63 142.73,38.23 142.73,34.87 v2(142.5,34.64)
  BOTTOM w0.089: v2(148.34,89.35) 148.2,89.35 UC1.AH11
  BOTTOM w0.196: v2(142.5,34.64) 142.36,34.78 142.36,35.66 142.03,35.99 JDIMM2.151
DDR_M1_MA15_CAS#: length 66.9
  IN1 w0.076: v2(150.21,87.47) 149.81,87.07 149.81,86.34 149.9,86.26 149.9,83.51 150.41,83 150.41,78.06 153.1,75.38 153.1,75.04
  IN1 w0.203: 153.1,75.04 153.1,74.04 153.35,73.79 153.35,72.17 153.21,72.02 153.21,64.47 144.51,55.77 144.51,52.42 145.07,51.86 145.07,50.1 144.81,49.84 144.81,45.3 144.56,45.05 144.56,38.57 143.75,37.76 143.75,36.73 144.2,36.28 144.2,35.87 143.75,35.42 143.75,33.08 143.41,32.74 143.41,32.52 143.62,32.3 143.81,32.3 v2(144.07,32.56)
  BOTTOM w0.076: v2(150.21,87.47) 150.1,87.47 UC1.AF8
  BOTTOM w0.196: JDIMM2.156 143.28,30.82 143.35,30.9 143.35,32.23 143.69,32.56 v2(144.07,32.56)
DDR_M1_MA16_RAS#: length 66.6
  IN1 w0.076: 151.19,75.52 151.19,75.64 149.54,77.28 149.54,80.38 149.04,80.89 149.04,82.75 148.65,83.14 148.65,86.37 148.8,86.52 148.8,87.55 148.34,88.01 v2(148.34,88.7)
  IN1 w0.203: 151.19,75.52 151.19,74 151.68,73.51 151.68,65.11 142.98,56.41 142.98,49.29 142.18,48.49 142.18,42.98 142.63,42.54 142.63,41.6 142.18,41.16 142.18,36.19 141.94,35.95 141.94,32.82 v2(142.1,32.66)
  BOTTOM w0.089: v2(148.34,88.7) 148.2,88.7 UC1.AH10
  BOTTOM w0.196: JDIMM2.152 142.28,30.82 142.76,31.3 142.76,32.23 142.32,32.66 v2(142.1,32.66)
DDR_M1_ODT0: length 67.3
  IN1 w0.076: v2(150.19,86.83) 150.19,83.51 150.61,83.08 150.61,78.32 153.66,75.27
  IN1 w0.203: v2(144.61,35.08) 145.04,35.51 145.04,37.35 145.39,37.7 145.39,44.7 145.65,44.95 145.65,49.49 146.19,50.03 146.19,54.26 145.34,55.1 145.34,55.42 145.69,55.76 145.97,55.76 146.61,55.13 146.79,55.13 147.2,55.53 147.2,55.81 146.61,56.4 146.61,56.69 146.97,57.05 146.98,57.05 154.04,64.12 154.04,65.19 154.55,65.7 154.55,66.21 154.35,66.41 154.25,66.41 154.04,66.62 154.04,66.92 154.25,67.12 154.35,67.12 154.55,67.33 154.55,67.63 154.35,67.84 154.25,67.84 154.04,68.04 154.04,68.34 154.25,68.55 154.35,68.55 154.55,68.75 154.55,70.83 154.19,71.19 154.19,74.24 153.66,74.78 153.66,75.27
  BOTTOM w0.076: UC1.AF7 150.11,86.83 v2(150.19,86.83)
  BOTTOM w0.196: v2(144.61,35.08) 144.25,35.08 144.09,34.92 144.09,34.42 143.9,34.22 143.58,34.22 143.38,34.43 143.38,35.92 143.03,36.27 JDIMM2.155
DDR_M1_ODT1: length 69.8
  IN1 w0.076: 155.72,75.32 155.72,75.87 151.9,79.7 151.9,83.49 151.37,84.02 151.37,86.49 v2(151.06,86.81)
  IN1 w0.203: v2(146.57,34.82) 146.73,34.98 146.73,35.67 146.57,35.83 146.57,36.52 147.33,37.28 147.33,43.06 147.73,43.46 147.73,53.21 148.35,53.84 148.35,54.54 152.77,58.95 152.77,59.24 152.23,59.78 152.23,60.06 152.44,60.28 152.73,60.28 153.27,59.74 153.56,59.74 153.82,60 153.82,60.29 153.27,60.83 153.27,61.12 153.49,61.33 153.77,61.33 154.32,60.79 154.61,60.79 154.81,60.99 154.81,61.28 154.26,61.84 154.26,62.12 154.47,62.34 154.76,62.34 155.32,61.79 155.6,61.79 155.88,62.06 155.88,62.36 155.43,62.81 155.43,63.13 156.08,63.78 156.08,71.46 155.72,71.81 155.72,75.32
  BOTTOM w0.089: v2(151.06,86.81) 150.79,87.08 UC1.AE8
  BOTTOM w0.196: JDIMM2.161 144.53,36.54 144.72,36.35 145.53,36.35 145.73,36.15 145.73,35.85 146.02,35.56 146.02,35.28 145.74,35 145.74,34.69 145.94,34.5 146.23,34.5 146.56,34.82 v2(146.57,34.82)
DDR_M1_PAR: length 64.4
  IN1 w0.076: v2(147.42,86.75) 147.65,86.52 147.65,84.51 147.91,84.26 147.91,82.64 147.92,82.62 147.92,80.02 148.35,79.6 148.35,76.12 149.17,75.29 149.17,75.18
  IN1 w0.203: 149.17,75.18 149.17,73.13 149.63,72.67 149.63,65.95 140.95,57.27 140.95,53.12 140.46,52.63 140.46,49.82 140.15,49.51 140.15,43.69 139.74,43.28 139.74,39.53 140.15,39.12 140.15,37.07 139.91,36.83 139.91,35.14 v2(139.42,34.64)
  BOTTOM w0.089: v2(147.42,86.75) 147.29,86.75 UC1.AJ7
  BOTTOM w0.196: JDIMM2.143 138.03,36.93 138.4,36.56 138.65,36.56 138.85,36.75 138.85,37.24 139.04,37.44 139.53,37.44 139.72,37.25 139.72,36.27 139.06,35.62 139.06,35 v2(139.42,34.64)
DDR_PG_CTRL: length 10.2
  BOTTOM w0.135: UC1.BT13 127.2,90.62 126.88,90.62 126.75,90.75 124.48,90.75 124.06,91.17 v1(123.59,91.17) 122.96,91.17 122.47,90.68 122.47,88.27 122.03,87.83 120.87,87.83 120.6,88.1 UC2.2
DEVSLP0: length 3.6
  BOTTOM w0.127: UH1.AL48 188.94,25.71 188.35,26.3 TH49.1
DEVSLP1: length 184.4
  TOP w0.127: v2(38,10.25) 39.76,10.25 v1(41.99,12.48) 42.82,13.31 45.45,13.31 46.59,14.45 52.99,14.45 53.42,14.03 57.55,14.03 60.41,16.89 61.44,16.89 64.06,19.5 64.06,20.54 65.02,21.5 65.02,22.27 65.31,22.56 66.47,22.56 66.88,22.15 v2(66.88,22.01)
  IN2 w0.127: v2(66.88,22.01) 67.29,22.01 68.66,23.38 72.29,23.38 73.11,22.56 84.36,22.56 87.32,19.6 109.89,19.6 112.51,16.98 114.5,16.98 115.09,16.39 118.13,16.39 118.42,16.68 120.54,16.68 120.96,17.1 122.11,17.1 122.87,17.87 123.74,17.87 124.36,17.25 126.98,17.25 127.95,18.22 134.31,18.22 135.43,17.11 141.19,17.11 142.96,18.88 145.92,18.88 147.13,20.1 151.56,20.1 153.1,21.64 160.1,21.64 161.43,20.3 167.79,20.3 168.51,21.02 175.93,21.02 180.13,25.22 180.71,25.22 183.26,27.77 184.39,27.77 185.22,26.93 185.22,26.46 186.17,25.52 186.88,25.52 187.45,26.08 188.44,26.08 189.37,27 190.95,27 191.66,26.29 193,26.29 193.2,26.49 194.93,26.49 195.08,26.33 195.08,26.18 195.33,25.93 197.29,25.93 197.59,26.24 v2(197.59,26.38)
  BOTTOM w0.127: R5217.2 35.73,12.47 36.11,12.09 36.11,11.26 36.83,10.54 37.71,10.54 v2(38,10.25) ; UH1.AH35 197.71,26.49 v2(197.59,26.38)
DEVSLP1_R: length 26.1
  BOTTOM w0.127: JSSD1.38 26.6,3.6 26.19,4.01 25.1,4.01 21.21,7.9 21.21,10.09 21.48,10.36 31.96,10.36 33.16,11.55 v1(33.67,11.55) 34.57,11.55 R5216.2 34.75,11.73 R5217.1
DEVSLP2: length 1.5
  TOP w0.127: v2(195.51,26.38) 195.51,26.08 TH4952.1
  BOTTOM w0.127: v2(195.51,26.38) 195.32,26.57 UH1.AH40
DEVSLP4: length 2.2
  TOP w0.127: TH48.1 191.11,24.41 v2(190.81,24.11)
  BOTTOM w0.127: UH1.AR47 191.54,23.79 191.12,23.79 v2(190.81,24.11)
DEVSLP5: length 4.5
  BOTTOM w0.102: 191.25,24.75 191.72,24.29 192.06,24.29 UH1.AN46
  BOTTOM w0.127: TH52.1 189.15,25.26 189.66,24.75 191.25,24.75
DGPU_CLKREQ#: length 14.3
  BOTTOM w0.102: 192.27,84.39 195.13,84.39 UG1.AK12
  BOTTOM w0.127: 192.27,84.39 192.09,84.57 191,84.57 190.8,84.36 189.5,84.36 189.4,84.46 186.92,84.46 186.8,84.58 184.07,84.58 v1(183.94,84.45) 183.47,83.98 QG1.1 182.63,83.51 RG7.2
DGPU_HOLD_RST#: length 84.4
  IN1 w0.127: v2(233.58,48.24) 232.47,48.24 231.12,46.89 231.12,45.55 230.28,44.71 227.6,44.71 226.79,43.9 223.64,43.9 219.65,47.88 194.07,47.88 193.85,48.11 193.43,48.11 193.13,47.81 193.13,47.8 193.09,47.8 193.01,47.72 v2(193.01,47.65)
  BOTTOM w0.102: v2(193.01,47.65) 190.78,47.65 189.07,45.93 189.07,42.95 188.3,42.19 186.49,42.19 186,41.7 185.47,41.7 184.92,41.15 v1(184.92,36.71) 184.73,36.52 184.73,33.82 185.09,33.45 185.09,27.77 186.09,26.78 186.99,26.78 187.41,26.37 RH193.1 187.41,25.52 188.49,24.43 189.2,24.43 189.54,24.08 189.55,24.08 190.63,23 UH1.AT49 ; v2(233.58,48.24) 234.17,48.83 234.17,48.87 234.2,48.89 234.2,50.64 234.12,50.72 234.12,51.43 234.29,51.61 UG2.2
DGPU_PWR_EN: length 105.9
  TOP w0.127: v2(247.59,38.82) 248.55,39.78 v1(249.7,39.78) 250.64,39.78 251.28,39.14 251.28,36.96 253.31,34.93 255.39,34.93 256.99,36.53 v2(258.68,36.53) ; v2(204.02,22.82) 203.31,22.82 202.97,22.48 202.97,20.35 203.28,20.04 203.28,18.97 RH82.2
  IN2 w0.127: v2(258.68,36.53) 256.77,34.62 253.35,34.62 252.46,35.51 248.17,35.51 247.12,34.46 243.62,34.46 242.76,35.32 227.9,35.32 219.96,27.37 219.96,26.49 218.78,25.31 217.84,25.31 216.85,24.32 213.91,24.32 213.33,24.91 211.05,24.91 210.84,24.71 205.71,24.71 204.78,23.77 204.61,23.77 204.02,23.18 v2(204.02,22.82)
  IN3 w0.127: v2(247.59,38.82) 246.87,38.82 246.23,38.18 244.98,38.18 244.54,37.74 239.25,37.74 237.15,39.84 237.15,42.17 236.76,42.56 236.76,46.28 236.32,46.72 v2(236.32,46.76)
  BOTTOM w0.127: DG1.2 247.6,39.72 247.6,38.83 v2(247.59,38.82) 247.06,38.82 RG148.1 ; v2(204.02,22.82) 203.39,22.82 UH1.AU24 ; UG10.2 v2(236.32,46.76)
DGPU_PWROK: length 142.1
  TOP w0.127: v2(178.25,68.25) 178.31,68.32 178.31,68.83 183.92,74.44 185.42,74.44 v3(186.61,75.63) v2(188.11,77.13)
  IN1 w0.127: v2(237.97,48.13) 237.03,47.18 234.7,47.18 232.99,45.47 232.99,45.11 232.5,44.62 230.99,44.62 230.58,44.2 227.81,44.2 227,43.39 223.43,43.39 219.44,47.38 193.86,47.38 v2(193.64,47.6)
  IN3 w0.127: v2(178.25,68.25) 178.36,68.14 178.36,67.59 176.8,66.03 176.8,56.65 181.88,51.57 181.88,49.16 185.43,45.62 185.43,43.02 v2(186.76,41.68)
  BOTTOM w0.127: UG11.2 184.79,75.91 185.12,76.24 185.12,76.42 185.83,77.13 v2(188.11,77.13) ; v2(193.64,47.6) 193.64,47.48 193.3,47.15 190.99,47.15 189.56,45.73 189.56,42.75 188.49,41.68 v2(186.76,41.68) 186.75,41.68 186.28,41.2 185.67,41.2 185.41,40.95 185.41,36.49 185.22,36.29 185.22,34.02 185.59,33.66 185.59,28 186.61,26.99 187.27,26.99 RH164.2 188.48,27.07 188.48,27.04 189.51,26.01 191.52,26.01 UH1.AL47 ; v2(237.97,48.13) 237.91,48.19 237.91,50.23 238.24,50.56 238.24,50.88 239.18,51.83 239.18,54.47 238.89,54.76 PRW16.2
  BOTTOM w0.254: PRW16.2 238.89,55.85 238.88,55.85 PRW1.2 239.2,56.24 239.64,55.81 240.24,55.81 240.45,55.6 PUW1.1
DGPU_S_VID: length 1.2
  TOP w0.127: TG11.1 208.17,79 v2(208.62,78.56)
  BOTTOM w0.102: v2(208.62,78.56) 208.98,78.92 UG1.P5
DGPU_SEL0: length 15.2
  TOP w0.102: v2(196.96,21.63) 196.83,21.63 196.32,21.12 196.32,20.38 195.94,20 195.94,18.34 195.65,18.05 v1(195.65,17.55) 195.34,17.24 195.34,15.66 195.14,15.45
  TOP w0.127: 195.14,15.45 195.14,15.01 194.35,14.22 193.88,14.22 192.92,13.26 RH258.2 RH257.1
  BOTTOM w0.127: UH1.AV34 197.4,21.93 197.26,21.93 v2(196.96,21.63)
DGPU_SEL1: length 12.7
  TOP w0.127: v2(197.27,19.9) 196.75,19.9 196.6,19.75 196.6,19.05
  TOP w0.135: 196.6,19.05 196.68,18.97 v1(196.68,18.54) 196.66,18.52 196.66,15.81 196.33,15.47 196.33,13.05 RH155.1 197.67,11.71 RH156.2
  BOTTOM w0.127: UH1.AW32 199.01,20.83 198.83,20.65 198.14,20.65 197.95,20.46 197.95,20.15 197.7,19.9 v2(197.27,19.9)
DH_CHG_R: length 10.9
  TOP w0.127: v2(254.31,11.55) v1(255.21,11.55)
  TOP w0.508: v2(244.14,12.09) 243.64,12.58 PRB14.2
  IN3 w0.635: 252.53,11.56 251.93,12.16 250.77,12.16 250.47,11.87 244.35,11.87 v2(244.14,12.09)
  vias: v2(254.3,10.98)
DIFFOUT_2PH: length 3.1
  BOTTOM w0.203: PUZ1.35 169.03,133.26 v1(169.35,133.58) 169.35,133.95 PRZ41.2 170.2,134.5 170.26,134.44 PRZ39.1
DIFFOUT_4PH: length 6.9
  BOTTOM w0.127: PCZ17.2 172.14,122.27 v1(172.97,121.45)
  BOTTOM w0.203: PCZ17.2 171.99,122.29 PRZ36.2 171.99,123.26 170.77,124.48 170.07,124.48 169.75,124.8 169.75,125.25 169.43,125.57 PUZ1.4
DIMM1_CHA_EVENT#: length 3.6
  TOP w0.127: v2(137.73,40.01) 137.53,40.01 137.17,39.65 RD7.1
  BOTTOM w0.137: v2(137.73,40.01) 137.49,40.01 137.14,40.36 137.14,40.99 137.28,41.13 JDIMM1.134
DIMM2_CHB_EVENT#: length 3.5
  TOP w0.137: v2(135.41,31.09) 135.41,30.84 v1(135.2,30.62) 134.83,30.25 RD25.1
  BOTTOM w0.127: JDIMM2.134 135.78,30.33 135.41,30.69 v2(135.41,31.09)
DISPOFF#: length 6.4
  BOTTOM w0.127: JEDP1.21 71.05,29.2 71.47,28.77 71.47,26.8 71.79,26.48 CV18.1 71.92,26.27 73.04,25.14 RV2.2
DL_CHG: length 15.9
  TOP w0.127: v1(255.07,8.66) 254.74,8.33 253.98,8.33 253.59,7.94
  TOP w0.203: v2(241.15,10.58) 241.1,10.63 PUB01.21
  IN3 w0.635: 252.28,6.83 251.83,7.28 251.83,8.2 250.45,9.59 242.47,9.59 242.02,10.04 241.5,10.04 241.15,10.39 v2(241.15,10.58)
  vias: v2(253.31,7.18) v2(253.93,7.19)
DMI_CRX_PTX_N0: length 78.2
  IN3 w0.076: 167.73,87.1 167.65,87.1 167.19,86.64 166.42,86.64 166.19,86.87 165.66,86.87 165.55,86.98 165.55,87.13 v2(165.65,87.23)
  IN3 w0.127: 167.73,87.1 167.95,87.32 167.95,88.68 168.52,89.25 174.45,89.25 182.75,80.95 182.75,80.04 183.9,78.9 183.9,74 185.75,72.14 185.75,70.55 188.54,67.77 188.54,60.74 187.14,59.34 187.14,56.2 188.54,54.8 188.54,53.2 193.59,48.14 197.05,48.14 200.45,44.74 200.45,43.33 199.89,42.77 199.89,42.43 199.4,41.93 199.06,41.93 v2(198.84,42.16)
  BOTTOM w0.076: UH1.C33 198.5,39.51 198.61,39.51 198.88,39.79 198.88,40 199.83,40.94 199.83,41.67 199.55,41.95 199.05,41.95 v2(198.84,42.16) ; UC1.E8 v2(165.65,87.23)
DMI_CRX_PTX_N1: length 76.5
  IN3 w0.076: 168.52,86.83 168.47,86.83 167.7,86.05 165.13,86.05 164.98,86.2 v2(164.98,86.44)
  IN3 w0.127: 168.52,86.83 169.93,88.23 174.19,88.23 182.04,80.39 182.04,79.52 183.18,78.37 183.18,73.57 185.02,71.74 185.02,70.28 187.83,67.47 187.83,61.03 186.43,59.63 186.43,55.91 187.83,54.51 187.83,51.88 192.77,46.93 197.14,46.93 199.74,44.33 199.74,43.63 199.36,43.25 199.07,43.25 v2(198.84,43.48)
  BOTTOM w0.076: UC1.F6 v2(164.98,86.44) ; v2(198.84,43.48) 198.85,43.47 199.39,43.47 200.21,42.64 200.21,40.66 199.5,39.95 199.5,39.74 199.11,39.35 UH1.C32
DMI_CRX_PTX_N2: length 78
  IN3 w0.076: 167.29,84.99 167.26,85.02 166.21,85.02 165.84,85.39 165.84,85.47 v2(165.65,85.66)
  IN3 w0.127: v2(201.28,41.56) 201.17,41.67 200.51,41.67 200.2,41.36 200.2,41.06 199.62,40.49 198.92,40.49 198.08,41.32 198.08,44.84 196.75,46.17 192.49,46.17 187.05,51.62 187.05,54.27 185.71,55.61 185.71,59.93 187.05,61.27 187.05,67.22 184.27,70 184.27,71.38 182.47,73.18 182.47,78.07 181.32,79.22 181.32,80 173.86,87.45 170.61,87.45 169.81,86.65 169.81,86.01 168.78,84.99 167.29,84.99
  BOTTOM w0.076: UH1.C31 199.89,39.44 199.98,39.44 200.27,39.73 200.27,39.99 200.56,40.28 200.56,40.64 200.72,40.79 200.72,41.51 200.77,41.56 200.99,41.56 201.08,41.65 201.19,41.65 v2(201.28,41.56) ; UC1.E5 v2(165.65,85.66)
DMI_CRX_PTX_N3: length 83
  IN3 w0.076: 166.17,89.35 166.14,89.38 165.59,89.38 165.03,88.82 165.03,88.69 164.59,88.26 163.52,88.26 163.12,87.86 163.12,87.69 163.19,87.62 163.28,87.62 163.44,87.77 163.76,87.77 163.89,87.65 163.89,87.39 163.84,87.34 v2(163.57,87.34)
  IN3 w0.127: 166.17,89.35 166.99,89.35 168.3,90.65 174.15,90.65 185.28,79.52 185.28,73.92 186.47,72.72 186.47,70.88 189.25,68.09 189.25,60.44 187.85,59.04 187.85,56.5 189.25,55.1 189.25,53.55 193.93,48.87 197.34,48.87 201.01,45.2 201.44,45.2 202,44.64 202,43.33 201.87,43.2 201.64,43.2 v2(201.45,43.39)
  BOTTOM w0.076: UH1.C29 200.7,39.52 200.94,39.52 201.07,39.65 201.07,39.93 202.45,41.31 202.45,42.79 202.05,43.19 201.57,43.19 201.49,43.26 201.49,43.35 v2(201.45,43.39) ; v2(163.57,87.34) 163.57,87.37 UC1.J9
DMI_CRX_PTX_P0: length 78.2
  IN3 w0.076: 167.57,87.29 167.57,87.24 167.13,86.8 166.49,86.8 166.3,86.98 v2(166.3,87.23)
  IN3 w0.127: v2(198.84,41.58) 198.94,41.68 199.5,41.68 200.15,42.32 200.15,42.66 200.71,43.23 200.71,44.84 197.15,48.4 193.7,48.4 188.8,53.3 188.8,54.91 187.4,56.31 187.4,59.23 188.8,60.63 188.8,67.87 186.01,70.66 186.01,72.25 184.15,74.11 184.15,79 183.01,80.15 183.01,81.06 174.56,89.51 168.42,89.51 167.7,88.78 167.7,87.42 167.57,87.29
  BOTTOM w0.076: UH1.B33 198.37,39.92 198.28,39.82 198.28,39.71 198.33,39.66 198.54,39.66 198.73,39.85 198.73,40.06 199.67,41.01 199.67,41.6 199.48,41.79 198.88,41.79 198.84,41.75 v2(198.84,41.58) ; UC1.D8 v2(166.3,87.23)
DMI_CRX_PTX_P1: length 76.5
  IN3 w0.076: v2(165.65,86.44) 165.88,86.22 167.63,86.22 168.36,86.95 168.36,87.03
  IN3 w0.127: v2(198.84,42.9) 198.93,42.99 199.47,42.99 199.99,43.52 199.99,44.44 197.25,47.19 192.88,47.19 188.08,51.98 188.08,54.61 186.68,56.01 186.68,59.53 188.08,60.93 188.08,67.57 185.27,70.38 185.27,71.85 183.44,73.68 183.44,78.48 182.29,79.62 182.29,80.5 174.3,88.49 169.82,88.49 168.36,87.03
  BOTTOM w0.076: v2(198.84,42.9) 198.98,42.76 199.05,42.76 199.22,42.92 199.22,43.08 199.11,43.18 199.11,43.24 199.18,43.31 199.32,43.31 200.06,42.58 200.06,40.73 199.34,40.02 199.34,39.8 199.27,39.73 199.17,39.73 UH1.B32 ; UC1.E6 v2(165.65,86.44)
DMI_CRX_PTX_P2: length 77.9
  IN3 w0.076: v2(166.3,85.66) 166.24,85.72 166.13,85.72 166.01,85.6 166.01,85.46 166.28,85.19 167.26,85.19 167.31,85.25
  IN3 w0.127: v2(201.28,42.15) 201.06,41.93 200.4,41.93 199.94,41.47 199.94,41.17 199.52,40.74 199.03,40.74 198.34,41.43 198.34,44.95 196.85,46.43 192.6,46.43 187.31,51.72 187.31,54.38 185.97,55.72 185.97,59.82 187.31,61.16 187.31,67.33 184.53,70.11 184.53,71.49 182.73,73.29 182.73,78.18 181.58,79.33 181.58,80.11 173.97,87.7 170.5,87.7 169.55,86.75 169.55,86.12 168.68,85.25 167.31,85.25
  BOTTOM w0.076: UC1.D5 v2(166.3,85.66) ; v2(201.28,42.15) 201.28,42.07 200.93,41.72 200.71,41.72 200.56,41.57 200.56,40.85 200.41,40.7 200.41,40.34 200.12,40.05 200.12,39.79 199.92,39.59 199.85,39.59 199.77,39.67 UH1.B31
DMI_CRX_PTX_P3: length 82.9
  IN3 w0.076: 166.17,89.6 166.11,89.55 165.52,89.55 164.86,88.89 164.86,88.76 164.53,88.42 163.45,88.42 162.95,87.92 162.95,87.52 v2(162.83,87.4)
  IN3 w0.127: v2(201.45,42.71) 201.69,42.95 201.98,42.95 202.25,43.22 202.25,44.75 201.55,45.45 201.11,45.45 197.44,49.12 194.04,49.12 189.51,53.65 189.51,55.2 188.11,56.6 188.11,58.93 189.51,60.33 189.51,68.2 186.73,70.98 186.73,72.83 185.54,74.02 185.54,79.63 174.26,90.9 168.19,90.9 166.89,89.6 166.17,89.6
  BOTTOM w0.076: v2(162.83,87.4) 162.86,87.4 UC1.J8 ; v2(201.45,42.71) 201.38,42.77 201.38,42.92 201.49,43.04 201.99,43.04 202.3,42.72 202.3,41.37 200.92,39.99 200.92,39.71 200.88,39.67 200.65,39.67 200.56,39.76 200.56,39.85 UH1.B29
DMI_CTX_PRX_N0: length 73.9
  IN3 w0.127: v2(171.79,86.31) 171.57,86.31 170.87,85.6 170.87,82.73 174.05,79.55 177.07,79.55 179.66,76.96 179.66,71.93 181.59,70 181.59,68.84 184.27,66.16 184.27,62.32 183.11,61.16 183.11,54.53 184.27,53.38 184.27,49.34 186.46,47.15 186.46,43.89 188.52,41.83 192.3,41.83 195.94,38.19 195.94,37.69 196.65,36.99 197.4,36.99 197.94,36.45 197.94,35.97 197.71,35.75 197.44,35.75 v2(197.27,35.59)
  BOTTOM w0.076: v2(171.79,86.31) 171.48,86.31 171.33,86.15 170.64,86.15 169.65,87.15 167.79,87.15 167.65,87 167.65,86.91 167.73,86.83 UC1.A8
  BOTTOM w0.127: UH1.K34 v2(197.27,35.59)
DMI_CTX_PRX_N1: length 73
  IN3 w0.127: v2(172.6,85.44) 172.38,85.44 171.76,84.81 171.76,83.11 174.53,80.34 177.44,80.34 180.46,77.31 180.46,72.14 182.33,70.28 182.33,69.22 185.01,66.54 185.01,62.05 183.83,60.87 183.83,54.83 185.01,53.64 185.01,49.61 187.18,47.44 187.18,45.11 189.67,42.62 192.57,42.62 195.73,39.46 197.37,39.46 198.21,38.62 198.21,37.8 197.79,37.38 v2(197.79,37.23)
  BOTTOM w0.076: UC1.B6 167.13,86.05 167.05,86.13 167.05,86.31 167.12,86.38 168.28,86.38 168.48,86.59 169.25,86.59 169.48,86.36 169.48,86.29
  BOTTOM w0.127: UH1.G33 v2(197.79,37.23) ; v2(172.6,85.44) 172.34,85.44 171.96,85.06 170.7,85.06 169.48,86.29
DMI_CTX_PRX_N2: length 73
  IN3 w0.127: v2(173.42,84.59) 173.08,84.59 172.68,84.18 172.68,83.4 174.92,81.15 177.69,81.15 181.21,77.64 181.21,72.48 183.07,70.61 183.07,69.52 185.77,66.82 185.77,61.64 184.54,60.41 184.54,55.12 185.72,53.94 185.72,49.9 187.93,47.7 187.93,45.39 189.94,43.38 193.06,43.38 196.25,40.19 197.61,40.19 198.81,38.99 198.81,38.09 199.11,37.79 199.11,36.34 199.25,36.2 v2(199.48,36.2)
  BOTTOM w0.076: UC1.A5 167.74,85.29 167.66,85.36 167.66,85.53 167.74,85.6 168.89,85.6 169.02,85.48 169.02,85.41
  BOTTOM w0.089: v2(199.48,36.2) 199.24,35.96 UH1.K32
  BOTTOM w0.127: 169.02,85.41 170.28,84.15 172.75,84.15 173.19,84.59 v2(173.42,84.59)
DMI_CTX_PRX_N3: length 73.7
  IN3 w0.127: v2(174.31,83.7) 174.04,83.7 174.02,83.69 173.9,83.56 173.9,83.35 175.28,81.96 177.93,81.96 182,77.9 182,72.81 183.8,71.01 183.8,69.83 186.56,67.07 186.56,61.42 185.25,60.12 185.25,55.42 186.56,54.12 186.56,50.16 188.65,48.06 188.65,45.77 190.12,44.29 192.75,44.29 193.14,44.68 196.49,44.68 196.9,44.27 196.9,43.75 197.47,43.18 197.47,41.23 199.98,38.72 199.98,37.82 200.08,37.72 200.08,37.72 200.13,37.67 200.37,37.67 v2(200.4,37.7)
  BOTTOM w0.076: UH1.G30 v2(200.4,37.7) ; 168.63,84.63 168.61,84.65 168.61,84.72 168.51,84.82 167.46,84.82 167.33,84.69 167.33,84.42 167.2,84.29 167.02,84.29 166.94,84.36 UC1.B4
  BOTTOM w0.127: 168.63,84.63 168.63,84.63 169.92,83.33 173.65,83.33 174.02,83.7 v2(174.31,83.7)
DMI_CTX_PRX_P0: length 73.9
  IN3 w0.127: v2(171.37,86.72) 171.26,86.72 171.1,86.55 171.1,86.43 171.17,86.36 171.17,86.27 170.61,85.71 170.61,82.62 173.94,79.29 176.96,79.29 179.4,76.85 179.4,71.83 181.33,69.9 181.33,68.73 184.01,66.05 184.01,62.43 183.13,61.54 182.86,61.27 182.86,54.43 184.01,53.27 184.01,49.24 186.2,47.04 186.2,43.79 188.42,41.58 192.19,41.58 195.69,38.08 195.69,37.58 196.54,36.73 197.29,36.73 197.68,36.34 197.68,36.08 197.61,36.01 197.34,36.01 197.26,36.08 v2(197.26,36.17)
  BOTTOM w0.076: v2(171.37,86.72) 171.37,86.42 171.26,86.31 170.71,86.31 169.71,87.3 167.73,87.3 UC1.B8
  BOTTOM w0.127: UH1.J35 197.61,36.35 197.43,36.17 v2(197.26,36.17)
DMI_CTX_PRX_P1: length 72.9
  IN3 w0.127: v2(172.19,85.85) 172.26,85.78 172.26,85.68 171.5,84.92 171.5,83 174.42,80.08 177.33,80.08 180.21,77.2 180.21,72.03 182.07,70.17 182.07,69.11 184.75,66.43 184.75,62.16 183.57,60.97 183.57,54.72 184.75,53.54 184.75,49.5 186.93,47.33 186.93,45 189.57,42.36 192.47,42.36 195.62,39.21 197.26,39.21 197.96,38.51 197.96,37.91 197.8,37.75 197.69,37.75 v2(197.54,37.9)
  BOTTOM w0.076: UC1.C6 166.83,86.05 166.89,86.11 166.89,86.38 167.05,86.54 168.22,86.54 168.42,86.74 169.32,86.74 169.6,86.46 169.67,86.46
  BOTTOM w0.127: v2(197.54,37.9) 197.7,37.74 198.12,37.74 UH1.F34 ; 169.67,86.46 170.81,85.32 171.86,85.32 172.19,85.65 v2(172.19,85.85)
DMI_CTX_PRX_P2: length 73
  IN3 w0.127: v2(198.72,36.1) 198.85,36.23 198.85,37.68 198.55,37.98 198.55,38.88 197.5,39.93 196.15,39.93 192.95,43.12 189.83,43.12 187.67,45.28 187.67,47.59 185.47,49.8 185.47,53.83 184.28,55.02 184.28,60.52 185.51,61.75 185.51,66.72 182.81,69.41 182.81,70.51 180.95,72.37 180.95,77.53 177.59,80.89 174.82,80.89 172.42,83.29 172.42,84.29 173,84.87 v2(173,85)
  BOTTOM w0.076: UC1.B5 167.4,85.26 167.51,85.36 167.51,85.59 167.67,85.76 168.96,85.76 169.13,85.59 169.2,85.59
  BOTTOM w0.089: v2(198.72,36.1) 198.72,36.23 UH1.J32
  BOTTOM w0.127: 169.2,85.59 170.38,84.4 172.65,84.4 173.07,84.82 173.07,84.93 v2(173,85)
DMI_CTX_PRX_P3: length 73.7
  IN3 w0.127: v2(173.9,84.12) 173.9,83.93 173.64,83.67 173.64,83.24 173.8,83.08 175.17,81.71 177.83,81.71 181.74,77.79 181.74,72.7 183.54,70.9 183.54,69.72 186.3,66.96 186.3,61.53 185,60.22 185,55.31 186.3,54.01 186.3,50.05 188.4,47.96 188.4,45.66 190.02,44.04 192.86,44.04 193.24,44.43 196.39,44.43 196.65,44.16 196.65,43.64 197.21,43.08 197.21,41.13 199.73,38.61 199.73,37.61 v2(199.66,37.55)
  BOTTOM w0.076: 168.81,84.81 168.79,84.83 168.72,84.83 168.58,84.97 167.4,84.97 167.31,84.88 166.73,84.88 UC1.D4
  BOTTOM w0.089: UH1.F30 199.66,37.74 v2(199.66,37.55)
  BOTTOM w0.127: v2(173.9,84.12) 173.9,83.94 173.55,83.59 170.03,83.59 169.87,83.74 169.26,84.35 169.26,84.35 168.81,84.81
DP_HPD: length 339.9
  TOP w0.127: v2(260.39,43.83) 260.23,44 256.29,44 255.78,44.51 254.93,44.51 253.7,45.74 248.88,45.74 248.09,44.95 248.09,44.32 247.35,43.59 244.15,43.59 239.08,48.66 239.08,54.59 241.29,56.8 v2(241.29,60.26) ; v2(50.78,29.63) v1(50.78,28.88)
  IN1 w0.127: v2(59.46,25.66) 59.59,25.66 59.99,25.26 59.99,24.67 59.58,24.27 56.26,24.27 50.9,29.63 v2(50.78,29.63)
  IN2 w0.127: v2(59.46,25.66) 59.96,26.15 59.96,28.78 60.61,29.43 66.31,29.43 67.67,28.07 81.9,28.07 82.78,27.19 82.78,26.21 84.06,24.93 87.93,24.93 90.54,22.33 97.45,22.33 98.92,23.8 98.92,25.45 99.27,25.81 99.9,25.81 101.2,24.51 102.58,24.51 103.6,25.52 103.6,26.48 106.72,29.61 113.73,29.61 114.42,28.92 118.56,28.92 118.94,28.55 118.94,27.6 119.19,27.34 122.69,27.34 124.27,28.92 140.77,28.92 141.37,29.51 142.99,29.51 143.59,28.92 144.9,28.92 145.39,29.4 149.47,29.4 149.88,29.8 163.53,29.8 163.75,29.59 168.95,29.59 172.95,33.59 172.95,36.09 173.87,37.01 177.22,37.01 178.51,38.31 180.04,38.31 182.08,40.35 186.39,40.35 186.83,40.8 186.83,41.14 189.9,44.21 192.6,44.21 194.99,46.59 200.02,46.59 200.91,45.71 214.4,45.71 222.12,37.99 237.08,37.99 237.54,38.45 239.08,38.45 239.54,37.99 243.72,37.99 244.67,37.04 245.52,37.04 246.23,37.75 246.23,38.62 247.37,39.75 250.54,39.75 251.72,38.56 259.86,38.56 260.05,38.38 v2(260.11,38.38)
  IN3 w0.127: v2(24.13,51.52) 24.13,51.64 24.63,52.13 27.23,52.13 27.91,51.46 29.27,51.46 29.49,51.23 32.77,51.23 33.51,50.49 33.51,47.93 34.34,47.1 35.23,47.1 38.69,43.64 38.69,40.04 40.62,38.11 41.95,38.11 42.73,37.33 49.64,37.33 50.05,36.93 50.05,36.01 49.91,35.88 49.91,35.34 50.69,34.56 50.69,31.31 51.24,30.76 51.24,30.09 v2(50.78,29.63)
  BOTTOM w0.127: v2(241.29,60.26) 241.29,59.93 241.19,59.84 UG29.1 240.87,60.2 240.24,60.83 RG395.2 ; v2(24.13,51.52) 24.13,51.64 24.6,52.11 26.69,52.11 RT803.1 ; v2(260.11,38.38) 260.11,40.34 260.94,41.17 260.94,41.72 260.39,42.27 v2(260.39,43.83)
DP_HPD_GPU#: length 42
  IN1 w0.127: v2(218.21,65.27) 220.19,65.27 221.36,64.1 225.74,64.1 226.78,63.06 228.87,63.06 229.27,62.66 229.65,62.66 230.5,63.51 233.42,63.51 233.67,63.76 234.27,63.76 235.19,64.67 238.22,64.67 238.84,64.05 v2(238.84,63.9)
  BOTTOM w0.127: v2(238.84,63.9) 238.84,64.41 239.22,64.79 QG56.1 240.9,64.79 RG394.2 ; v2(218.21,65.27) 217.35,66.13 217.35,68.99 v1(216.52,69.81) 215.07,71.26 213.67,71.26 211.46,73.47 211.46,73.64 210.4,74.7 210.23,74.7 209.76,75.17 208.75,75.17 208.18,75.74 UG1.R1
DP_RCOMP: length 4.7
  TOP w0.127: v2(165.93,108.63) 165.94,108.63 v1(166.68,109.37)
  TOP w0.381: RC1.1 165.04,106.27 165.44,106.67 165.44,108.14 v2(165.93,108.63)
  BOTTOM w0.305: v2(165.93,108.63) 165.93,108.21 UC1.D37
DPE_AUXN_SUB1: length 40.3
  TOP w0.127: v2(8.66,51.87) 7.98,51.87 7.81,51.69 JUSBC1.A8 ; v2(18.48,53.58) 18.55,53.65 22.77,53.65 23,53.88 24.1,53.88 24.9,54.67 25.8,54.67 26.14,54.33 RT815.1 26.37,54.5 26.37,54.65 26.86,55.14 29.93,55.14 30.55,54.52 UT11.27
  IN1 w0.127: v2(18.48,53.58) 18.48,53.58 18.48,50.18 v2(18.61,50.05)
  IN3 w0.127: v2(8.66,51.87) 9.13,51.4 9.63,51.4 10.42,50.61 v2(10.42,49.02)
  BOTTOM w0.127: v2(18.61,50.05) 18.86,50.3 19.51,50.3 19.74,50.08 19.74,48.77 19.12,48.15 19.12,47.48 18.96,47.32 DU14.3 16.77,47.32 16.64,47.19 16.64,46.33 16.49,46.17 16.03,46.17 15.93,46.28 15.93,47.19 15.8,47.32 15.32,47.32 15.19,47.19 15.19,46.43 15.07,46.3 14.66,46.3 14.51,46.45 14.51,47.72 14.32,47.91 13.76,47.91 13.47,48.21 13.04,48.21 12.22,49.02 v2(10.42,49.02)
DPE_AUXP_SUB2: length 40.3
  TOP w0.127: UT11.26 30.95,54.49 30.15,55.3 RT816.1 29.99,55.65 29.75,55.41 26.75,55.41 26.33,54.99 24.84,54.99 24,54.14 22.89,54.14 22.66,53.91 18.86,53.91 18.58,54.19 18.22,54.19 17.92,53.9 v2(17.92,53.75)
  IN1 w0.076: 7.04,53.36 6.97,53.29 JUSBC1.B8
  IN1 w0.127: v2(17.92,53.75) 17.92,53.85 18.23,54.15 18.6,54.15 18.9,53.84 18.9,50.35 19.17,50.08 v2(19.17,49.88) ; v2(14.51,49.96) 14.51,50.75 14.08,51.17 14.08,53.25 12.28,55.05 8.57,55.05 7.79,54.28 7.79,54.11 7.04,53.36
  BOTTOM w0.127: v2(14.51,49.96) 15.22,49.25 DU14.2 19.33,49.25 19.45,49.36 19.45,49.76 19.32,49.88 v2(19.17,49.88)
DRAM_RESET#: length 10.6
  BOTTOM w0.102: UH1.BB46 191.54,20.11 190.4,20.11 189.62,19.33 189.62,19.03 189.55,18.96
  BOTTOM w0.127: 189.55,18.96 188.7,18.11 188.7,16.98 188.37,16.66 187.61,16.66 187.4,16.45 187,16.45 CH11.2 187,16.96 RH39.1 186.12,16.9 RH40.1 186.12,15.94 v1(185.54,15.35)
DRON: length 134.9
  TOP w0.254: PUG1.3 120.62,94.9 121.14,94.38 121.14,92.46 120.16,91.48 116.67,91.48 115.98,90.8 107.58,90.8 106.61,91.77 106.61,104.04 109.58,107.01 v3(111.82,107.01) 115.42,110.61 v2(118.39,110.61)
  IN3 w0.254: v2(162.13,128.17) 162.13,129.18 163.02,130.07 163.02,131.47 v2(160.1,134.39) 160.1,134.64 159.59,135.15 156.93,135.15 156.29,134.52 154.72,134.52 v2(152.8,136.43) 152.8,136.32 151.25,134.77 146.92,134.77 v2(145.19,136.5) 145.19,136.39 143.57,134.77 139.22,134.77 v2(137.57,136.42) 137.57,136.3 136.04,134.77 131.82,134.77 v2(130.21,136.39) 130.21,136.07 129.67,135.53 125.33,135.53 122.71,132.92 122.71,129.28 124.92,127.07 124.92,124.03 126.04,122.91 126.04,116.48 120.17,110.61 v2(118.39,110.61)
  BOTTOM w0.203: PUZ1.17 164.55,128.24 164.42,128.11 163.76,128.11 163.69,128.04 163.13,128.04 163.12,128.03 162.93,128.03 162.91,128.04 162.26,128.04 v2(162.13,128.17)
  BOTTOM w0.254: PUZ2.3 152.73,136.36 v2(152.8,136.43) ; v2(145.19,136.5) 145.11,136.42 PUZ3.3 ; PUZ5.3 130.12,136.31 v2(130.21,136.39) ; v2(137.57,136.42) 137.49,136.34 PUZ4.3 ; v2(160.1,134.39) 160.1,134.13 160.35,133.88 PUA1.3
E51RXD_P80CLK: length 181.2
  TOP w0.127: v2(149.71,9.81) 149.71,9.54 149.24,9.07 UK1.31
  IN2 w0.127: v2(149.71,9.81) 150.3,9.81 154.95,14.45 171.23,14.45 173.84,11.84 176.98,11.84 178.66,10.16 179.89,10.16 182.03,8.01 189.03,8.01 190.05,9.03 192.88,9.03 193.63,8.28 197.73,8.28 198.02,8.57 198.02,9.38 198.35,9.71 203.16,9.71 203.45,9.43 205.91,9.43 206.28,9.05 210.83,9.05 211.1,9.32 217.37,9.32 218.31,10.26 219.19,10.26 219.93,11 221.38,11 223.7,13.32 223.7,13.78 226.82,16.9 233.12,16.9 233.33,17.11 236.57,17.11 236.75,17.3 258.14,17.3 258.34,17.09 263.07,17.09 263.36,17.38 271.07,17.38 272.6,18.9 273.39,18.9 273.91,18.38 v2(275.4,18.38)
  IN3 w0.127: v2(275.4,18.38) 275.14,18.12 275.14,17.64 277.38,15.4 279.91,15.4 280.73,14.59 281.97,14.59 286.32,10.24 290.92,10.24 292.06,11.38 297.87,11.38 298.37,11.88 300.32,11.88 301.16,12.73 302.41,12.73 303.29,13.6 306.19,13.6 306.68,13.12 308.12,13.12 v2(309,13.99)
  BOTTOM w0.127: JWLAN1.32 309.49,14.85 309.37,14.74 309.37,14.37 309.35,14.34 ; v2(149.71,9.81) 149.71,9.64 v1(149.36,9.29)
  BOTTOM w0.135: 309.35,14.34 v2(309,13.99)
E51TXD_P80DATA: length 183
  TOP w0.127: RK26.1 147.77,6.99 148.66,6.99 148.84,7.16 UK1.30 148.84,9.26 149.1,9.52 v2(149.1,9.81)
  IN2 w0.127: v2(275.56,17.82) 274.09,17.82 273.28,18.63 272.71,18.63 271.18,17.11 263.47,17.11 263.19,16.82 258.23,16.82 258.03,17.03 236.86,17.03 236.68,16.85 233.45,16.85 233.23,16.63 226.94,16.63 223.97,13.67 223.97,13.21 221.49,10.73 220.04,10.73 219.3,9.99 218.42,9.99 217.48,9.05 211.21,9.05 210.94,8.79 206.17,8.79 205.8,9.16 202.08,9.16 201.71,8.79 199.02,8.79 198.25,8.01 193.52,8.01 192.77,8.76 190.16,8.76 189.14,7.74 181.92,7.74 179.77,9.89 178.55,9.89 176.87,11.57 173.73,11.57 171.12,14.19 155.06,14.19 150.14,9.26 149.65,9.26 v2(149.1,9.81)
  IN3 w0.142: v2(308.95,14.68) 308.51,15.11 307.3,15.11 307,14.81 304.1,14.81 302.29,13 292.59,13 290.95,11.37 285.75,11.37 282.25,14.86 280.84,14.86 280.01,15.7 277.48,15.7 277.04,16.13 277.04,16.13 276.87,16.3 275.56,17.62 v2(275.56,17.82)
  BOTTOM w0.127: v1(148.05,9.33) 148.62,9.33 v2(149.1,9.81) ; JWLAN1.30 309.62,15.35 v2(308.95,14.68)
EC_AMP_EAPD: length 4.2
  TOP w0.127: v1(296.63,16.89) 296.76,16.75 RA54.2
  TOP w0.203: 298.28,18.72 298.28,18.97 298.21,19.03 UA1.13
  TOP w0.381: 298.28,18.72 CA88.2 RA54.2
EC_BEEP#: length 166.5
  TOP w0.127: v2(282.09,26.71) 282.33,26.94 285.73,26.94 v1(285.77,26.91) 285.86,26.82 CA27.1 ; v2(145.6,9.81) 145.6,9.65 146.04,9.21 UK1.23
  IN2 w0.127: v2(145.6,9.81) 145.6,10.21 146.56,11.17 150.14,11.17 154.59,15.62 171.58,15.62 174.29,12.92 179.95,12.92 183.35,9.52 188.47,9.52 189.52,10.56 197.08,10.56 197.69,11.17 200.19,11.17 200.85,11.83 203.11,11.83 204.06,10.88 206.05,10.88 206.28,11.12 206.53,11.12 207.68,12.27 209.53,12.27 210.28,11.53 214.87,11.53 215.8,12.46 218.34,12.46 219.09,13.21 220.15,13.21 221.97,15.02 221.97,16.4 222.15,16.59 222.15,18.1 222.85,18.8 222.85,24.02 229.04,30.21 239.35,30.21 240.52,31.38 246,31.38 246.69,30.69 248.5,30.69 253.17,26.02 272.93,26.02 273.38,26.48 275.7,26.48 275.9,26.28 281.66,26.28 v2(282.09,26.71)
EC_BKOFF#: length 71.7
  TOP w0.127: UK1.105 134.58,19.02 134.1,19.5 134.1,19.83 133.58,20.34 133.58,20.87 v2(133.34,21.11)
  BOTTOM w0.127: RV2.1 RV3.1 74.37,23.47 76.01,23.47 76.81,22.67 v1(77.25,22.67) 83.97,22.67 87.4,19.24 97.16,19.24 99.47,21.55 99.47,23.47 100.15,24.15 101.99,24.15 103.07,25.24 103.29,25.24 103.8,25.75 104.69,25.75 104.77,25.67 105.56,25.67 106.55,24.69 109.88,24.69 111.14,23.42 113.77,23.42 114.94,22.25 124.37,22.25 125.25,21.37 132.49,21.37 132.75,21.11 v2(133.34,21.11)
EC_FAN_PWM1: length 175.2
  TOP w0.127: v2(274.18,26.01) 274.27,25.92 v3(274.83,25.92) ; v2(147.35,9.81) 147.24,9.7 UK1.26 ; RE2.2 v2(273.17,44.93)
  IN2 w0.127: v2(274.18,26.01) 273.3,26.01 273.04,25.75 253.06,25.75 248.39,30.42 246.58,30.42 245.88,31.12 240.63,31.12 239.46,29.94 229.15,29.94 223.17,23.96 223.17,18.74 222.42,17.99 222.42,13.87 221.04,12.49 220.68,12.49 220.37,12.19 215.91,12.19 214.96,11.24 211.05,11.24 210.17,10.36 208.1,10.36 207.61,10.85 206.39,10.85 206.16,10.61 203.94,10.61 203,11.56 200.96,11.56 200.31,10.9 197.8,10.9 197.19,10.29 189.63,10.29 188.58,9.25 183.24,9.25 179.84,12.65 174.18,12.65 171.55,15.28 154.63,15.28 150.25,10.9 148.09,10.9 147.35,10.16 v2(147.35,9.81)
  BOTTOM w0.127: JFAN1.3 272.99,45.11 v2(273.17,44.93) 273.17,43.79 272.74,43.36 272.74,36.91 274.18,35.47 v2(274.18,26.01)
EC_FAN_PWM2: length 155.6
  TOP w0.127: UK1.25 146.84,9.38 146.77,9.45 v2(146.77,9.82) ; v2(41.74,37.26) 43.36,37.26 v1(43.83,36.79)
  IN2 w0.127: v2(41.74,37.26) 41.78,37.22 46.03,37.22 46.5,36.75 47.82,36.75 48.89,35.67 49.52,35.67 50.07,36.22 50.62,36.22 51.02,35.82 51.02,35.6 52.33,34.28 52.33,31.89 52.04,31.61 52.04,28.44 55.07,25.41 55.07,22.72 55.93,21.85 56.86,21.85 57.45,21.27 57.45,20.83 58.34,19.94 61.12,19.94 65.09,15.97 74,15.97 76.29,13.68 92.1,13.68 92.56,13.22 94.71,13.22 95.72,14.23 97.92,14.23 98.89,13.26 98.89,11.35 101.77,8.47 113.73,8.47 114.9,9.63 116.13,9.63 116.81,10.31 124.31,10.31 124.99,9.62 126.15,9.62 126.55,10.03 126.55,10.56 126.75,10.77 132.15,10.77 134.02,8.91 146.15,8.91 146.77,9.52 v2(146.77,9.82)
  BOTTOM w0.127: RE4.2 39.97,43.58 40.23,43.84 ; 33.31,47.6 34.87,47.6 35.27,48
  BOTTOM w0.135: v2(41.74,37.26) 41.97,37.49 43.35,37.49 44.05,38.19 44.05,40.2 43.69,40.55 43.69,43.58 43.16,44.12 40.51,44.12 40.23,43.84 ; 33.31,47.6 JFAN2.3 ; RE4.2 38.08,44.49 38.08,47.01 36.92,48.17 35.44,48.17 35.27,48
EC_KBRST#: length 92.4
  TOP w0.102: RH67.1 195.92,12.95 195.83,13.04 195.83,13.79 v2(195.82,13.79) ; UK1.2 137.64,11.07 140.57,14.01 140.57,15.89 142.67,17.99 144.26,17.99 v2(144.37,18.1)
  IN1 w0.127: v2(168.54,6.31) 168.57,6.28 168.57,5.83 169.06,5.34 177.27,5.34 177.79,5.86 177.79,6.48 177.49,6.78 177.49,7.54 178.41,8.47 180.69,8.47 181.73,9.5 184.97,9.5 185.28,9.81 193.07,9.81 195.82,12.56 v2(195.82,13.79)
  BOTTOM w0.102: v2(168.54,6.31) 168.57,6.33 v1(168.57,7.15) 168.57,9 166.67,10.89 164.51,10.89 162.99,12.42 152.36,12.42 150.45,10.5 144.53,10.5 144.37,10.65 142.29,12.73 142.29,15.76 144.37,17.84 v2(144.37,18.1) ; v2(195.82,13.79) 195.82,15.07 195.41,15.49 195.41,17.2 195.66,17.45 195.66,18.64 195.74,18.72 UH1.BE39
EC_LAN_ISOLATEB#_R: length 5.2
  TOP w0.127: v1(57.46,19.19) 57.35,19.07 57.35,18.55 57.05,18.26 RM6.2 56.7,18.21 56.65,18.16 RM11.2 56,17.87 56,16.95 v2(56.34,16.61)
  BOTTOM w0.127: v2(56.34,16.61) 55.91,17.04 UL1.20
EC_MISO: length 84.9
  TOP w0.127: v2(138.88,19.05) 138.88,18.67 138.48,18.27 138.48,17.4 138.2,17.11 138.2,15.77 137.89,15.47 137.89,14.54 136.77,13.42 UK1.119
  IN3 w0.127: v2(138.88,19.05) 138.88,19.26 138.45,19.7 137.54,19.7 137.27,19.43 136.8,19.43 136.52,19.72 136.52,20.76 137.42,21.67 143.27,21.67 143.54,21.93 144.95,21.93 146.02,23.01 150.42,23.01 152.06,24.65 160.17,24.65 160.62,24.2 162,24.2 162.24,23.96 164.04,23.96 164.69,24.6 166.4,24.6 166.63,24.37 171.34,24.37 172.54,25.57 181.62,25.57 185.78,29.73 185.78,37.86 184.46,39.19 184.46,43.93 v2(184.17,44.22)
  BOTTOM w0.127: RH241.2 186.66,43.78 186.52,43.63 186.01,43.63 185.44,43.06 184.39,43.06 184.17,43.28 v2(184.17,44.22)
EC_MOSI: length 84.7
  TOP w0.127: UK1.120 137.01,13.02 138.32,14.34 138.32,15.29 138.63,15.59 138.63,16.93 138.92,17.22 138.92,18.06 v2(138.91,18.06)
  IN3 w0.127: v2(182.43,44.24) 182.65,44.03 182.65,43.83 182.65,43.82 182.65,39.77 184.92,37.5 184.92,30.47 180.88,26.43 172.18,26.43 170.98,25.24 166.99,25.24 166.76,25.47 164.33,25.47 163.68,24.82 162.6,24.82 162.36,25.06 160.98,25.06 160.53,25.51 151.7,25.51 150.06,23.87 137.53,23.87 135.65,21.99 135.65,18.92 136.4,18.17 136.4,17.7 136.67,17.43 138.28,17.43 v2(138.91,18.06)
  BOTTOM w0.127: RH240.2 183.13,43.71 v1(182.55,43.71) 182.43,43.84 v2(182.43,44.24)
EC_MUTE#: length 188.9
  TOP w0.127: UK1.83 142.44,23.06 142.74,22.76 142.74,20.93 143.62,20.05 v2(143.62,19.85) ; v2(278.92,14.14) 278.92,13.8 v1(281.6,11.12) 282.81,9.91 284.81,9.91 287.43,12.53 287.43,12.78 287.89,13.25 292.42,13.25 DA3.1
  IN2 w0.127: v2(155.23,5.97) 155.23,8.96 157.19,10.92 167.22,10.92 172.65,5.5 222.96,5.5 226.05,8.59 226.05,10.84 226.52,11.3 226.52,12.16 228.83,14.48 230.7,14.48 231.77,13.41 236.9,13.41 238.02,14.53 240.28,14.53 240.51,14.3 247.7,14.3 248.16,14.76 256.05,14.76 256.94,13.87 264.78,13.87 265.86,14.95 274.68,14.95 275.49,14.14 v2(278.92,14.14)
  BOTTOM w0.127: v2(143.62,19.85) 143.62,19.16 140.93,16.48 140.93,10.52 143.9,7.55 150.03,7.55 151.72,9.24 154.09,9.24 155.12,8.21 155.12,6.08 v2(155.23,5.97)
EC_ON: length 214.8
  TOP w0.127: D514.2 129.42,6.44 127.61,6.44 127.37,6.68 127.37,9.71 127.4,9.74 v3(127.4,11.45) 127.4,12.11 130.5,15.21 RK29.2 132.19,15.68 133.39,15.68 133.59,15.88 134.11,15.88 134.45,16.22 UK1.112 136.4,16.22 v2(136.86,16.69)
  IN1 w0.127: v2(255.65,28.81) 257.08,27.39 264.58,27.39 265.47,26.5 272.53,26.5 273.72,25.31 274.68,25.31 v2(275.28,24.71)
  IN2 w0.127: v2(275.28,24.71) 275.28,24.31 274.99,24.01 274.99,20.66 276.53,19.12 276.53,17.35 275.48,16.3 264.87,16.3 263.79,15.21 257.5,15.21 256.5,16.22 237.8,16.22 236.98,15.39 235.49,15.39 235.06,15.82 228.11,15.82 224.02,11.73 224.02,10.22 220.64,6.84 203.36,6.84 202.49,7.71 199.48,7.71 198.7,6.93 181.59,6.93 180.26,8.26 171.8,8.26 167.49,12.57 156.79,12.57 153.89,9.67 153.89,7.28 153.33,6.73 v2(153.33,5.18)
  BOTTOM w0.127: v2(153.33,5.18) 152.8,5.72 143.14,5.72 137.73,11.13 137.73,15.39 138.31,15.97 138.31,16.79 138.05,17.04 137.22,17.04 v2(136.86,16.69) ; PR310.1 255.65,29.67 v2(255.65,28.81)
EC_PCIE_WAKE#_CPU: length 4.8
  BOTTOM w0.102: 197.37,17.26 197.15,17.48 197.15,18.67 UH1.BE36
  BOTTOM w0.127: RH182.1 196.55,15.26 TH4965.1 197.29,15.77 197.49,15.97 197.49,17.14 197.37,17.26
EC_PECI: length 3.6
  TOP w0.127: RK17.1 133.43,12.71 v1(133.77,13.05) 134.05,13.05 134.82,13.82 UK1.118
