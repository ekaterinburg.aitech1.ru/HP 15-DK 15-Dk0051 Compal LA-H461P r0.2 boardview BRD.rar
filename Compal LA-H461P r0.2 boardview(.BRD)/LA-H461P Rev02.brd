# Allegro board LA-H461P Rev02.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+0.95VS_VCCIO on BOTTOM (solid shape): outline of 199 points within 161.37,92.1 164.55,102.13
+0.95VS_VCCIO on IN1 (solid shape): outline of 289 points within 160.48,90.8 164.67,101.88
+0.95VS_VCCIO on VCC: 179.09,81.22 178.11,82.19 176.46,82.19 175.09,83.57 175.09,84.08 171.64,87.53 170.24,87.53 168.72,89.05 167.95,89.05 167.57,89.43 164.02,89.43 163.02,90.43 163.02,91.57 161.88,92.71 161.88,101.77 163.28,103.17 163.28,109.26 163.51,109.5 165.29,109.5 167.06,111.28 172.57,111.28 173.18,110.66 173.18,99.7 169.12,95.63 169.12,93.01 179.41,82.72 179.41,81.54
+0.95VS_VCCIOP on BOTTOM (solid shape): 180.45,113.99 181.78,113.99 182.83,112.93 182.83,112.29 177.62,107.08 176.05,107.08 175.53,107.59 175.14,107.21 174.79,107.56 175.18,107.95 175.04,108.08 176.35,108.08 176.35,108.03 176.35,107.98 176.37,107.92 176.39,107.88 176.42,107.83 176.46,107.79 176.5,107.76 176.55,107.73 176.6,107.71 176.65,107.7 176.7,107.7 176.75,107.7 176.81,107.71 176.86,107.73 176.9,107.76 176.94,107.79 176.98,107.83 177.01,107.88 177.03,107.92 177.05,107.98 177.06,108.03 177.06,108.08 177.05,108.13 177.03,108.19 177.01,108.23 176.98,108.28 176.94,108.32 176.9,108.35 176.86,108.38 176.81,108.4 176.75,108.41 176.7,108.41 176.65,108.41 176.6,108.4 176.55,108.38 176.5,108.35 176.46,108.32 176.42,108.28 176.39,108.23 176.37,108.19 176.35,108.13 176.35,108.08 175.04,108.08 174.68,108.44 174.29,108.06 173.94,108.41 174.33,108.8 173.85,109.27 173.85,109.48 174.45,110.08 176,110.08 177.83,111.91 177.83,112.98 179.41,114.55 179.89,114.55
+1.0VSDGPU on TOP (solid shape): 201.6,81.76 201.6,81.35 201.53,81.28 201.53,81.12 201.39,80.98 201.39,80.26 201.36,80.24 200.36,80.24 200.28,80.31 200.28,80.57 200.94,81.23 201.05,81.23 201.16,81.34 201.16,81.8 201.2,81.84 201.53,81.84
+1.0VSDGPU on TOP (solid shape): 198.84,80.31 198.84,80.17 198.68,80.01 198.53,80.01 198.44,79.92 198.44,79.54 198.33,79.44 198.19,79.44 197.99,79.24 197.99,78.94 197.9,78.85 197.53,78.85 197.48,78.9 197.48,80.01 197.59,80.11 198.13,80.11 198.42,80.41 198.74,80.41
+1.0VSDGPU on TOP (solid shape): 198.63,82.67 198.63,82.66 198.63,82.26 198.62,82.23 198.58,82.21 198.52,82.21 198.46,82.19 198.25,82.19 198.08,82.02 198.08,81.39 197.87,81.18 197.87,81.02 197.74,80.9 197.62,80.9 197.04,81.48 196.47,81.48 196.38,81.57 196.13,81.57 195.94,81.75 195.94,82.3 196.01,82.37 196.02,82.37 196.24,82.6 196.84,82.6 196.84,82.62 198.1,82.62 198.1,82.63 198.18,82.63 198.25,82.7 198.6,82.7
+1.0VSDGPU on TOP (solid shape): 198.92,97.42 198.92,96.98 199.35,96.55 199.35,95.86 199.59,95.61 199.59,94.62 199.79,94.43 199.79,90.58 199.91,90.46 199.91,89.93 199.82,89.84 199.32,89.84 198.65,90.51 198.65,90.76 198.65,90.76 198.76,90.88 198.76,91.3 197.45,92.6 197.45,92.99 197.71,93.25 197.71,94.89 197.41,95.19 197.41,95.5 197.56,95.64 197.97,95.64 198.17,95.85 198.17,97.2 198.42,97.45 198.89,97.45
+1.0VSDGPU on BOTTOM (solid shape): 184.03,97.66 184.03,94.38 183.28,93.64 181.85,93.64 180.67,94.82 180.67,95.03 180.89,95.26 181.28,94.87 181.67,95.26 181.28,95.64 181.46,95.82 181.85,95.43 182.24,95.82 181.85,96.21 182.14,96.5 182.14,96.52 182.26,96.65 182.26,97.66 182.47,97.86 183.82,97.86
+1.0VSDGPU on BOTTOM (solid shape): 199.19,93.19 199.19,90.31 199.08,90.2 198.34,90.2 197.86,90.67 197.86,91.16 197.91,91.24 198,91.26 198.33,91.69 197.8,91.61 197.72,91.53 197.63,91.56 197.56,91.63 197.56,91.64 197.49,91.75 197.38,91.82 197.37,91.82 197.05,92.14 197.05,92.38 197.15,92.48 197.19,92.62 197.19,92.64 197.95,93.4 198.98,93.4
+1.0VSDGPU on IN2 (solid shape): outline of 3343 points within 181.39,78.61 201.85,101.32
+1.0VSDGPUP on BOTTOM (solid shape): 182.01,99.07 182.01,96.55 181.67,96.21 182.06,95.82 181.85,95.61 181.46,96 181.1,95.64 181.49,95.26 181.28,95.05 180.89,95.44 180.32,94.86 179.98,95.2 178.09,95.2 177.8,95.49 177.8,96.57 180.7,99.46 181.61,99.46
+1.2V_HDMI on TOP (solid shape): outline of 97 points within 20.5,56.61 30.09,65.54
+1.2V_VCCSFR_OC_OUT on TOP (solid shape): 118.04,90.18 118.6,90.18 118.6,90.21 118.68,90.21 118.83,90.06 118.83,89.31 116.5,86.98 115.2,86.98 115.07,87.1 115.07,88.86 115.09,88.88 117.48,88.88 117.9,89.29 117.9,90.14 117.97,90.21 118.04,90.21
+1.2V_VDDQ on TOP (solid shape): 108.77,73.35 108.95,73.3 109.14,73.35 112.29,73.35 112.88,72.77 112.88,69.14 112.68,68.93 107.19,68.93 106.91,69.21 106.91,72.24 107.51,72.84 107.51,72.86 108.01,73.35
+1.2V_VDDQ on TOP (solid shape): outline of 16834 points within 96.63,27.33 166.96,57.77
+1.2V_VDDQ on IN2 (solid shape): outline of 2181 points within 95.86,36.19 165.31,73.29
+1.2V_VDDQ_CPU on TOP (solid shape): outline of 8994 points within 110.43,69.24 165.05,91.59
+1.2VP on TOP (solid shape): 96.47,43.46 96.47,39.08 96.49,39.07 96.98,39.07 97.01,39.04 97.01,38.66 96.99,38.65 96.48,38.65 96.47,38.64 96.47,37.88 96.97,37.88 97.02,37.83 97.02,37.48 97,37.46 96.48,37.46 96.47,37.44 96.47,36.22 96.35,36.09 95.2,36.09 95.08,36.22 95.08,37.23 94.57,37.74 94.57,39.39 92.79,41.17 92.79,41.81 94.57,43.58 96.35,43.58
+1.2VP on BOTTOM (solid shape): 96.24,45.88 96.24,43.06 96.35,42.95 96.35,40.41 96.47,40.28 96.47,36.6 95.97,36.09 95.2,36.09 92.66,38.63 91.01,38.63 90,39.65 88.09,39.65 87.97,39.77 87.97,41.79 88.09,41.92 91.58,41.92 91.79,42.13 91.79,45.67 92.44,46.32 95.79,46.32
+1.05V_PCH on TOP (solid shape): outline of 863 points within 204.46,29.96 216.18,41.22
+1.05V_PCH on BOTTOM (solid shape): 187.87,35.27 187.87,34.38 187.7,34.21 186.58,34.21 186.43,34.37 186.42,34.45 186.39,34.52 186.39,35.2 186.52,35.33 187.82,35.33
+1.05V_PCH on BOTTOM (solid shape): 217.35,44.6 217.35,44.4 218.47,43.28 218.47,42.76 217.86,42.76 217.86,42.59 217.4,42.59 216.67,41.86 216.67,41.2 216.24,40.76 215.22,40.76 214.94,41.04 214.94,41.91 216.13,43.1 216.49,43.1 216.72,43.33 216.72,44.22 216.73,44.22 216.73,44.74 216.79,44.8 217.15,44.8
+1.05V_PCH on IN2 (solid shape): outline of 1618 points within 186.51,29.84 209.73,35.38
+1.05V_PCH_PRIM on TOP (solid shape): 205.78,38.67 205.78,38.41 205.63,38.12 205.78,37.82 205.78,35.85 205.5,35.56 205.41,35.54 205.34,35.59 204.9,35.75 204.74,35.31 204.73,35.21 204.65,35.17 204.1,35.17 203.58,35.69 203.58,36.21 203.56,36.22 203.56,37.02 203.49,37.02 203.37,37.14 203.37,38.08 203.67,38.38 203.68,38.38 203.89,38.52 203.96,38.75 203.96,38.78 204.03,38.84 205.61,38.84
+1.05V_PCH_PRIM on IN3 (solid shape): outline of 1513 points within 199.98,28.22 206.84,39.39
+1.05V_PCH_PRIM on VCC: 195.87,25.58 195.56,25.88 195.56,30.8 195.77,31.02 203.01,31.02 203.54,31.54 203.54,38.91 203.77,39.14 208.26,39.14 209.78,37.62 210.5,37.62 210.63,37.74 211.18,37.74 212.04,36.87 212.04,31.75 210.77,30.48 210.77,28.87 211.41,28.24 211.41,26.74 210.24,25.58
+1.05V_VCCAMPHYPLL on BOTTOM (solid shape): 189.66,39.65 189.91,39.55 190.15,39.65 190.71,39.65 190.84,39.52 190.84,38.63 190.58,38.38 187.79,38.38 187.66,38.25 187.66,36.6 187.91,36.35 187.91,35.73 187.85,35.67 186.94,35.67 186.85,35.58 186.36,35.58 186.21,35.74 186.21,39.34 186.52,39.65
+1.05V_VCCMPHY on TOP (solid shape): outline of 497 points within 197.26,31.39 203.24,39.29
+1.05V_VCCMPHY on VCC: 195.76,31.53 195.56,31.73 195.56,38.6 196.1,39.14 202.79,39.14 203.03,38.91 203.03,31.75 202.8,31.53
+1.05V_VCCSFR on TOP (solid shape): 163.2,102.93 163.2,101.85 162.82,101.47 162.34,101.47 162.11,101.7 162.11,102.81 162.12,102.92 162.11,103.07 162.18,103.14 162.21,103.13 162.4,103.11 162.57,103.19 162.58,103.2 162.62,103.2 162.62,103.23 162.63,103.25 162.88,103.25
+1.05V_VCCSTU on TOP (solid shape): 253.61,41.48 253.61,40.22 253.56,40.17 253.45,40.17 253.4,40.21 253.4,40.89 253.36,40.93 253.25,40.93 253.21,40.9 253.21,40.2 253.16,40.15 253.01,40.15 252.34,40.82 251.66,40.82 251.62,40.85 251.62,41.47 251.86,41.71 253.38,41.71
+1.05V_XTAL on BOTTOM (solid shape): 214.75,34.51 214.75,34.4 214.39,34.04 213.97,34.04 213.96,34.04 213.87,33.94 213.09,33.94 212.91,34.12 212.91,34.26 213.11,34.45 214.07,34.45 214.2,34.59 214.59,34.59 214.64,34.63
+1.05VALW on TOP (solid shape): 253.61,38.85 253.61,38.08 253.22,37.68 253.22,37.51 253.1,37.39 252.3,37.39 251.84,37.85 251.84,38.56 251.87,38.59 252.8,38.59 253.09,38.88 253.17,38.88 253.21,38.83 253.21,38.21 253.24,38.18 253.39,38.18 253.41,38.2 253.41,38.85 253.43,38.88 253.58,38.88
+1.05VALW on TOP (solid shape): 178.08,107.95 178.08,106.09 178.39,105.79 178.95,105.79 179.07,105.66 179.07,105.27 178.95,105.05 179.01,104.8 179.04,104.76 178.92,104.65 176.53,104.65 176.46,104.72 176.46,107.06 175.93,107.58 175.93,108.29 176.05,108.4 176.46,108.4 177.63,108.4
+1.05VALW on TOP (solid shape): 229.43,25.15 229.43,22.05 229.42,22.04 228.89,22.04 228.88,22.03 228.88,21.29 228.89,21.28 229.41,21.28 229.43,21.26 229.43,20.87 229.41,20.85 228.89,20.85 228.88,20.83 228.88,20.09 228.89,20.08 229.4,20.08 229.43,20.05 229.43,19.43 229.37,19.37 226.77,19.37 226.6,19.54 226.6,20.93 226.49,21.04 225.53,21.04 225.41,21.16 225.41,25.28 225.72,25.59 229,25.59
+1.05VALW on TOP (solid shape): 208.33,42.18 208.33,42.17 208.4,42.06 208.51,41.99 208.52,41.98 209.02,41.49 209.02,41.48 209.06,41.38 209.13,41.3 209.13,40.09 209.05,40.01 207.49,40.01 207.43,40.07 207.43,41.1 207.36,41.17 207.35,41.18 207.14,41.4 206.83,41.37 206.82,41.36 206.77,41.36 206.61,41.21 206.58,41.22 206.19,41.15 206.11,40.75 206.12,40.72 205.84,40.44 203.97,40.44 203.94,40.41 203.94,40.11 203.81,39.98 201.51,39.98 201.4,40.08 201.4,41.06 201.52,41.18 202.01,41.18 202.23,41.4 202.23,41.46 202.24,41.47 202.25,41.56 202.24,41.66 202.23,41.67 202.23,42.04 202.24,42.05 202.25,42.15 202.24,42.25 202.23,42.25 202.23,42.96 202.71,43.43 207.07,43.43
+1.05VALW on IN3 (solid shape): 253.28,37.15 253.03,36.91 251.9,36.91 251.11,36.12 250.92,36.12 250.18,36.87 250.18,37.04 251.01,37.87 253.28,37.87
+1.05VALW on IN3 (solid shape): 227.58,27.06 227.58,26.8 227.15,26.37 227.15,21.22 227.11,21.22 226.96,21.07 225.76,21.07 225.43,21.4 225.43,26.51 226.43,27.51 227.13,27.51
+1.05VALW on VCC: 218.31,20.34 211.92,26.74 211.92,28.45 211.28,29.08 211.28,30.27 212.55,31.54 212.55,37.09 211.39,38.25 210.41,38.25 210.29,38.12 209.99,38.12 208.47,39.65 202.5,39.65 202.27,39.88 202.27,44.88 202.5,45.11 218.29,45.11 234.27,29.13 234.27,21.59 233.4,20.72 219.02,20.69 218.67,20.34
+1.05VALWP on TOP (solid shape): 234.1,23.11 234.1,18.39 233.9,18.19 229.77,18.19 229.59,18.37 229.59,20.24 229.59,20.24 229.07,20.24 229.04,20.26 229.04,20.66 229.06,20.68 229.59,20.68 229.59,20.68 229.59,21.43 229.59,21.44 229.06,21.44 229.04,21.45 229.04,21.86 229.05,21.87 229.59,21.87 229.59,21.88 229.59,23.24 229.65,23.3 233.91,23.3
+1.05VALWP on BOTTOM (solid shape): 235.3,22.88 235.3,18.08 234.89,17.66 233.14,17.66 232.83,17.35 232.83,17.35 232.5,17.02 228.28,17.02 227.79,17.51 227.79,22.63 228.12,22.97 234.02,22.97 234.28,23.23 234.95,23.23
+1.05VS_VCCSTG on TOP (solid shape): 176.2,106.4 176.2,104.85 176.1,104.75 174.78,104.75 174.69,104.8 174.69,104.91 174.68,105.34 174.26,105.44 174.17,105.45 174.12,105.54 174.12,105.97 174.2,106.04 175.11,106.04 175.52,106.45 176.15,106.45
+1.8V_PHVLDO on TOP (solid shape): 204.43,29.09 204.52,29.11 206.08,29.11 206.2,28.98 206.2,28.47 206.08,28.34 204.17,28.34 204.04,28.47 204.04,28.98 204.17,29.11 204.34,29.11
+1.8V_PRIM on TOP (solid shape): 220.34,22.12 220.34,22.02 220.34,22.02 220.34,21.46 220.22,21.35 218.91,21.35 218.67,21.59 218.67,22.39 218.85,22.57 219.89,22.57
+1.8V_PRIM on TOP (solid shape): 208.62,24.53 208.62,24.03 208.49,23.9 207.85,23.9 207.73,23.77 207.73,22.12 207.85,21.99 208.62,21.99 208.74,21.87 208.74,21.65 208.66,21.44 208.74,21.22 208.74,19.84 208.62,19.71 208.36,19.71 208.23,19.84 208.23,20.72 208.2,20.76 208.2,20.78 208.18,20.78 207.1,21.86 207.1,21.87 207.04,21.95 206.96,22.01 206.96,23.14 206.76,23.34 206.76,23.36 206.59,23.63 206.26,23.65 206.25,23.65 206.2,23.65 206.08,23.77 206.08,24.28 206.2,24.41 206.84,24.41 207.09,24.66 208.49,24.66
+1.8V_PRIM on BOTTOM (solid shape): 219.61,22.45 219.61,22.19 219.07,21.65 219.07,20.94 219,20.87 218.29,20.87 217.81,21.35 217.81,21.86 217.91,21.96 218.22,21.96 218.39,22.12 218.39,22.16 218.47,22.16 218.47,22.31 218.68,22.52 219.53,22.52
+1.8V_PRIM on IN1 (solid shape): outline of 623 points within 207,20.77 219.77,24.78
+1.8V_PRIM on IN2 (solid shape): 220.44,22.51 220.44,22.13 220.3,21.98 218.7,21.98 218.54,22.14 218.54,22.44 218.71,22.61 220.35,22.61
+1.8VALW on TOP (solid shape): 222.39,22.78 222.39,22.72 221.12,21.44 220.72,21.44 220.65,21.51 220.65,22.82 221.32,23.48 221.68,23.48
+1.8VALW on TOP (solid shape): 223.75,34.11 223.75,32.03 223.57,31.85 223.01,31.85 222.74,32.13 222.74,34.14 222.96,34.37 223.5,34.37
+1.8VALW on TOP (solid shape): 256.05,38.9 256.98,38.9 257.15,38.73 257.15,37.7 256.92,37.48 255.75,37.48 255.01,38.22 255.01,38.83 255.08,38.9 255.19,38.9 255.21,38.88 255.21,38.25 255.24,38.22 255.37,38.22 255.4,38.26 255.4,38.83 255.47,38.9 255.73,38.9 255.73,38.9 256.04,38.9
+1.8VALW on BOTTOM (solid shape): 261.3,28.22 261.3,25.31 260.94,25.31 260.94,25.89 260.38,25.89 260.38,25.31 260.17,25.31 260.17,25.88 259.6,25.88 259.6,25.31 258.65,25.31 258.45,25.51 258.45,27.88 258.97,28.41 261.11,28.41
+1.8VALW on BOTTOM (solid shape): 243.33,41.9 243.33,41.13 242.93,40.74 242.91,40.74 242.91,40.72 242.77,40.58 242.77,40.27 242.52,40.27 242.05,39.8 242.05,39.01 241.95,38.92 241.25,38.92 240.95,39.22 240.95,39.91 240.83,40.03 240.29,40.03 240.1,40.22 240.1,40.89 240.48,41.27 242.04,41.27 242.73,41.96 243.27,41.96
+1.8VALW on BOTTOM (solid shape): 245.44,41.93 245.49,41.9 245.64,41.74 245.64,41.74 245.89,41.49 247.18,41.49 247.42,41.24 247.56,41.24 247.73,41.08 247.73,40.64 247.47,40.38 245.52,40.38 245.26,40.64 245.16,40.94 244.87,41.05 244.87,41.05 244.72,41.2 244.72,41.91 244.74,41.93
+1.8VALW on BOTTOM (solid shape): 257.6,37.89 257.6,35.39 257.49,35.29 255.94,35.29 255.55,35.68 255.55,37.72 255.6,37.81 255.71,37.8 255.94,37.74 256.15,37.84 256.19,37.85 256.22,37.84 256.57,37.75 256.81,38.01 256.82,38.04 257.44,38.04
+1.8VALW on IN2 (solid shape): 225.25,35.16 225.25,34.55 223.65,32.95 222.84,32.95 222.74,33.05 222.74,34.11 222.98,34.36 223.61,34.36 224.61,35.36 225.05,35.36
+1.8VALW on IN2 (solid shape): 253.72,37.95 253.81,37.89 253.8,37.79 254.09,37.23 254.38,37.79 254.37,37.89 254.46,37.95 255.59,37.95 255.84,37.75 256.15,37.84 256.19,37.85 256.22,37.84 256.53,37.75 256.79,37.95 256.96,37.95 257.11,37.79 257.11,37.27 255.36,35.51 254.79,35.51 254.71,35.55 254.69,35.64 254.35,36.09 254.01,35.64 253.99,35.55 253.91,35.51 253.49,35.51 252.76,36.24 252.4,36.24 252.4,37.27 252.44,37.28 252.52,37.31 252.59,37.36 252.66,37.38 252.72,37.36 253.17,37.35 253.26,37.8 253.27,37.9 253.35,37.95
+1.8VALW on IN3 (solid shape): outline of 537 points within 240.12,37.26 257.55,43.09
+1.8VALWP on BOTTOM (solid shape): 261.68,24.83 261.68,24.32 260.02,22.67 260.02,21.99 260.23,21.78 260.23,17.31 260.03,17.11 257.89,17.11 257.77,17.23 257.77,23.88 259.04,25.16 261.35,25.16
+1.8VS on TOP (solid shape): 256.77,42.6 256.9,42.57 257.04,42.59 257.05,42.59 257.3,42.59 258.02,41.87 258.02,40.96 257.96,40.9 256.87,40.9 256.87,40.91 256.03,40.91 256.03,40.82 255.62,40.41 255.62,40.26 255.52,40.16 255.47,40.16 255.41,40.21 255.41,40.84 255.36,40.88 255.25,40.88 255.21,40.84 255.21,40.19 255.17,40.16 255.08,40.16 255.01,40.22 255.01,41.22 255.23,41.44 255.23,42.54 255.29,42.6 256.76,42.6
+1.8VSDGPU_AON on TOP (solid shape): 213.28,82.79 213.28,81.81 213.56,81.53 213.89,81.53 213.97,81.45 213.97,80.69 213.91,80.63 213.33,80.63 213.29,80.68 211.64,80.68 211.55,80.77 211.55,82.17 211.68,82.3 212.14,82.3 212.27,82.43 212.27,82.76 212.37,82.86 213.21,82.86
+1.8VSDGPU_AON on BOTTOM (solid shape): 213.23,82.74 213.23,81.68 213.35,81.56 213.35,81.36 213.26,81.28 212.28,81.28 212.2,81.35 212.2,82.74 212.29,82.83 213.14,82.83
+1.8VSDGPU_AON on BOTTOM (solid shape): 247.76,44.96 247.76,43.49 247.65,43.38 245.5,43.38 245.33,43.21 244.81,43.21 244.7,43.31 244.7,44.37 244.79,44.46 244.9,44.46 244.9,45.04 245.08,45.21 247.5,45.21
+1.8VSDGPU_AON on IN2 (solid shape): outline of 3962 points within 211.93,44.08 247.64,82.29
+1.8VSDGPU_AON on IN3 (solid shape): outline of 2582 points within 211.68,43.31 247.7,83.89
+1.8VSDGPU_AON on IN2: 43.86,43.41 48.04,43.41 48.96,42.49 48.96,41.24 48.45,40.73 44.65,40.73 43.5,41.87 43.5,43.05
+1.8VSDGPU_AON on IN3: 212.86,94.03 213.97,94.03 214.47,93.54 214.47,87.91 213.91,87.35 213.13,87.35 212.87,87.62 212.87,88.02 213.04,88.2 213.04,93.35 212.73,93.66 212.73,93.9
+1.8VSDGPU_MAIN on TOP (solid shape): 210.79,82.8 210.79,82.35 210.93,82.22 211.24,82.22 211.32,82.14 211.32,81.89 210.61,81.18 210.17,81.18 210.04,81.31 210.04,82.5 210.4,82.85 210.74,82.85
+1.8VSDGPU_MAIN on TOP (solid shape): outline of 442 points within 191.38,81.2 199.83,98.27
+1.8VSDGPU_MAIN on BOTTOM (solid shape): 242.3,44.63 242.97,44.63 243.33,44.26 243.33,43.31 243.24,43.23 242.57,43.23 242.4,43.4 240.45,43.4 239.73,44.11 239.73,44.89 240.04,45.19 241.73,45.19
+1.8VSDGPU_MAIN on BOTTOM (solid shape): outline of 244 points within 196.96,84.18 199.19,90.49
+1.8VSDGPU_MAIN on BOTTOM (solid shape): outline of 525 points within 187.48,95.4 198.42,98.47
+1.8VSDGPU_MAIN on IN3 (solid shape): outline of 1398 points within 189.23,84.01 200.63,98.1
+1.8VSDGPU_MAIN on VCC: 240.22,43.84 232.87,51.18 232.87,54.14 232.87,54.35 232.72,54.5 231.89,55.34 229,55.34 224.52,59.82 189.51,59.82 188.45,60.88 188.45,60.88 188.3,61.03 188.3,61.03 187.37,61.96 187.37,95.22 190.13,98.02 190.18,98.07 191.75,98.07 192,97.81 196.82,97.81 197.58,97.03 197.58,97.03 197.65,96.96 197.73,96.88 197.73,96.88 197.87,96.74 197.87,96.03 193.67,91.83 193.51,91.83 193.51,65.81 194.83,64.48 218.47,64.48 221.57,67.59 222.09,67.59 225.02,64.67 243.31,64.67 243.54,64.43 243.54,44.71 242.67,43.84
+1.35VRAMP on TOP (solid shape): 246.54,64.06 246.92,64.44 246.94,64.44 247.25,64.13 246.85,63.74 247.4,63.19 247.78,63.57 248.06,63.29 248.06,63.27 247.71,62.91 247.71,62.89 250.3,60.3 250.68,60.68 250.98,60.37 250.6,59.99 250.6,59.97 251.13,59.43 251.16,59.43 251.54,59.81 251.82,59.54 251.44,59.15 252.33,58.27 252.33,58.11 251.41,57.2 251.03,57.2 244.86,63.37 244.86,63.5 245.98,64.62
+1.35VRAMP on BOTTOM (solid shape): 250.74,63.68 256.88,63.68 257.12,63.43 257.12,59.53 256.52,58.92 252.99,58.92 251.36,57.3 251.01,57.3 249.29,59.02 249.29,59.8 248.55,60.54 247.69,60.54 245.17,63.06 245.17,63.22 246.87,64.93 246.87,65.35 247.25,65.73 248.69,65.73
+1.35VSDGPU on TOP (solid shape): outline of 1088 points within 233.67,90.17 240.71,96.38
+1.35VSDGPU on TOP (solid shape): outline of 25780 points within 182.97,58.75 254.28,136.65
+1.35VSDGPU on BOTTOM (solid shape): outline of 85 points within 241.87,65.68 244.81,71.2
+1.35VSDGPU on BOTTOM (solid shape): outline of 92 points within 184.54,124.9 189.96,127.52
+1.35VSDGPU on BOTTOM (solid shape): outline of 111 points within 197.91,96.64 211.77,97.96
+1.35VSDGPU on BOTTOM (solid shape): outline of 135 points within 212.55,81.21 214.79,97.23
+1.35VSDGPU on IN1 (solid shape): outline of 11163 points within 185.12,63.43 253.47,136.8
+1.35VSDGPU on IN2 (solid shape): 244.25,102.03 244.25,101.17 244.15,101.07 243.46,101.07 243.39,101.1 243.36,101.18 243.37,101.22 243.12,101.61 242.72,101.38 242.66,101.37 242.6,101.39 242.47,101.52 242.41,101.58 242.37,101.67 242.41,101.75 242.53,101.87 242.57,102.02 242.57,102.11 242.55,102.2 242.59,102.24 242.65,102.26 244.02,102.26
+1.35VSDGPU on IN2 (solid shape): outline of 466 points within 245.27,93.67 249.69,101.75
+1.35VSDGPU on IN2 (solid shape): outline of 554 points within 214.59,130.09 223.48,134.59
+1.35VSDGPU on IN2 (solid shape): outline of 612 points within 188.69,130.46 198.93,135.01
+1.35VSDGPU on IN2 (solid shape): outline of 669 points within 234.4,69.26 244.12,72.15
+1.35VSDGPU on IN2 (solid shape): outline of 628 points within 214.06,120.75 216.68,129.18
+1.35VSDGPU on IN2 (solid shape): outline of 708 points within 233.89,100.23 242.33,103.05
+1.35VSDGPU on IN2 (solid shape): outline of 822 points within 187.43,120.76 190.17,129.96
+1.35VSDGPU on IN2 (solid shape): outline of 1016 points within 234.56,93.09 243.22,96.75
+1.35VSDGPU on IN2 (solid shape): outline of 1001 points within 221.02,119.86 224.02,130.02
+1.35VSDGPU on IN2 (solid shape): outline of 1511 points within 233.8,63.95 253.41,79.29
+1.35VSDGPU on IN2 (solid shape): outline of 1573 points within 193.68,120 198.96,130.04
+1.35VSDGPU on IN2 (solid shape): outline of 5300 points within 197.86,81.13 220.57,103.17
+1.35VSDGPU on BOTTOM: outline of 1337 points within 181.84,63.87 254.39,136.65 ; 3 cut-outs
+2.5V on TOP (solid shape): 114.39,26.35 114.39,21.28 114.29,21.18 113.14,21.18 113.14,21.18 113.14,20.63 113.12,20.62 112.98,20.62 112.96,20.63 112.96,21.17 112.96,21.18 112.47,21.18 112.2,21.45 112.2,25.73 111.67,26.25 111.67,26.58 112.02,26.92 113.82,26.92
+2.5V on BOTTOM (solid shape): 171.42,38.38 171.42,36.56 171.29,36.43 169.55,36.43 169.5,36.49 168.52,36.49 168.39,36.61 168.39,38.78 168.83,39.22 170.58,39.22
+2.5V on TOP: 175.93,41.54 176.1,41.28 176.15,41.21 176.12,41.13 175.39,39.88 175.28,38.43 175.28,38.4 174.69,37.81 173.39,37.81 173.31,37.73 173.31,36.18 173.1,35.97 173.05,35.87 173.04,35.84 172.59,35.84 172.36,36.07 172.06,36.18 171.71,35.96 171.63,35.99 171.58,36.04 171.58,36.06 171.41,36.32 171.1,36.35 171.09,36.35 169.88,36.35 169.75,36.47 169.75,38 170.24,38.48 170.29,38.48 170.29,38.53 170.52,38.76 171.6,38.76 172.63,39.79 174.01,39.79 174.41,40.2 174.41,41.8 174.76,42.14 174.76,42.74 173.92,43.57 173.92,47.4 172.79,48.54 171.66,48.54 171.15,49.05 171.15,50.95 171.28,51.08 172.93,51.08 173.18,51.33 173.69,51.33 173.82,51.2 173.82,49.62 175.54,47.89 175.54,47.82 175.62,47.82 175.69,47.74 175.69,46.45 175.54,46.45 175.54,45.49 175.54,45.31 176.5,44.35 176.5,43.2 176.48,43.13 176.41,43.1 176.11,42.92 176.1,42.58 176.11,42.51 176.08,42.45 175.95,42.22 176.02,41.96 176.04,41.89 176.02,41.83
+2.5V on VCC: 111.87,26.24 111.74,26.37 111.74,29.53 111.95,29.74 131.29,29.74 131.95,29.09 167.17,29.09 169.81,31.72 169.81,32.66 171.33,34.18 171.33,35.18 173.33,37.18 173.33,43.09 173.97,43.73 173.97,47.31 174.43,47.78 175.01,47.78 176.51,46.27 176.51,35.99 167.64,27.12 167.49,27.12 160,27.13 114.81,27.13 113.92,26.24
+2.5VP on TOP (solid shape): 112.79,20.98 112.79,20.47 112.82,20.44 113.28,20.44 113.3,20.47 113.3,20.98 113.32,21.01 113.49,21.01 113.57,20.93 113.57,16.55 113.13,16.11 113.13,15.45 113.08,15.39 110.62,15.39 110.42,15.59 110.42,16.28 110.54,16.41 111.59,16.41 112.1,16.91 112.1,20.88 112.23,21.01 112.77,21.01
+3V_IRCAM on TOP (solid shape): 62.87,32.76 62.87,32.43 62.75,32.17 62.85,31.91 62.89,31.84 62.86,31.77 62.78,31.6 62.8,31.41 62.79,31.32 62.7,31.27 62.2,31.27 61.95,31.52 61.95,31.53 61.86,31.68 61.71,31.77 61.69,31.78 61.41,32.06 61.05,32.06 60.99,32.12 60.99,32.92 61.14,33.08 62.55,33.08
+3V_IRCAM on BOTTOM (solid shape): 62.69,32.8 62.69,29.93 62.6,29.84 62.49,29.84 62.44,29.89 62.44,31.07 62.38,31.13 62.23,31.13 62.17,31.06 62.17,29.88 62.11,29.83 62.01,29.83 61.93,29.91 61.93,31.28 61.93,31.29 61.96,31.43 61.93,31.57 61.93,31.58 61.93,31.63 61.8,31.76 61.8,31.76 61.64,31.92 61.64,32.65 61.92,32.93 62.56,32.93
+3V_PCH_PRIM on TOP (solid shape): 208.95,18.74 209.48,18.74 209.55,18.67 209.55,18.11 209.38,17.93 209.38,16.41 210.01,15.77 210.01,14.76 209.89,14.63 209.5,14.63 208.72,15.41 208.72,17.56 208.62,17.67 208.62,17.68 208.23,18.06 208.23,18.95 208.26,18.97 208.72,18.97
+3V_PCH_PRIM on TOP (solid shape): 206.58,25.55 206.58,25.3 205.82,24.53 203.66,24.53 203.54,24.41 203.54,24.05 202.84,24.05 202.77,23.97 202.67,24 202.65,24.03 201.12,24.03 201,24.15 200.49,24.15 200.36,24.28 200.36,25.04 200.49,25.17 205.69,25.17 206.2,25.68 206.46,25.68
+3V_PCH_PRIM on TOP (solid shape): 180.78,30.9 181.29,30.9 181.29,31.39 181.58,31.39 181.58,30.9 182.09,30.9 182.09,31.39 184.87,31.39 184.99,31.27 184.99,24.53 184.87,24.41 184.48,24.41 184.36,24.53 184.36,25.04 184.23,25.17 183.22,25.17 183.09,25.04 183.09,23.85 182.77,23.85 181.76,24.85 179.28,24.85 179.28,28.09 179.02,28.34 178.26,28.34 178.14,28.47 178.14,29.49 178.04,29.58 178.04,30.47 178.03,30.52 178.01,30.59 178.01,30.63 178.1,30.73 178.91,30.73 178.91,30.9 179.41,31.39 180.78,31.39
+3V_PCH_PRIM on IN2 (solid shape): outline of 691 points within 209.3,13.5 218.39,20.45
+3V_PCH_PRIM on VCC: 183.02,19 182.64,19.37 182.64,25.77 184.2,27.33 185.28,27.33 187.55,25.07 210.45,25.07 211.45,26.06 211.88,26.06 217.89,20.05 217.89,19.56 217.33,19
+3V_PCH_PRIM on IN3: 197.9,15.94 197.9,16.89 198.64,17.64 198.64,21.24 199.34,21.95 199.34,25.01 199.53,25.2 201.89,25.2 202.07,25.02 202.07,22.39 202,22.19 202.07,21.99 202.07,18.42 201.88,18.23 201.88,16.74 201.84,16.66 201.77,16.63 201.65,16.62 201.54,16.56 201.48,16.54 201.41,16.57 200.82,16.32 201.39,16.02 201.45,16.04 201.52,16.02 201.55,15.99 201.59,15.96 201.65,15.89 201.62,15.8 199.66,13.84 199.62,13.86 199.22,13.79 199.15,13.38 199.17,13.35 199.16,13.34 198.48,13.34 198.48,13.35 198.15,13.84 197.82,13.35 197.82,13.34 196.56,13.34 196.45,13.46 196.45,14.99 196.6,15.15 197.11,15.15
+3V_PHVLDO on TOP (solid shape): 211.64,21.74 211.69,21.69 211.76,21.65 211.78,21.62 211.77,21.59 211.74,21.43 211.78,21.28 211.79,21.27 211.79,21.11 211.41,20.72 211.41,20.17 211.23,19.87 211.41,19.56 211.41,17.3 211.16,17.04 210.65,17.04 210.39,17.3 209.89,17.3 209.76,17.42 209.76,18.55 210.39,19.18 210.5,19.42 210.39,19.66 210.39,20.98 211.16,21.74
+3VALW on TOP (solid shape): 184.47,43.49 184.47,40.13 183.45,40.13 183.45,42.64 182.98,43.12 182.98,43.62 183.02,43.66 184.3,43.66
+3VALW on TOP (solid shape): 53.36,40.13 54.01,40.13 54.67,39.47 54.67,38.75 54.64,38.71 53.9,38.71 53.7,38.91 53.7,38.92 53.12,39.51 53.12,40.16 53.17,40.21 53.29,40.21
+3VALW on TOP (solid shape): 106.32,20.82 106.32,19.91 106.13,19.72 105.34,19.72 105.04,19.42 104.66,19.42 104.66,19.97 104.16,19.97 104.16,19.42 103.64,19.42 103.34,19.72 103.34,20.68 103.58,20.92 106.22,20.92
+3VALW on TOP (solid shape): 119.5,21.22 119.5,20.64 119.34,20.48 118.51,20.48 118.43,20.41 118.43,19.72 118.39,19.68 117.74,19.68 117.51,19.91 117.51,20.86 118.01,21.36 119.36,21.36
+3VALW on TOP (solid shape): 247.7,22.01 247.7,19.5 247.59,19.39 246.83,19.39 246.83,19.95 246.08,19.95 246.08,19.39 245.64,19.39 245.64,19.95 244.88,19.95 244.88,19.39 243.57,19.39 243.35,19.61 243.35,21.85 243.68,22.18 247.53,22.18
+3VALW on TOP (solid shape): 268.02,42.22 269.63,42.22 269.95,41.91 269.95,40.22 269.34,39.61 267.62,39.61 267.57,39.66 267.57,40.18 267.26,40.49 267.26,41.05 267.27,41.15 267.26,41.25 267.26,41.79 267.86,41.79 267.86,41.82 267.96,41.82 267.98,41.84 267.98,41.99 267.95,42.02 267.23,42.02 267.23,42.19 267.26,42.23 267.32,42.24 267.35,42.19 267.35,42.19 267.86,42.19 267.86,42.25 267.99,42.25
+3VALW on TOP (solid shape): 175.29,23.92 175.29,14.15 175.06,13.92 174.02,13.92 173.39,14.55 173.36,14.65 173.43,14.72 173.67,15.18 173.18,15.38 173.17,15.38 172.95,15.38 172.95,18.31 173,18.31 173.31,18.63 173.08,19 173.06,19.01 172.95,19.12 172.95,22.26 173.67,22.98 173.67,24.87 173.86,25.05 174.16,25.05
+3VALW on TOP (solid shape): 179.48,34.33 179.48,34.03 179.47,33.93 179.48,33.83 179.48,33.74 179.71,33.51 182.44,33.51 182.59,33.36 182.59,31.64 182.52,31.57 179.35,31.57 178.77,32.15 178.04,32.15 178.04,32.67 178.04,32.7 178.07,32.74 178.35,33.13 177.98,33.44 177.7,33.33 177.61,33.03 177.61,33.01 177.6,32.99 177.6,32.83 177.55,32.76 177.53,32.67 177.53,32.15 177.12,32.15 176.75,32.53 175.82,32.53 175.72,32.62 175.72,33.28 177.01,34.57 179.24,34.57
+3VALW on TOP (solid shape): 58.35,17.04 58.35,16.51 58.32,16.48 58.28,16.48 57.92,16.28 57.89,15.88 57.89,15.87 57.89,15.51 57.53,15.15 57.53,15.14 56.99,14.59 55.08,14.59 55.08,15 55.08,15 55.08,15.06 54.62,15.06 54.53,15.15 54.53,15.27 54.6,15.34 55.08,15.34 55.13,15.39 55.13,15.79 55.08,15.84 55.08,15.86 54.59,15.86 54.55,15.89 54.55,16.15 55.08,16.15 55.08,16.65 55.38,16.65 55.38,16.6 55.51,16.33 55.81,16.26 55.9,16.23 55.93,16.13 56.11,15.7 56.56,15.83 56.73,15.83 56.85,15.94 56.87,15.95 57.08,16.04 57.19,16.24 57.19,16.26 57.24,16.3 57.24,16.91 57.46,16.91 57.46,17.27 57.46,17.27 58.12,17.27
+3VALW on TOP (solid shape): outline of 151 points within 302.98,6.6 306.27,10.87
+3VALW on TOP (solid shape): outline of 259 points within 171.67,100.89 182.15,107.21
+3VALW on BOTTOM (solid shape): 237.04,25.93 237.04,24.81 237.22,24.64 237.22,24.05 237.06,23.9 236.45,23.9 236.4,23.95 236.4,24.58 236.34,24.65 236.33,24.65 236.21,24.78 236.21,25.69 236.51,25.99 236.58,25.99 236.65,26 236.72,26.02 236.73,26.03 236.94,26.03
+3VALW on BOTTOM (solid shape): 182.17,106.85 182.17,105.42 183.47,104.12 183.49,104.06 183.49,103.78 183.47,103.76 182.66,103.76 181.56,104.85 181.56,105.64 181.51,105.69 181.26,105.69 181.11,105.84 181.11,106.78 181.12,106.84 181.11,106.9 181.11,106.93 181.32,107.13 181.89,107.13
+3VALW on BOTTOM (solid shape): 173.09,104.53 173.09,103.82 172.93,103.66 172.93,103.66 172.62,103.35 172.62,103.35 172.57,103.3 172.57,103.22 172.95,102.84 172.78,102.67 172.45,103 172.42,103 172.38,103.04 172.33,103 172.29,103 172.06,102.77 172.06,102.73 172.02,102.68 172.4,102.3 172.2,102.1 171.79,102.51 171.22,101.95 170.54,102.64 170.54,103.22 172.06,104.75 172.88,104.75
+3VALW on BOTTOM (solid shape): 180.15,33.09 181.03,33.09 181.26,32.87 181.26,29.82 180.24,28.8 180.24,28.73 174.77,23.25 174.07,23.25 173.61,23.71 173.61,24.05 173.64,24.18 173.61,24.32 173.61,24.99 173.77,25.14 174.88,25.14 179.38,29.64 179.38,29.79 179.41,29.81 179.6,30.12 179.41,30.44 179.38,30.46 179.38,32.81 179.66,33.09 180.15,33.09
+3VALW on BOTTOM (solid shape): outline of 127 points within 263.35,18.78 272.79,41.9
+3VALW on IN2 (solid shape): 173.13,104.8 173.13,102.21 173,102.08 171.94,102.08 171.81,102.21 171.81,104.75 171.96,104.9 173.03,104.9
+3VALW on IN2 (solid shape): 186.3,43.32 185.12,42.14 183.55,42.14 182.83,42.87 182.83,43.47 183.05,43.69 185.06,43.69 185.35,43.98 185.65,43.98
+3VALW on IN3 (solid shape): outline of 100 points within 97.24,12.67 119.61,21.26
+3VALW on IN3 (solid shape): outline of 560 points within 45.64,13.75 58.16,20.63
+3VALW on VCC: 99.47,12.19 98.87,12.8 94.34,12.8 94.11,13.03 94.11,13.99 94.62,14.5 142.91,14.5 144.43,16.03 149.56,16.03 152.03,18.49 217.54,18.49 219.23,20.18 233.61,20.22 234.78,21.38 234.78,25.44 235.01,25.68 271.25,25.68 271.54,25.39 271.54,18.63 270.59,17.69 239.57,17.69 237.67,15.78 218.73,15.78 217.05,14.11 200.93,14.11 199.4,12.57 178.88,12.57 177.78,13.66 173.01,13.66 170.39,16.28 153.67,16.28 149.58,12.19
+3VALW on IN2: 90.38,10.05 89.46,10.97 84.97,10.97 84.67,11.15 84.36,10.97 75.94,10.97 75.87,11 75.84,11.07 75.57,11.4 75.17,11.23 75.1,11.18 75.01,11.21 72.55,13.67 66.51,13.67 66.11,13.28 62.59,13.28 62.29,12.98 59.2,12.98 58.88,13.31 57.89,13.31 56.28,14.91 56.28,15.63 56.33,15.67 56.34,15.68 56.5,15.76 56.6,15.9 56.65,15.96 56.73,15.96 57.05,16.01 57.19,16.31 57.22,16.38 57.3,16.41 57.91,16.41 58,16.36 57.99,16.25 58.28,15.69 58.57,16.25 58.57,16.36 58.66,16.41 61,16.41 61.2,16.21 64.46,16.21 64.88,15.8 64.99,15.8 65.01,15.78 73.92,15.78 76.21,13.49 78.75,13.49 78.84,13.44 78.84,13.34 78.95,12.89 79.42,12.93 79.49,12.96 79.56,12.94 80,12.92 80.12,13.35 80.13,13.44 80.21,13.49 82.93,13.49 83.02,13.43 83.01,13.32 83.28,12.73 83.54,13.32 83.53,13.43 83.62,13.49 92.02,13.49 92.48,13.02 94.79,13.02 95.8,14.04 97.84,14.04 98.66,13.22 98.66,10.77 97.94,10.05
+3VALW on IN2: outline of 127 points within 267.28,6.81 305.29,44.16
+3VALW on IN2: 45.61,45.96 48.39,45.96 49,45.35 49,44.16 48.91,44.07 48.29,44.07 48.28,44.08 46.28,44.08 45.92,44.44 43.78,44.44 43.54,44.68 43.54,46.12 43.92,46.5 45.07,46.5
+3VALW_DSW on BOTTOM (solid shape): 191.34,18.95 191.34,18.82 190.96,18.44 190.45,18.44 189.69,17.68 189.69,17.3 189.57,17.17 189.31,17.17 189.18,17.3 189.18,17.93 190.06,18.8 190.09,18.79 190.2,18.78 190.32,18.81 190.33,18.82 190.55,18.82 190.6,18.81 190.61,18.82 190.84,18.82 191.09,19.07 191.22,19.07
+3VALWP on TOP (solid shape): 242.93,20.68 242.93,19.66 243.33,19.26 247.38,19.26 247.68,19.26 248.44,20.01 249.45,20.01 249.63,19.84 249.63,19.2 248.12,17.69 241.39,17.69 241.04,18.03 241.04,20.61 241.25,20.81 242.8,20.81
+3VALWP on BOTTOM (solid shape): 248.98,20.48 249.44,20.02 250.4,20.02 250.51,19.91 250.51,19.05 250.46,19 248.23,19 247.08,17.85 244.92,17.85 243.7,16.63 240.62,16.63 240.38,16.88 240.38,20.58 240.52,20.73 248.73,20.73
+3VB_1.8V on BOTTOM (solid shape): 269.76,20.83 269.76,20.5 269.21,20.5 269.21,20 269.76,20 269.76,19.7 269.21,19.7 269.21,19.2 269.76,19.2 269.76,18.89 269.69,18.82 267.93,18.82 267.73,19.02 266.84,19.02 265.67,20.19 265.06,20.19 264.99,20.27 264.99,20.42 265.04,20.47 266.58,20.47 266.71,20.34 268.25,20.34 268.86,20.95 269.64,20.95
+3VL on BOTTOM (solid shape): 250.91,26.45 250.91,25.91 250.92,25.9 252.54,25.9 252.78,25.66 252.78,24.08 252.74,24.03 251.88,24.03 251.77,24.14 251.77,24.94 251.67,25.04 251.64,25.04 251.59,25.09 250.31,25.09 250.31,25.09 250.31,25.85 250.35,25.9 250.71,25.9 250.73,25.92 250.73,26.44 250.75,26.46 250.9,26.46
+3VL on IN2 (solid shape): 253.92,23.58 253.92,23.55 254,23.47 254,23.31 253.95,23.26 253.05,23.26 251.76,24.55 251.76,24.96 252.05,25.25 252.26,25.25
+3VLP on BOTTOM (solid shape): 250.64,28.94 250.69,28.94 251.77,27.86 252.76,27.86 252.84,27.79 252.84,27.35 252.73,27.25 251.69,27.25 251.34,26.9 251.34,26.08 251.31,26.06 251.07,26.07 251.07,26.62 251.06,26.62 250.59,26.62 250.57,26.61 250.57,26.08 250.54,26.06 250.04,26.06 249.79,26.31 249.79,27.56 249.8,27.67 249.79,27.78 249.79,28.9 249.84,28.95 250.59,28.95
+3VS on TOP (solid shape): 36.78,57.01 36.78,56.25 36.68,56.15 35.76,56.15 35.6,56.32 35.6,57.59 35.77,57.75 36.03,57.75
+3VS on TOP (solid shape): 73.54,47.6 73.54,47.06 73.44,46.96 72.04,46.96 71.94,47.06 71.94,47.61 72.34,47.7 73.44,47.7
+3VS on TOP (solid shape): 265.35,42.19 265.9,42.19 265.95,42.13 265.95,42.07 265.9,42.02 265.25,42.02 265.23,42 265.23,41.84 265.24,41.83 265.35,41.83 265.35,41.79 265.95,41.79 265.95,41.19 265.57,40.8 265.57,40.23 265.04,39.71 262.45,39.71 262.26,39.9 262.26,40.91 262.49,41.13 264.21,41.13 264.25,41.17 264.25,41.6 264.78,42.14 264.96,42.14 265.11,42.22 265.35,42.22
+3VS on TOP (solid shape): 29.87,57.75 29.87,57.56 29.7,57.39 29.21,57.39 28.67,56.86 28.66,56.85 28.54,56.77 28.47,56.66 28.46,56.65 28.37,56.56 28.15,56.56 28.15,56.56 27.34,56.56 27.34,56.54 25.2,56.54 25.08,56.66 25.08,56.72 25.08,56.72 25.08,56.89 25.18,57 26.17,57 26.24,57.07 26.71,57.07 27.01,57.04 27.22,57.24 27.23,57.25 27.69,57.71 28.42,57.71 29.07,58.37 29.26,58.37
+3VS on TOP (solid shape): 37.39,15.42 37.39,15.39 37.42,15.39 37.55,15.26 37.8,15.26 38.23,14.83 38.35,14.83 38.36,14.82 38.54,14.78 38.72,14.83 40.26,14.83 40.65,14.45 41.25,14.45 41.36,14.35 41.36,13.56 41.22,13.42 39.9,13.42 39.88,13.41 39.22,13.41 39.21,13.4 39.21,12.89 39.18,12.87 38.99,12.87 38.97,12.89 38.97,13.39 38.95,13.41 38.43,13.41 38.41,13.38 38.41,12.91 38.36,12.87 38.2,12.87 38.17,12.89 38.17,13.39 38.15,13.41 36.95,13.41 36.89,13.42 36.82,13.41 36.61,13.41 35.26,14.76 35.26,16.28 35.39,16.41 36.4,16.41
+3VS on IN3 (solid shape): outline of 480 points within 67.73,20.27 77.88,47.75
+3VS on IN1: 269.24,12.77 274.31,12.77 277.39,9.7 277.39,9.69 278.92,8.15 278.92,6.51 278.76,6.35 276.46,6.35 275.76,5.65 260.7,5.65 260,6.35 249.64,6.35 249.19,6.79 244.99,6.79 244.04,7.74 244.04,10.5 244.56,11.02 247.58,11.02 249.52,12.96 269.05,12.96
+3VS on VCC: 56.74,44.63 56.04,45.33 46.65,48.11 43.53,50.42 36.87,54.48 34.04,57.3 29.61,57.3 28.65,58.26 28.65,66.11 28.91,66.37 29.29,66.37 42.42,52.8 60.33,46.84 60.33,46.24 64,46.11 67.67,46.32 67.67,46.92 70.68,47.36 73.65,48.02 73.77,47.9 73.77,47.22 71.18,44.63
+3VS on VCC: 1.17,1.17 1.17,12.1 34.07,12.1 34.07,16.76 34.23,16.92 60.81,16.92 66.92,10.82 73.59,10.82 75.65,12.87 75.65,20.62 76.01,20.98 79.22,20.98 79.46,20.75 79.48,12.93 80.12,12.29 93.37,12.29 93.6,12.06 93.6,10.08 94.34,9.34 150.43,9.34 154.82,13.74 169.32,13.74 172.01,11.05 176.38,11.05 178.26,9.17 223.12,9.17 226.73,12.77 248,12.77 249.56,14.33 276.01,14.33 276.59,14.9 276.59,25.73 276.92,26.06 283.06,26.06 284.18,24.94 284.17,4.69 284.05,4.57 259.61,4.57 259.61,5.17 250.77,5.17 250.77,4.57 170.42,4.57 170.42,4.57 166.07,4.57 166.07,7.8 165.43,9.33 163.9,9.97 157.96,9.97 157.9,9.97 156.37,9.33 155.73,7.8 155.73,4.57 43,4.57 41.47,3.93 40.83,2.4 40.83,1.17
+3VS on IN3: 276.01,28.51 280.1,24.42 280.1,23.56 280.06,23.48 279.98,23.46 279.54,23.11 279.98,22.76 280.06,22.74 280.1,22.66 280.1,21.65 279.69,21.24 276.42,21.24 276.33,21.33 274.05,21.33 262.59,32.79 262.59,38.38 262.59,38.43 262.57,38.5 262.57,38.64 262.24,38.97 262.24,40.95 262.82,41.53 265.73,41.53 265.99,41.27 265.99,41.24 265.98,41.12 266.01,41.01 266.01,41 266.01,40.01 268.4,37.62 268.4,35.64 268.51,35.53 268.53,35.49 268.56,35.46 275.08,28.94 275.28,28.94 275.33,28.95 275.41,28.96 275.86,28.51
+3VS_MUX on TOP (solid shape): 36.68,54.06 36.47,53.85 36.02,53.85 35.87,53.99 35.38,53.99 35.31,53.93 35.22,53.93 35.22,53.26 35.03,53.07 34.5,53.07 34.49,53.07 33.22,53.07 33.15,53.14 33.15,53.53 34.82,55.2 35.49,55.2 35.69,55.4 36.68,55.4
+3VS_MUX on IN1: 26.5,50.45 25.64,50.45 25.29,50.81 25.29,53.35 26.44,54.51 34.22,54.51 35.01,53.71 35.01,53.12 34.8,52.91 27.62,52.91 26.82,52.11 26.82,50.77
+3VS_MUX on IN2: 29.28,56.6 30.44,56.6 31.92,55.12 32.11,55.12 32.11,55.12 32.62,55.12 33.49,54.25 34.4,54.25 34.95,53.71 34.95,53.46 34.76,53.27 33.79,53.27 33.51,53.55 32.89,53.55 32.23,54.21 30.97,54.21 30.72,53.96 28.32,53.96 28.2,54.07 28.2,54.44 28.23,54.48 28.23,55.55 28.43,55.75 28.52,55.78 28.6,55.72 28.85,55.53 29.16,55.61 29.22,55.63 29.29,55.61 29.88,55.87 29.29,56.14 29.22,56.12 29.16,56.14 29.12,56.17 29.07,56.24 29.09,56.32 29.12,56.38 29.15,56.45 29.15,56.47
+3VS_SSD on TOP (solid shape): 38.01,13.21 38.01,12.72 38.02,12.7 38.55,12.7 38.57,12.72 38.57,13.21 38.61,13.25 38.78,13.25 38.8,13.23 38.8,12.72 38.82,12.7 39.36,12.7 39.39,12.73 39.39,13.22 39.42,13.25 39.75,13.25 39.86,13.13 39.86,11.2 39.68,11.02 36.58,11.02 36.43,11.17 36.43,12.34 36.62,12.53 36.98,12.53 37.7,13.25 37.97,13.25
+3VS_SSD on TOP (solid shape): 19.79,4.87 19.79,3.99 20.81,2.97 29.66,2.97 29.81,3.12 31.97,3.12 32.12,2.97 32.12,2.87 32.24,2.75 35.37,2.75 35.84,3.22 37.04,3.22 37.37,2.89 37.37,2.46 37.34,2.44 36.99,2.44 36.89,2.43 36.81,2.39 36.8,2.39 36.76,2.39 36.73,2.36 36.67,2.36 36.67,2.3 36.63,2.26 36.63,2.19 36.63,2.18 36.61,2.06 36.63,1.93 36.63,1.92 36.63,1.65 36.5,1.52 18.01,1.52 17.94,1.6 17.94,3.99 17.99,4.04 18.57,4.04 18.8,4.26 18.8,4.87 18.9,4.98 19.69,4.98
+3VS_SSD on BOTTOM (solid shape): 20.8,3.83 20.8,2.91 20.6,2.72 18.88,2.72 18.75,2.59 18.75,1.17 17.45,1.17 17.45,3.43 17.5,3.5 17.53,3.56 17.58,3.66 17.62,3.78 17.78,3.95 20.68,3.95
+3VS_SSD on BOTTOM (solid shape): 36.16,3 37.34,3 37.34,2.99 37.34,2.61 37.17,2.44 35.84,2.44 35.74,2.33 35.74,1.17 34.98,1.17 34.98,2.89 34.98,2.91 35.39,2.97 35.47,3.38 35.78,3.38
+3VS_SSD on BOTTOM (solid shape): 33.23,3.05 33.23,1.17 31.45,1.17 31.45,2.56 31.4,2.61 31.28,2.61 31.1,2.68 30.92,2.61 30.78,2.61 30.68,2.66 30.57,2.68 30.12,2.68 29.96,2.68 29.81,2.83 29.81,3.34 29.93,3.45 32.82,3.45
+3VS_SSD on IN3: 18.81,2.2 18.23,2.77 18.23,4.33 18.75,4.85 18.75,7.79 18.81,7.88 18.91,7.87 19.47,8.16 18.91,8.46 18.81,8.45 18.75,8.54 18.75,9.1 19.67,10.03 32.31,10.03 33.11,10.83 33.17,10.8 33.18,10.78 33.2,10.75 33.18,10.71 33.17,10.22 33.65,10.18 33.72,10.2 33.79,10.17 34.3,10.2 34.25,10.71 34.22,10.79 34.25,10.87 34.36,11.26 34.03,11.5 33.94,11.56 33.96,11.67 34.89,12.61 40.36,12.61 41.39,11.58 41.39,4.21 39.38,2.2 37.83,2.2 37.82,2.23 37.51,2.41 37.2,2.23 37.18,2.2
+3VS_TPM on TOP (solid shape): 119.4,17.49 119.34,17.34 119.36,17.18 119.01,16.83 118.47,16.83 118.41,16.77 118.41,16.17 118.36,16.11 117.31,16.11 117.11,15.91 117.11,15.36 117.29,15.18 118.32,15.18 118.38,15.12 118.38,14.66 118.32,14.6 117.3,14.6 117.12,14.42 117.12,13.92 117.5,13.54 118.62,13.54 118.69,13.62 118.69,14.18 118.82,14.3 119.36,14.3 119.62,14.04 119.62,12.61 117.6,12.61 116.41,13.8 116.41,17.67 116.75,18 116.9,18 116.97,18 117.05,18 117.07,18.01 117.23,17.85 117.27,17.81 117.34,17.74 117.36,17.74 117.54,17.69 117.71,17.74 117.72,17.74 118.48,17.74 118.55,17.81 118.55,19.66 118.56,19.67 118.56,20.13 118.75,20.32 119.4,20.32
+3VS_WLAN on TOP (solid shape): 310.37,24.59 310.37,23.82 310.35,23.82 310.35,23.37 310.16,23.18 309.71,23.18 309.71,23.17 309.6,23.17 309.3,22.88 309.28,22.88 309.2,22.88 309.11,22.85 307.81,22.85 307.7,22.96 307.7,23.57 307.7,23.58 307.73,23.72 307.7,23.86 307.7,23.87 307.7,24.32 307.94,24.57 308.17,24.55 308.39,24.6 310.35,24.6
+3VS_WLAN on TOP (solid shape): 309.06,8.29 309.84,8.29 310.34,7.8 310.34,6.12 310.35,6.11 310.35,5.49 310.22,5.36 309.16,5.36 309.15,5.41 308.42,6.35 307.28,6.01 307.26,5.99 307.17,5.99 306.79,6.37 306.79,8.41 307.04,8.66 308.69,8.66
+3VS_WLAN on BOTTOM (solid shape): 311.08,24.38 311.08,24.28 311,24.2 309.66,24.2 309.58,24.13 309.58,24.09 309.68,23.99 311.05,23.99 311.12,23.92 311.12,23.76 311.06,23.7 309.56,23.7 308.77,22.91 308.67,22.91 308.46,23.11 308.46,23.85 309.1,24.48 310.98,24.48
+3VS_WLAN on BOTTOM (solid shape): 309.45,7.52 309.45,7.06 309.52,6.98 311,6.98 311.08,6.91 311.08,6.75 311.03,6.7 309.71,6.7 309.63,6.63 309.63,6.51 309.66,6.49 311.04,6.49 311.08,6.44 311.08,6.24 311.05,6.21 309.65,6.21 309.46,6.02 308.95,6.02 308.52,6.45 308.52,6.87 308.52,6.88 308.52,7.42 308.77,7.67 309.3,7.67
+3VS_WLAN on IN2 (solid shape): outline of 1610 points within 303.89,4.74 309.89,24.72
+5V_HDMI on TOP (solid shape): 14.95,117.74 16.96,117.74 17.01,117.74 17.1,117.75 17.48,117.37 17.48,115.85 17.06,115.42 17.03,115.43 16.91,115.44 16.8,115.41 16.79,115.4 16.27,115.4 15.07,116.61 13.67,116.61 13.16,116.1 13.16,115.59 12.78,115.21 12.15,115.21 11.89,115.47 11.89,116.23 13.42,117.75 14.93,117.75
+5V_TYPEC on TOP (solid shape): 12.36,51.24 12.36,50.71 12.31,50.66 9.51,50.66 9.36,50.8 8.53,50.8 8.44,50.9 8.44,51.05 8.56,51.18 8.97,51.18 9.13,51.34 12.26,51.34
+5V_TYPEC on TOP (solid shape): 12.65,47.66 12.65,45.63 12.5,45.48 11.89,45.48 11.47,45.9 10.57,45.9 10.14,45.47 9.85,45.47 9.51,45.81 9.51,47.54 9.74,47.76 12.56,47.76
+5V_TYPEC on TOP (solid shape): 11.92,53.87 11.92,53.39 11.83,53.3 10.38,53.3 10.26,53.42 9.53,53.42 9.28,53.67 8.64,53.67 8.54,53.77 8.54,53.97 8.61,54.05 11.74,54.05
+5V_TYPEC on TOP (solid shape): 37.6,41.68 37.6,40.76 37.57,40.74 37.06,40.74 37.04,40.71 37.04,40.03 37.06,40 37.13,40 37.13,40 37.55,40 37.57,39.98 37.57,39.57 37.55,39.55 37.06,39.55 37.04,39.52 37.04,38.83 37.06,38.81 37.13,38.81 37.13,38.8 37.58,38.8 37.6,38.78 37.6,38.28 37.57,38.25 36.42,38.25 35.89,38.78 35.89,41.03 35.7,41.21 35.7,42.1 36.07,42.47 36.81,42.47
+5V_TYPEC on VCC: 34.22,37.13 34.07,37.29 34.07,43.54 26.07,43.54 26.07,45.54 13.33,45.54 13.33,43.54 5.12,43.54 5.12,44.04 1.62,44.04 1.62,46.67 6.04,46.67 6.04,55.61 7.83,57.4 8.66,57.4 15.7,50.37 26.39,50.37 29.34,47.42 35.15,47.42 38.33,44.24 38.33,37.39 38.08,37.13
+5V_TYPEC_L on TOP (solid shape): 43.91,41.3 43.91,40.44 43.91,40.44 43.91,40.26 42.87,39.22 42.87,38.98 42.42,38.53 39.23,38.53 39.01,38.31 38.96,38.3 38.91,38.28 37.78,38.28 37.78,38.9 37.74,38.9 37.74,38.94 37.72,38.95 37.23,38.95 37.23,39.39 37.71,39.39 37.72,39.4 37.78,39.4 37.78,40.1 37.74,40.1 37.74,40.13 37.72,40.15 37.23,40.15 37.23,40.59 37.72,40.59 37.72,40.6 37.78,40.6 37.78,41.27 38.25,41.27 39.17,40.35 41.94,40.35 41.94,40.36 42.01,40.36 43,41.35 43.87,41.35
+5VALW on TOP (solid shape): 74.18,36.31 74.18,35.19 73.95,34.95 73.17,34.95 73.02,35.1 73.02,36.32 73.12,36.42 74.07,36.42
+5VALW on TOP (solid shape): 180.28,106.95 180.28,106.78 180.04,106.54 180.04,105.88 179.03,105.88 179,105.92 178.6,105.92 178.34,106.17 178.34,106.4 178.48,106.54 179.31,106.54 179.88,107.1 180.13,107.1
+5VALW on TOP (solid shape): 23.39,82.87 23.86,82.87 23.99,82.74 24.2,81.29 23.73,80.82 20.87,80.82 20.76,80.93 20.76,82.06 20.33,82.49 20.33,82.94 20.5,83.12 23.14,83.12
+5VALW on TOP (solid shape): 43.91,42.11 43.91,41.7 43.91,41.7 43.91,41.61 43.87,41.57 43.02,41.57 41.94,40.49 39.61,40.49 39.34,40.76 39.34,41.82 39.53,42.01 42.17,42.01 42.32,42.15 43.86,42.15
+5VALW on TOP (solid shape): 80.8,36.67 81.85,36.67 82.01,36.51 82.01,35.97 81.9,35.86 77.84,35.86 77.74,35.77 77.71,35.73 77.71,34.08 77.67,34.03 77.13,34.03 77.05,34.11 77.05,37.75 77.22,37.92 79.55,37.92
+5VALW on TOP (solid shape): 268.87,43.19 269.28,43.19 269.39,43.08 269.38,43.05 269.35,42.93 269.37,42.81 269.35,42.72 269.27,42.68 268.32,42.68 268.18,42.82 267.88,42.82 267.88,42.82 267.28,42.82 267.25,42.85 267.25,42.99 267.29,43.03 267.35,43.01 267.35,42.99 267.86,42.99 267.86,43.04 268.16,43.04 268.18,43.05 268.26,43.05 268.69,43.49 268.87,43.49
+5VALW on TOP (solid shape): 271.11,45.5 271.11,44.47 270.91,44.27 268.98,44.27 268.87,44.16 268.72,44.16 268.12,43.57 267.86,43.57 267.86,43.58 267.36,43.58 267.25,43.69 267.25,43.79 267.86,43.79 267.86,43.82 267.93,43.82 267.95,43.85 267.95,44 267.93,44.02 267.27,44.02 267.25,44.04 267.25,44.43 267.26,44.5 267.25,44.57 267.25,44.6 267.26,44.6 267.26,45.34 267.38,45.47 267.53,45.47 267.64,45.57 267.64,46.27 267.86,46.5 270.12,46.5
+5VALW on BOTTOM (solid shape): 73.17,15.41 73.17,11.51 72.92,11.26 68.83,11.26 68.33,11.76 68.33,13.08 68.64,13.38 68.64,14.44 69.17,14.44 69.17,15.14 68.62,15.14 68.62,15.64 69.17,15.64 69.17,16.34 68.62,16.34 68.62,16.79 71.79,16.79
+5VALW on BOTTOM (solid shape): 307.29,45.87 307.29,43.71 307.17,43.58 305.86,43.58 305.82,43.6 305.76,43.62 305.7,43.63 305.67,43.63 304.96,43.63 304.72,43.88 306.95,43.88 306.95,44.12 306.41,44.12 306.41,43.88 304.72,43.88 304.37,44.22 304.37,44.88 306.95,44.88 306.95,45.12 306.41,45.12 306.41,44.88 304.37,44.88 304.37,45.74 304.75,46.12 307.04,46.12
+5VALW on VCC: outline of 191 points within 21.16,11.33 312.43,136.65 ; 2 cut-outs
+5VALWP on TOP (solid shape): 66.54,12.24 66.54,8.68 68.11,7.11 68.11,5.43 67.85,5.18 64.3,5.18 64.04,5.43 64.04,6.32 63.79,6.57 62.9,6.57 62.77,6.7 62.77,7.44 62.6,7.61 62.6,7.82 62.77,7.99 62.77,8.71 62.6,8.88 62.6,9.09 62.77,9.26 62.77,9.98 62.6,10.15 62.6,10.36 62.77,10.53 62.77,11.14 64.15,12.51 66.27,12.51
+5VALWP on BOTTOM (solid shape): 68.49,16.22 69.04,16.22 69.04,15.77 68.49,15.77 68.49,15.02 69.04,15.02 69.04,14.57 68.49,14.57 68.49,13.94 68.49,13.94 68.49,13.82 67.91,13.24 67.91,7.66 68.11,7.46 68.11,5.43 67.85,5.18 64.3,5.18 64.04,5.43 64.04,6.32 63.79,6.57 62.9,6.57 62.77,6.7 62.77,7.44 62.6,7.61 62.6,7.82 62.77,7.99 62.77,8.71 62.6,8.88 62.6,9.09 62.77,9.26 62.77,9.98 62.6,10.15 62.6,10.36 62.77,10.53 62.77,11.4 64.52,13.15 64.52,14.63 66.68,16.79 68.49,16.79
+5VL on TOP (solid shape): outline of 87 points within 75.36,12.97 80.09,20.77
+5VL on BOTTOM (solid shape): 24.89,76.43 24.89,75.38 24.82,75.31 21.27,75.31 21.21,75.37 21.21,76.42 21.32,76.53 24.8,76.53
+5VL on BOTTOM (solid shape): 80.06,13.34 80.06,12.6 80.01,12.55 79.61,12.55 79.6,12.54 79.6,12.02 79.57,11.99 79.46,11.99 79.43,12.02 79.43,12.54 79.41,12.56 79,12.56 78.91,12.64 78.91,13.33 79.01,13.43 79.98,13.43
+5VLP on BOTTOM (solid shape): 79.3,11.86 79.73,11.86 79.73,12.42 80.03,12.42 80.09,12.36 80.09,11.3 79.91,11.12 79.34,11.12 79.27,11.05 79.27,10.23 79.17,10.13 78.35,10.13 77.72,9.5 76.96,9.5 76.88,9.59 76.88,10.26 77.17,10.26 78.07,11.17 78.07,11.18 78.5,11.61 78.8,11.61 78.93,11.75 78.93,12.33 79.02,12.42 79.3,12.42
+5VS on TOP (solid shape): 287.61,17.42 287.61,15.9 287.48,15.77 285.2,15.77 284.69,16.28 284.69,17.42 285.2,17.93 287.1,17.93
+5VS on TOP (solid shape): 265.3,45.35 265.3,44.79 265.97,44.12 265.97,44.07 265.92,44.02 265.27,44.02 265.24,43.99 265.24,43.88 265.29,43.82 265.35,43.82 265.35,43.79 265.86,43.79 265.86,43.8 265.92,43.83 265.97,43.77 265.97,43.67 265.93,43.62 264.58,43.62 264.51,43.55 264.5,43.55 264.4,43.48 264.34,43.38 264.33,43.37 264.14,43.18 264.14,43.15 263.91,42.91 262.03,42.91 261.72,42.6 261.18,42.6 261.02,42.77 261.02,43.23 263.22,45.44 263.55,45.44 263.57,45.46 265.2,45.46
+5VS on TOP (solid shape): 18.24,114.07 18.24,113.08 17.84,112.67 16.64,112.67 16.31,113 16.31,113.56 16.59,113.84 16.67,113.87 16.74,113.84 17.17,113.78 17.34,114.18 17.35,114.27 17.44,114.31 17.72,114.31 17.73,114.32 17.99,114.32
+5VS on BOTTOM (solid shape): 206.47,10.91 205.84,10.91 205.48,11.26 205.48,11.59 205.84,11.95 206.11,11.95 206.22,12.06 206.22,13.05 206.27,13.09 206.47,13.09
+5VS on BOTTOM (solid shape): 286.24,17.4 286.24,16.26 286.01,16.03 283.85,16.03 283.52,16.36 283.52,17.4 283.64,17.52 283.7,17.55 284.74,17.55 284.76,17.57 286.06,17.57
+5VS on BOTTOM (solid shape): 201.49,13.03 201.49,12.01 201.76,11.74 202.18,11.74 202.31,11.61 202.31,11.07 202,10.77 201.03,10.77 200.89,10.91 200.89,11.92 201.22,12.26 201.22,13.05 201.27,13.1 201.42,13.1
+5VS on BOTTOM (solid shape): 274.85,48.16 275.98,47.69 277.12,47.25 277.23,47.22 277.57,46.88 277.57,45.29 277.82,45.04 277.82,44.62 277.78,44.58 275.28,44.58 274.64,45.22 274.64,47.95
+5VS on BOTTOM (solid shape): 32.11,45.46 32.11,45 32.26,44.84 32.26,44.69 32.06,44.48 31.76,44.48 31.59,44.65 31.59,45.08 31.35,45.32 30.97,45.32 30.73,45.55 29.06,45.55 28.96,45.66 28.96,46.1 29.08,46.23 31.34,46.23
+5VS on BOTTOM (solid shape): 276.73,16.72 276.73,14.65 275.96,13.88 265.43,13.88 265.28,14.02 259.53,14.02 259.47,13.96 259.44,13.96 259.21,13.73 257.99,13.73 257.86,13.87 257.86,14.41 273.95,14.41 273.95,14.36 273.95,14.31 273.97,14.26 273.99,14.21 274.02,14.17 274.06,14.13 274.1,14.09 274.15,14.07 274.2,14.05 274.25,14.03 274.3,14.03 274.36,14.03 274.41,14.05 274.46,14.07 274.5,14.09 274.54,14.13 274.58,14.17 274.61,14.21 274.63,14.26 274.65,14.31 274.66,14.36 274.66,14.41 274.65,14.47 274.63,14.52 274.61,14.57 274.58,14.61 274.54,14.65 274.5,14.68 274.46,14.71 274.41,14.73 274.36,14.74 274.3,14.74 274.25,14.74 274.2,14.73 274.15,14.71 274.1,14.68 274.06,14.65 274.02,14.61 273.99,14.57 273.97,14.52 273.95,14.47 273.95,14.41 257.86,14.41 257.86,14.51 258.03,14.69 258.22,14.69 258.31,14.78 258.31,16.88 258.41,16.98 276.47,16.98
