# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P9: length 203
  TOP w0.127: C370.1 35.67,7.34 37.69,7.34 38.43,6.59 40.85,6.59 45.79,11.53 46.11,11.53 46.79,12.22 53.24,12.22 54.05,11.4 58.23,11.4 60.9,14.07 61.55,14.07 65.85,18.37 69.4,18.37 74.63,23.6 84.17,23.6 88.76,19.01 96.33,19.01 100.8,14.54 100.8,13.68 102.39,12.09 103.71,12.09 105.8,10 111.14,10 112.9,8.24 115.96,8.24 116.23,8.51 116.23,8.91 v2(116.4,9.08)
  IN1 w0.135: v2(196.14,43.42) 196.14,43.49 196.04,43.6 194.55,43.6 193.71,42.76 193.31,42.76 193.16,42.61 192.76,42.61 192.62,42.76 192.21,42.76 192.07,42.61 191.66,42.61 191.52,42.76 191.1,42.76 186.83,38.49 186.83,35.74 186.45,35.35 186.45,34.26 186.91,33.81 186.91,31.21 180.7,25 180.7,23.92 177.09,20.31 176.61,20.31 173.54,17.25 172.81,17.25 172.09,16.53 154.19,16.53 152.31,14.64 151.08,14.64 150.92,14.49 143.47,14.49 142.5,13.52 139.85,13.52 138.39,12.06 125.17,12.06 124.75,11.63 121.1,11.63 119.81,10.34 117.11,10.34 116.14,9.37 116.14,9.17 116.22,9.08 v2(116.4,9.08)
  BOTTOM w0.089: UH1.D34 197.69,39.03 197.69,39.34 197.88,39.53 197.88,42.32 196.64,43.57 196.29,43.57 v2(196.14,43.42)
PCIE_PTX_DRX_P10: length 209.7
  TOP w0.127: C372.1 29.99,5.68 29.99,5.39 30.25,5.13 34.49,5.13 35.67,6.31 37.72,6.31 38.16,5.87 41.11,5.87 46.06,10.83 46.43,10.83 47.1,11.5 52.98,11.5 53.77,10.71 58.53,10.71 61.2,13.38 62.04,13.38 66.27,17.61 69.78,17.61 75.07,22.91 83.61,22.91 88.22,18.3 96,18.3 100.08,14.22 100.08,10.02 102.56,7.55 116.51,7.55 117.66,8.7 117.66,9.25 118.01,9.6 118.79,9.6 118.89,9.49 118.89,9.3 v2(118.66,9.07)
  IN1 w0.135: v2(118.66,9.07) 118.79,9.2 118.79,9.46 119.23,9.9 119.99,9.9 121.28,11.19 124.93,11.19 125.36,11.62 138.57,11.62 140.03,13.08 142.69,13.08 142.96,13.35 150.63,13.35 151.48,14.2 152.49,14.2 154.37,16.09 172.27,16.09 172.99,16.81 173.73,16.81 176.79,19.87 177.37,19.87 181.55,24.05 181.55,25.21 187.35,31.01 187.35,38.38 191.02,42.06 194.36,42.06 195.03,42.73 196.02,42.73 v2(196.12,42.83)
  BOTTOM w0.089: UH1.B35 197.53,39.75 197.53,39.96 197.67,40.1 197.67,41.91 196.97,42.61 196.1,42.61 196.05,42.67 196.05,42.75 v2(196.12,42.83)
PCIE_PTX_DRX_P11: length 212.1
  TOP w0.127: C374.1 26.93,5.64 26.93,5.05 27.58,4.39 34.73,4.39 35.96,5.62 37.32,5.62 37.76,5.18 41.39,5.18 46.34,10.13 46.73,10.13 47.4,10.79 52.71,10.79 53.48,10.02 58.81,10.02 61.49,12.69 62.36,12.69 66.28,16.61 69.78,16.61 75.34,22.16 83.22,22.16 87.8,17.59 95.71,17.59 99.39,13.9 99.39,9.74 102.42,6.72 119.32,6.72 121.08,8.47 121.08,8.9 v2(121.25,9.07)
  IN1 w0.135: v2(121.25,9.07) 121.16,8.98 121.07,8.98 120.99,9.06 120.99,9.48 121.7,10.2 125.34,10.2 125.77,10.62 138.98,10.62 140.44,12.08 143.1,12.08 143.37,12.36 151.24,12.36 152.09,13.21 153,13.21 154.89,15.09 172.69,15.09 173.4,15.81 174.14,15.81 177.21,18.87 177.89,18.87 182.63,23.62 182.63,24.41 183.43,25.21 183.81,25.21 185.1,26.5 185.1,27.34 186.25,28.5 186.92,28.5 188.37,29.95 188.37,37.84 189.03,38.51 189.5,38.51 191.66,40.66 194.87,40.66 195.58,41.37 195.8,41.37 195.88,41.29 195.88,41.18 195.99,41.07 v2(196.17,41.07)
  BOTTOM w0.089: UH1.C36 196.67,39.53 196.67,39.93 196.83,40.1 196.83,40.26 196.9,40.33 196.9,40.33 197,40.43 197.11,40.54 197.11,41.05 196.86,41.3 196.4,41.3 v2(196.17,41.07)
PCIE_PTX_DRX_P12: length 216.3
  TOP w0.127: C376.1 23.93,5.77 23.93,4.95 25.19,3.69 35.01,3.69 36.25,4.93 36.95,4.93 37.38,4.49 41.75,4.49 46.67,9.42 47.03,9.42 47.59,9.98 52.54,9.98 53.2,9.33 59.1,9.33 61.77,12 62.87,12 66.68,15.82 70.04,15.82 75.57,21.35 82.92,21.35 87.49,16.78 95.55,16.78 98.71,13.62 98.71,9.28 101.98,6 124.39,6 124.74,6.35 124.74,6.64 v2(124.89,6.79)
  IN1 w0.135: v2(124.89,6.79) 124.69,6.99 124.69,7.2 124.81,7.32 129.14,7.32 129.67,6.79 135.36,6.79 136.16,7.59 140.02,7.59 140.82,8.39 152.27,8.39 156.1,12.22 168.41,12.22 169.79,10.83 174.53,10.83 175.78,12.08 177.19,12.08 179.81,14.69 185.19,14.69 185.88,15.39 185.88,15.66 187.62,17.41 187.62,17.83 188.04,18.25 188.04,19.25 187.72,19.57 187.72,20.24 188.08,20.6 188.08,23.79 190.41,26.12 190.41,27.92 192,29.51 192,35.55 193.63,37.18 193.63,37.69 193.92,37.98 194.36,37.98 194.53,37.81 194.53,37.67 194.65,37.55 194.85,37.55 v2(195.02,37.72)
  BOTTOM w0.089: v2(195.02,37.72) 195.02,37.79 195.28,38.05 195.35,38.05 195.52,38.22 196,38.22 196.23,38.46 UH1.E37
PCIE_PTX_DRX_P14: length 5.7
  BOTTOM w0.089: 194.89,41.67 194.89,41.65 194.92,41.61 194.92,41.13 195.19,40.86 195.19,40.44 195.6,40.04 195.6,39.47 195.52,39.39 195.52,39.01 UH1.D39
  BOTTOM w0.127: 194.89,41.67 194.89,42.04 194.29,42.63 194.29,43.4 CH75.2
PCIE_PTX_DRX_P15: length 5.7
  BOTTOM w0.089: UH1.C40 194.96,39.42 194.96,39.92 194.82,40.05 194.82,40.68 194.48,41.02 194.48,41.14 194.32,41.31 194.27,41.31 194.26,41.32
  BOTTOM w0.127: CH77.2 192.46,43.4 192.46,43.12 194.26,41.32
PCIE_PTX_DRX_P16: length 7.4
  BOTTOM w0.089: UH1.C41 194.62,39.38 194.46,39.38 194.28,39.57 194.28,40.09 194.45,40.27 194.45,40.52 194.18,40.8 193.76,40.8 193.73,40.76 193.71,40.76
  BOTTOM w0.127: CH61.2 190.51,43.36 190.51,42.74 192.48,40.76 193.71,40.76
PCIE_RCOMPN: length 5.3
  BOTTOM w0.203: 208.73,40.86 208.92,40.68 208.92,40.23 208.77,40.08 UH1.B12
  BOTTOM w0.305: 208.73,40.86 208.12,41.47 208.12,42.81 207.75,43.18 206.51,43.18 RH21.1
PCIE_RCOMPP: length 5.3
  BOTTOM w0.305: UH1.A13 207.67,41.32 207.67,42.55 207.52,42.7 v1(207.45,42.7) 207.16,42.7 207,42.54 207,41.91 206.81,41.73 206.52,41.73 206.33,41.92 RH21.2
PD_EE_CLK: length 35.4
  TOP w0.127: v2(53.92,47.53) 54.54,46.92 CU68.1 54.17,46.47 53.61,46.47 53.25,46.11 RU62.2 ; v1(59.54,30.36) 59.3,30.61 v2(59.3,31.45)
  IN3 w0.127: v2(59.3,31.45) 59.3,31.53 61.19,33.42 62.26,33.42 62.54,33.71 62.54,40.09 63.08,40.63 63.08,43.87 62.27,44.69 56.34,44.69 53.92,47.1 v2(53.92,47.53)
  BOTTOM w0.127: UU5.6 61.44,27.14 61.23,27.35 61.23,28.01 60.35,28.9 60.35,30.4 v2(59.3,31.45)
PD_EE_CLK_R: length 2.7
  TOP w0.127: RU62.1 52.34,45.63 v1(51.59,44.88) 51.17,44.46 UU4.38
PD_EE_CS_N: length 36.1
  TOP w0.127: UU4.39 51.09,44.86 51.84,45.61 51.84,46.22 52.01,46.38 53.16,46.38 53.36,46.59 v2(53.36,47.68) ; v2(58.01,31.61) 58.01,31.83 v1(57.55,32.29)
  IN3 w0.127: v2(53.36,47.68) 53.36,47.22 56.69,43.89 56.69,37.08 57.89,35.88 57.89,31.73 v2(58.01,31.61)
  BOTTOM w0.127: RU70.2 55.86,25.91 55.86,25.19 56.45,24.6 UU5.1 57.93,24.6 58.11,24.78 58.11,25.7 59.18,26.76 59.18,28.31 58.38,29.11 58.38,30.42 58.01,30.78 v2(58.01,31.61)
PD_EE_DI: length 37.5
  TOP w0.127: v1(60.49,31.28) 60.21,31.56 v2(59.92,31.56) ; v2(54.67,47.45) 54.74,47.45 55.02,47.17 55.02,45.59 54.84,45.4 52.7,45.4 51.36,44.06 UU4.37
  IN3 w0.127: v2(54.67,47.45) 54.67,46.73 56.45,44.96 62.39,44.96 63.35,43.99 63.35,40.52 62.81,39.98 62.81,33.59 62.37,33.15 61.51,33.15 v2(59.92,31.56)
  BOTTOM w0.127: v2(59.92,31.56) 60.61,30.87 60.61,29 61.2,28.41 UU5.5
PD_EE_DO: length 48
  TOP w0.127: v2(55.43,47.24) 55.67,47.01 v1(55.67,45.97) 55.67,45.87 54.94,45.14 52.81,45.14 51.33,43.66 UU4.36
  IN3 w0.127: v2(63.1,32.16) 63.08,32.18 63.08,39.87 63.62,40.41 63.62,44.1 62.5,45.22 56.56,45.22 55.16,46.62 55.16,46.97 v2(55.43,47.24)
  BOTTOM w0.127: RU69.2 56.71,25.87 UU5.2 57.91,25.87 58.91,26.87 58.91,28.2 58.12,29 58.12,30.27 57.59,30.79 57.59,32.47 58.64,33.51 62.31,33.51 63.1,32.72 v2(63.1,32.16)
PD_EE_WP_N: length 3.5
  BOTTOM w0.127: UU5.3 56.4,27.14 55.22,28.32 RU68.2 v1(55.05,29.36)
PD_HOLD_N: length 5.1
  BOTTOM w0.127: RU71.2 59.75,29.12 60.76,28.1 v2(60.76,27.48) 60.76,26.59 61.48,25.87 UU5.7
PDB: length 7.1
  TOP w0.135: UA1.2 293.22,17.75 v1(292.58,17.11) 291.98,16.51 CA94.2 291.98,15.69 RA15.1 291.93,15.06 RA26.2 291.98,14.7 292.51,14.17 DA3.2 292.51,13.87 QA2.1
PEDET: length 5.6
  TOP w0.127: v2(19.11,8.16) 19.52,7.76 Q79.2 19.04,7.28 18.9,7.42 EC11.1 18.08,7.42 17.93,7.26 R5220.2 v1(16.32,7.26)
  BOTTOM w0.127: JSSD1.61 18.85,8.43 v2(19.11,8.16)
PEG_CRX_C_GTX_N0: length 18.9
  TOP w0.076: 192.57,85.07 192.58,85.07 192.62,85.11 193.64,85.11 194.12,85.6 196.21,85.6 196.6,85.98 v2(196.66,85.98)
  TOP w0.127: 192.57,85.07 190.57,85.07 190.37,85.28 187.96,85.28 187.76,85.07 v4(180.89,85.07) 179.32,85.07 CG532.2
  BOTTOM w0.076: v2(196.66,85.98) 196.66,86.31 UG1.AJ14
PEG_CRX_C_GTX_N1: length 22.5
  TOP w0.076: 192.49,86.19 192.51,86.19 192.56,86.24 193.46,86.24 193.88,86.66 194.63,86.66 194.83,86.46 197.37,86.46 v2(197.68,86.14)
  TOP w0.127: 192.49,86.19 v4(188.45,86.19) 176.57,86.19 CG534.2
  BOTTOM w0.076: UG1.AG14 v2(197.68,86.14)
PEG_CRX_C_GTX_N2: length 17.8
  TOP w0.076: v2(196.02,87.72) 195.74,87.44 193.79,87.44 193.73,87.5 192.43,87.5 192.37,87.55 192.38,87.56 192.37,87.56
  TOP w0.127: CG536.2 179.35,87.56 v4(190.44,87.56) 192.37,87.56
  BOTTOM w0.076: UG1.AJ15 v2(196.02,87.72)
PEG_CRX_C_GTX_N3: length 20
  TOP w0.076: v2(195.2,87.81) 195.2,88.04 195.11,88.13 193.17,88.13 192.88,88.42 192.4,88.42 192.36,88.37
  TOP w0.127: CG538.2 176.6,88.37 v4(183.63,88.37) 192.36,88.37
  BOTTOM w0.076: UG1.AK16 v2(195.2,87.81)
PEG_CRX_C_GTX_N4: length 19
  TOP w0.076: v2(196.83,88.64) 196.58,88.89 196.58,89.02 196.39,89.2 193.25,89.2 192.83,89.62 192.46,89.62 192.41,89.67 192.39,89.67
  TOP w0.127: CG540.2 179.39,89.67 v4(189.07,89.67) 192.39,89.67
  BOTTOM w0.076: UG1.AJ17 v2(196.83,88.64)
PEG_CRX_C_GTX_N5: length 23.1
  TOP w0.076: 192.35,90.24 192.35,90.24 192.36,90.24 192.41,90.29 192.66,90.29 193.45,89.51 196.82,89.51 197.37,88.96 197.51,88.96 197.57,88.96 197.67,88.86 v2(197.67,88.63)
  TOP w0.127: CG542.2 176.58,90.52 183.29,90.52 183.57,90.24 v4(184.6,90.24) 192.35,90.24
  BOTTOM w0.076: UG1.AG17 v2(197.67,88.63)
PEG_CRX_C_GTX_N6: length 19.5
  TOP w0.076: v2(196.85,90.26) 196.57,90.26 196.17,90.65 195.81,90.65 195.41,90.24 195.41,90.24 193.76,90.24 192.77,91.23 192.33,91.23 192.28,91.29 192.26,91.29
  TOP w0.127: 192.26,91.29 v4(187.7,91.29) 184.08,91.29 183.51,91.86 179.37,91.86 CG544.2
  BOTTOM w0.076: UG1.AJ18 v2(196.85,90.26)
PEG_CRX_C_GTX_N7: length 21.6
  TOP w0.076: 192.26,91.84 192.28,91.84 192.33,91.89 192.63,91.89 194,90.52 195.38,90.52 195.96,91.11 v2(196,91.11)
  TOP w0.127: 192.26,91.84 184.49,91.84 183.67,92.67 v4(183.14,92.67) 176.57,92.67 CG546.2
  BOTTOM w0.076: UG1.AK19 v2(196,91.11)
PEG_CRX_C_GTX_P0: length 18.9
  TOP w0.076: v2(196.06,85.99) 196.12,85.93 196.12,85.82 196.05,85.75 194.06,85.75 193.58,85.26 192.63,85.26 192.57,85.32 192.58,85.33 192.57,85.33
  TOP w0.127: CG531.2 179.05,85.47 179.19,85.33 187.65,85.33 187.85,85.53 190.48,85.53 190.68,85.33 v4(191.43,85.33) 192.57,85.33
  BOTTOM w0.076: UG1.AK14 195.89,86.54 196.06,86.37 v2(196.06,85.99)
PEG_CRX_C_GTX_P1: length 22.5
  TOP w0.076: 192.49,86.45 192.51,86.45 192.5,86.44 192.55,86.4 193.4,86.4 193.82,86.81 194.7,86.81 194.89,86.62 197.36,86.62 v2(197.67,86.93)
  TOP w0.127: 192.49,86.45 v4(184.65,86.45) 176.57,86.45 CG533.2
  BOTTOM w0.076: UG1.AH14 v2(197.67,86.93)
PEG_CRX_C_GTX_P2: length 17.8
  TOP w0.076: v2(196.02,87.02) 196.02,87.08 195.81,87.29 193.73,87.29 193.67,87.35 192.42,87.35 192.38,87.3 192.37,87.3
  TOP w0.127: CG535.2 179.39,87.3 v4(180.95,87.3) 192.37,87.3
  BOTTOM w0.076: UG1.AK15 v2(196.02,87.02)
PEG_CRX_C_GTX_P3: length 20
  TOP w0.076: v2(195.19,88.6) 195.19,88.42 195.05,88.28 193.23,88.28 192.94,88.57 192.43,88.57 192.38,88.62 192.39,88.63 192.37,88.63
  TOP w0.127: CG537.2 176.55,88.63 v4(186.97,88.63) 192.37,88.63
  BOTTOM w0.076: UG1.AL16 v2(195.19,88.6)
PEG_CRX_C_GTX_P4: length 19
  TOP w0.076: v2(195.98,88.64) 196.32,88.64 196.43,88.75 196.43,88.95 196.33,89.05 193.19,89.05 192.77,89.47 192.46,89.47 192.41,89.42 192.4,89.42 192.4,89.42
  TOP w0.127: 192.4,89.42 v4(181.17,89.42) 179.34,89.42 CG539.2
  BOTTOM w0.076: v2(195.98,88.64) 195.73,88.89 UG1.AK17
PEG_CRX_C_GTX_P5: length 23.1
  TOP w0.076: v2(197.67,89.43) 197.67,89.19 197.6,89.11 197.51,89.11 197.43,89.11 196.88,89.66 193.51,89.66 192.73,90.45 192.41,90.45 192.36,90.5 192.34,90.5
  TOP w0.127: CG541.2 176.56,90.78 183.4,90.78 183.68,90.5 v4(191.52,90.5) 192.34,90.5
  BOTTOM w0.076: UG1.AH17 v2(197.67,89.43)
PEG_CRX_C_GTX_P6: length 19.5
  TOP w0.076: v2(196,90.26) 196.08,90.34 196.27,90.34 196.38,90.22 196.38,90.06 196.21,89.88 195.73,89.88 195.52,90.09 193.69,90.09 192.7,91.08 192.33,91.08 192.28,91.03
  TOP w0.127: 192.28,91.03 183.97,91.03 183.4,91.6 v4(181.93,91.6) 179.36,91.6 CG543.2
  BOTTOM w0.076: UG1.AK18 v2(196,90.26)
PEG_CRX_C_GTX_P7: length 21.6
  TOP w0.076: 192.26,92.1 192.28,92.1 192.33,92.05 192.69,92.05 194.06,90.68 195.32,90.68 195.6,90.96 195.6,91.05 195.54,91.11 v2(195.2,91.11)
  TOP w0.127: 192.26,92.1 184.6,92.1 183.77,92.92 v4(180.37,92.92) 176.57,92.92 CG545.2
  BOTTOM w0.076: UG1.AL19 v2(195.2,91.11)
PEG_CRX_GTX_N0: length 15.3
  TOP w0.076: v2(165.62,88.03) 165.43,87.84 165.43,87.73 165.5,87.65 165.94,87.65 166.02,87.73 166.02,87.96 166.1,88.03 166.29,88.03 166.59,87.73 167.19,87.73 167.65,87.27 169.21,87.27 169.26,87.21 169.27,87.21
  TOP w0.127: 169.27,87.21 169.63,87.21 169.69,87.28 171.86,87.28 v4(172.77,86.36) 174.01,85.13 177.82,85.13 CG532.1
  BOTTOM w0.076: UC1.E10 v2(165.62,88.03)
PEG_CRX_GTX_N1: length 11.6
  TOP w0.076: 169.45,87.99 169.43,87.99 169.38,88.04 169,88.04 168.81,87.85 167.86,87.85 167.48,88.24 166.7,88.24 166.52,88.42 166.02,88.42 v2(165.62,88.82)
  TOP w0.127: CG534.1 175.11,86.11 174.37,86.11 172.48,87.99 v4(172.17,87.99) 169.45,87.99
  BOTTOM w0.076: UC1.E11 v2(165.62,88.82)
PEG_CRX_GTX_N2: length 15.7
  TOP w0.076: v2(164.97,89.61) 164.76,89.61 164.69,89.54 164.69,89.29 164.8,89.18 165.15,89.18 165.44,89.46 167.39,89.46 167.85,89 169.36,89 169.4,89.04
  TOP w0.127: 169.4,89.04 172.89,89.04 v4(173.74,88.19) 174.4,87.52 177.95,87.52 178.14,87.71 CG536.1
  BOTTOM w0.076: UC1.E12 v2(164.97,89.61)
PEG_CRX_GTX_N3: length 11.4
  TOP w0.076: 169.42,89.55 169.4,89.55 169.35,89.61 168.96,89.61 168.79,89.43 168,89.43 167.62,89.81 166.04,89.81 165.84,90.01 165.84,90.18 v2(165.62,90.4)
  TOP w0.127: CG538.1 175.05,88.33 174.46,88.33 173.23,89.55 v4(169.87,89.55) 169.42,89.55
  BOTTOM w0.076: UC1.E13 v2(165.62,90.4)
PEG_CRX_GTX_N4: length 14.5
  TOP w0.076: 169.29,90.62 169.25,90.57 167.8,90.57 167.42,90.96 165.61,90.96 165.56,91.01 165.56,91.12 v2(165.62,91.18)
  TOP w0.127: CG540.1 178.14,89.7 178.05,89.61 177.06,89.61 176.96,89.71 174.52,89.71 v4(173.96,90.26) 173.61,90.62 169.29,90.62
  BOTTOM w0.076: v2(165.62,91.18) 165.67,91.23 165.67,91.46 165.51,91.63 165.38,91.63 UC1.E14
PEG_CRX_GTX_N5: length 11.2
  TOP w0.076: 169.32,91.12 169.31,91.12 169.25,91.18 169.04,91.18 168.84,90.98 168,90.98 167.6,91.39 166.04,91.39 165.84,91.58 165.84,91.75 v2(165.62,91.97)
  TOP w0.127: 169.32,91.12 v4(169.74,91.12) 173.94,91.12 174.63,90.43 175.11,90.43 CG542.1
  BOTTOM w0.076: UC1.E15 v2(165.62,91.97)
PEG_CRX_GTX_N6: length 14.3
  TOP w0.076: 169.32,92.19 169.29,92.19 169.25,92.15 167.84,92.15 167.49,92.49 165.62,92.49 165.53,92.58 165.53,92.66 v2(165.62,92.76)
  TOP w0.127: CG544.1 178.14,91.87 178.06,91.79 176.93,91.79 176.87,91.86 174.75,91.86 174.42,92.19 v4(170.92,92.19) 169.32,92.19
  BOTTOM w0.076: v2(165.62,92.76) 165.53,92.67 165.44,92.67 165.35,92.76 165.35,92.87 165.31,92.91 UC1.E16
PEG_CRX_GTX_N7: length 10.9
  TOP w0.076: v2(165.62,93.55) 165.84,93.33 165.84,93.16 166.04,92.96 167.66,92.96 168.06,92.56 168.74,92.56 168.9,92.72 169.27,92.72 169.32,92.67 169.34,92.67
  TOP w0.127: 169.34,92.67 v4(172.47,92.67) 175.02,92.67 CG546.1
  BOTTOM w0.076: UC1.E17 v2(165.62,93.55)
PEG_CRX_GTX_P0: length 15.3
  TOP w0.076: 169.27,87.47 169.27,87.47 169.22,87.42 167.71,87.42 167.25,87.88 166.65,87.88 166.35,88.19 165.99,88.19 165.77,88.42 165.35,88.42 v2(164.97,88.03)
  TOP w0.127: 169.27,87.47 169.53,87.47 169.59,87.53 v4(169.99,87.53) 171.96,87.53 172.96,86.54 174.11,85.38 177.82,85.38 CG531.1
  BOTTOM w0.076: UC1.F10 v2(164.97,88.03)
PEG_CRX_GTX_P1: length 11.6
  TOP w0.076: 169.46,88.25 169.4,88.2 168.94,88.2 168.75,88.01 167.93,88.01 167.55,88.39 166.76,88.39 166.58,88.57 166.33,88.57 166.27,88.63 v2(166.27,88.82)
  TOP w0.127: 169.46,88.25 172.59,88.25 v4(174.04,86.8) 174.47,86.37 175.28,86.37 175.34,86.43 CG533.1
  BOTTOM w0.076: UC1.D11 166.07,89.29 166.21,89.27 166.35,89.1 166.32,88.86 v2(166.27,88.82)
PEG_CRX_GTX_P2: length 15.7
  TOP w0.076: v2(164.32,89.61) 164.54,89.39 164.54,89.22 164.74,89.02 165.22,89.02 165.5,89.3 167.33,89.3 167.79,88.85 169.33,88.85 169.39,88.79
  TOP w0.127: 169.39,88.79 v4(171.01,88.79) 172.78,88.79 173.56,88.01 174.3,87.27 177.83,87.27 CG535.1
  BOTTOM w0.076: UC1.F12 v2(164.32,89.61)
PEG_CRX_GTX_P3: length 11.4
  TOP w0.076: 169.42,89.81 169.37,89.76 168.9,89.76 168.72,89.58 168.06,89.58 167.68,89.96 166.1,89.96 165.99,90.07 165.99,90.34 166.05,90.4 v2(166.27,90.4)
  TOP w0.127: 169.42,89.81 v4(172.43,89.81) 173.34,89.81 174.56,88.59 175.14,88.59 175.34,88.78 CG537.1
  BOTTOM w0.076: UC1.D13 v2(166.27,90.4)
PEG_CRX_GTX_P4: length 14.5
  TOP w0.076: 169.29,90.36 169.28,90.37 169.27,90.37 169.22,90.42 167.73,90.42 167.35,90.8 165.47,90.8 165.09,91.18 v2(164.97,91.18)
  TOP w0.127: 169.29,90.36 169.29,90.36 v4(171.01,90.36) 173.5,90.36 173.78,90.08 174.41,89.45 176.85,89.45 176.95,89.35 177.91,89.35 CG539.1
  BOTTOM w0.076: UC1.F14 v2(164.97,91.18)
PEG_CRX_GTX_P5: length 11.2
  TOP w0.076: 169.32,91.38 169.31,91.38 169.26,91.34 168.98,91.34 168.78,91.13 168.06,91.13 167.66,91.54 166.1,91.54 165.99,91.65 165.99,91.82 166.14,91.97 v2(166.27,91.97)
  TOP w0.127: 169.32,91.38 v4(172.23,91.38) 174.04,91.38 174.74,90.69 175.09,90.69 175.34,90.94 CG541.1
  BOTTOM w0.076: UC1.D15 v2(166.27,91.97)
PEG_CRX_GTX_P6: length 14.3
  TOP w0.076: 169.31,91.94 169.31,91.95 169.3,91.95 169.25,92 167.77,92 167.43,92.34 165.51,92.34 165.09,92.76 v2(164.97,92.76)
  TOP w0.127: 169.31,91.94 169.32,91.94 v4(173.88,91.94) 174.32,91.94 174.65,91.61 176.76,91.61 176.83,91.54 177.88,91.54 CG543.1
  BOTTOM w0.076: UC1.F16 v2(164.97,92.76)
PEG_CRX_GTX_P7: length 10.9
  TOP w0.076: 169.33,92.93 169.28,92.87 168.84,92.87 168.67,92.71 168.13,92.71 167.72,93.11 166.1,93.11 165.99,93.22 165.99,93.49 166.05,93.55 v2(166.27,93.55)
  TOP w0.127: CG545.1 175.34,93.11 175.15,92.93 v4(169.74,92.93) 169.33,92.93
  BOTTOM w0.076: UC1.D17 v2(166.27,93.55)
PEG_CTX_C_GRX_N0: length 17.7
  BOTTOM w0.076: 191.34,85.61 191.35,85.6 191.36,85.6 191.41,85.54 192.64,85.54 192.84,85.34 193.47,85.34 193.68,85.12 193.68,84.9 193.74,84.84 UG1.AM12
  BOTTOM w0.127: 191.34,85.61 191.34,85.61 v4(188.76,85.61) 179.47,85.61 178.22,86.85 177.56,86.85 CC16.2
PEG_CTX_C_GRX_N1: length 20.9
  BOTTOM w0.076: UG1.AM14 193.79,86.54 193.72,86.47 193.72,86.27 193.48,86.04 192.13,86.04 192.02,86.15 191.41,86.15 191.36,86.09 191.35,86.09 191.34,86.09
  BOTTOM w0.127: 191.34,86.09 191.34,86.08 v4(180.57,86.08) 180.08,86.08 178.58,87.58 174.53,87.58 CC14.2
PEG_CTX_C_GRX_N2: length 16.3
  BOTTOM w0.076: UG1.AP15 192.38,87.09 192.3,87.02 191.41,87.02 191.36,87.07 191.35,87.07 191.34,87.08
  BOTTOM w0.127: CC12.2 177.64,88.93 178.86,88.93 180.71,87.08 v4(187.85,87.08) 191.34,87.08 191.34,87.08
PEG_CTX_C_GRX_N3: length 21.5
  BOTTOM w0.076: 191.34,87.69 191.38,87.69 191.42,87.74 192.73,87.74 192.84,87.62 192.84,87.19 193.04,86.99 193.63,86.99 193.92,87.28 UG1.AM15
  BOTTOM w0.127: 191.34,87.69 v4(189.48,87.69) 181.07,87.69 179.01,89.75 174.54,89.75 CC10.2
PEG_CTX_C_GRX_N4: length 18.5
  BOTTOM w0.076: 191.34,88.71 191.36,88.71 191.41,88.66 192.74,88.66 192.84,88.76 192.84,89.17 193.07,89.4 193.62,89.4 UG1.AM17
  BOTTOM w0.127: CC8.2 177.65,91.09 179.16,91.09 181.54,88.71 v4(186.57,88.71) 191.34,88.71
PEG_CTX_C_GRX_N5: length 21.2
  BOTTOM w0.076: 191.05,89.47 191.09,89.52 191.36,89.52 191.74,89.89 191.97,89.89 192.05,89.81 192.05,89.7 191.82,89.47 191.82,89.39 191.92,89.28 192.03,89.28 192.13,89.38 192.5,89.38 192.61,89.49 192.61,89.76 192.54,89.84 UG1.AP18
  BOTTOM w0.127: CC6.2 174.54,91.91 179.22,91.91 181.66,89.47 v4(188.17,89.47) 191.05,89.47
PEG_CTX_C_GRX_N6: length 18.4
  BOTTOM w0.076: 191.09,90.48 191.1,90.47 191.11,90.47 191.16,90.42 191.36,90.42 191.64,90.7 192.69,90.7 193.04,90.35 193.48,90.35 UG1.AM18
  BOTTOM w0.127: 191.09,90.48 v4(185.35,90.48) 182.16,90.48 179.37,93.27 177.62,93.27 CC4.2
PEG_CTX_C_GRX_N7: length 21.4
  BOTTOM w0.076: 191.34,90.98 191.36,90.98 191.41,91.04 193.48,91.04 UG1.AM20
  BOTTOM w0.127: 191.34,90.98 v4(187.36,90.98) 182.6,90.98 179.51,94.07 174.54,94.07 CC2.2
PEG_CTX_C_GRX_P0: length 17.7
  BOTTOM w0.076: 191.34,85.35 191.38,85.39 192.58,85.39 192.78,85.19 193.4,85.19 193.53,85.06 193.53,84.9 193.47,84.84 UG1.AN12
  BOTTOM w0.127: CC15.2 177.32,86.45 177.47,86.6 178.12,86.6 179.36,85.35 v4(187.08,85.35) 191.34,85.35
PEG_CTX_C_GRX_P1: length 20.9
  BOTTOM w0.076: UG1.AN14 193.5,86.54 193.56,86.48 193.56,86.34 193.42,86.19 192.19,86.19 192.08,86.3 191.41,86.3 191.36,86.34 191.34,86.34
  BOTTOM w0.127: 191.34,86.34 191.01,86.34 191.01,86.34 v4(183.3,86.34) 180.18,86.34 178.69,87.84 174.35,87.84 174.22,87.96 CC13.2
PEG_CTX_C_GRX_P2: length 16.3
  BOTTOM w0.076: 191.34,86.82 191.35,86.82 191.4,86.86 192.3,86.86 192.38,86.79 UG1.AP14
  BOTTOM w0.127: CC11.2 177.63,88.68 178.75,88.68 180.61,86.82 v4(185.72,86.82) 191.34,86.82
PEG_CTX_C_GRX_P3: length 21.5
  BOTTOM w0.076: 191.34,87.95 191.35,87.94 191.36,87.94 191.41,87.89 192.79,87.89 192.98,87.7 193.5,87.7 193.63,87.57 193.63,87.21 193.55,87.14 193.38,87.14 UG1.AN15
  BOTTOM w0.127: CC9.2 174.54,90 179.12,90 181.17,87.95 v4(182.38,87.95) 191.34,87.95
PEG_CTX_C_GRX_P4: length 18.5
  BOTTOM w0.076: UG1.AN17 193.39,89.25 193.56,89.25 193.63,89.18 193.63,88.81 193.5,88.69 192.98,88.69 192.8,88.51 191.39,88.51 191.33,88.46
  BOTTOM w0.127: 191.33,88.46 v4(184.55,88.46) 181.43,88.46 179.06,90.83 177.63,90.83 CC7.2
PEG_CTX_C_GRX_P5: length 21.1
  BOTTOM w0.076: 191.04,89.73 191.05,89.73 191.11,89.67 191.3,89.67 191.67,90.04 192.03,90.04 192.21,90.22 192.54,90.22 192.77,89.99 192.77,89.43 UG1.AP17
  BOTTOM w0.127: 191.04,89.73 v4(189.87,89.73) 181.77,89.73 179.33,92.17 174.53,92.17 CC5.2
PEG_CTX_C_GRX_P6: length 18.4
  BOTTOM w0.076: 191.08,90.23 191.12,90.27 191.42,90.27 191.7,90.55 192.63,90.55 192.98,90.19 193.41,90.19 193.57,90.04 193.57,89.9 193.51,89.84 UG1.AN18
  BOTTOM w0.127: 191.08,90.23 v4(183.3,90.23) 182.05,90.23 179.26,93.02 177.66,93.02 CC3.2
PEG_CTX_C_GRX_P7: length 21.4
  BOTTOM w0.076: 191.34,91.24 191.35,91.24 191.41,91.19 193.41,91.19 193.58,91.36 193.58,91.46 193.51,91.54 UG1.AN20
  BOTTOM w0.127: 191.34,91.24 v4(189.31,91.24) 182.7,91.24 179.62,94.33 174.54,94.33 CC1.2
PEG_CTX_GRX_N0: length 10.9
  BOTTOM w0.076: UC1.B10 167.21,88.47 167.04,88.47 166.96,88.39 166.96,88.27 167.05,88.19 167.13,88.11 168.17,88.11 168.26,88.01 168.67,88.01 168.85,88.19 169.3,88.19 169.35,88.23
  BOTTOM w0.127: CC16.1 176.07,86.75 v4(175.32,86.75) 172.78,86.75 171.3,88.23 169.35,88.23
PEG_CTX_GRX_N1: length 6.9
  BOTTOM w0.076: UC1.B11 167.73,88.73 168.24,88.73 168.31,88.8 169.22,88.8 169.27,88.75 169.28,88.75
  BOTTOM w0.127: CC14.1 173.01,87.57 172.64,87.57 172.64,87.57 172.63,87.57 172.48,87.73 v4(172.29,87.92) 171.46,88.75 169.29,88.75 169.29,88.75 169.28,88.75
PEG_CTX_GRX_N2: length 10.6
  BOTTOM w0.076: 169.34,89.81 169.32,89.81 169.27,89.76 168.85,89.76 168.67,89.58 168.26,89.58 168.17,89.68 167.13,89.68 167.05,89.77 166.96,89.85 166.96,89.94 167.05,90.03 167.22,90.03 UC1.B12
  BOTTOM w0.127: CC12.1 176.06,88.91 v4(175.32,88.91) 172.92,88.91 172.02,89.81 169.34,89.81
PEG_CTX_GRX_N3: length 6.7
  BOTTOM w0.076: 169.31,90.34 169.31,90.35 169.3,90.35 169.25,90.4 168.34,90.4 168.24,90.3 167.73,90.3 UC1.B13
  BOTTOM w0.127: 169.31,90.34 169.32,90.34 v4(169.68,90.34) 172.17,90.34 172.76,89.75 172.99,89.75 CC10.1
PEG_CTX_GRX_N4: length 10.4
  BOTTOM w0.076: 169.37,91.37 169.36,91.37 169.31,91.32 168.84,91.32 168.67,91.16 168.26,91.16 168.17,91.26 167.13,91.26 167.05,91.34 166.96,91.42 166.96,91.51 167.07,91.61 167.21,91.61 UC1.B14
  BOTTOM w0.127: CC8.1 176.06,91.06 v4(175.32,91.06) 173.01,91.06 172.7,91.37 169.37,91.37
PEG_CTX_GRX_N5: length 6.4
  BOTTOM w0.076: 169.34,91.92 169.32,91.92 169.27,91.97 168.34,91.97 168.24,91.88 167.73,91.88 UC1.B15
  BOTTOM w0.127: 169.34,91.92 v4(169.88,91.92) 172.98,91.92 CC6.1
PEG_CTX_GRX_N6: length 10.4
  BOTTOM w0.076: UC1.B16 167.21,93.19 167.04,93.19 166.96,93.11 166.96,93 167.05,92.92 167.13,92.83 168.17,92.83 168.26,92.73 168.67,92.73 168.85,92.91 169.29,92.91 169.33,92.95 169.34,92.95
  BOTTOM w0.127: 169.34,92.95 169.91,92.95 170.21,93.25 v4(175.32,93.25) 176.08,93.25 CC4.1
PEG_CTX_GRX_N7: length 6.7
  BOTTOM w0.076: 169.31,93.5 169.26,93.55 168.34,93.55 168.24,93.45 167.73,93.45 UC1.B17
  BOTTOM w0.127: CC2.1 172.99,94.07 v4(170.86,94.07) 170.3,94.07 169.73,93.5 169.31,93.5
PEG_CTX_GRX_P0: length 10.9
  BOTTOM w0.076: UC1.C10 167.07,87.95 168.1,87.95 168.2,87.86 168.74,87.86 168.91,88.03 169.27,88.03 169.32,87.98 169.33,87.98 169.34,87.97
  BOTTOM w0.127: CC15.1 176.12,86.5 172.68,86.5 172.68,86.5 172.67,86.5 172.51,86.66 171.2,87.97 v4(170.12,87.97) 169.34,87.97 169.34,87.97
PEG_CTX_GRX_P1: length 6.9
  BOTTOM w0.076: UC1.A11 167.86,89.25 167.71,89.25 167.61,89.15 167.61,89.06 167.8,88.88 168.18,88.88 168.25,88.95 169.22,88.95 169.27,89 169.29,89
  BOTTOM w0.127: CC13.1 172.97,87.82 172.75,87.82 172.74,87.83 172.74,87.83 171.57,89 v4(170.95,89) 169.29,89
PEG_CTX_GRX_P2: length 10.6
  BOTTOM w0.076: UC1.C12 167.07,89.53 168.1,89.53 168.2,89.43 168.74,89.43 168.91,89.6 169.27,89.6 169.32,89.56
  BOTTOM w0.127: CC11.1 176.12,88.65 172.81,88.65 v4(172.26,89.21) 171.91,89.56 169.32,89.56 169.32,89.56
PEG_CTX_GRX_P3: length 6.7
  BOTTOM w0.076: UC1.A13 167.86,90.83 167.69,90.83 167.61,90.75 167.61,90.64 167.7,90.55 167.8,90.45 168.18,90.45 168.27,90.55 169.28,90.55 169.32,90.59
  BOTTOM w0.127: 169.32,90.59 v4(170.95,90.59) 172.28,90.59 172.87,90 172.99,90 CC9.1
PEG_CTX_GRX_P4: length 10.4
  BOTTOM w0.076: 169.37,91.11 169.36,91.11 169.3,91.17 168.9,91.17 168.74,91.01 168.2,91.01 168.1,91.1 167.07,91.1 UC1.C14
  BOTTOM w0.127: CC7.1 176.13,90.8 172.91,90.8 172.6,91.11 v4(172.13,91.11) 169.37,91.11
PEG_CTX_GRX_P5: length 6.4
  BOTTOM w0.076: 169.34,92.18 169.33,92.18 169.28,92.12 168.27,92.12 168.18,92.03 167.8,92.03 167.7,92.13 167.61,92.21 167.61,92.33 167.69,92.4 167.86,92.4 UC1.A15
  BOTTOM w0.127: CC5.1 173.01,92.18 v4(171.16,92.18) 169.34,92.18
PEG_CTX_GRX_P6: length 10.4
  BOTTOM w0.076: UC1.C16 167.07,92.68 168.1,92.68 168.2,92.58 168.74,92.58 168.91,92.76 169.27,92.76 169.32,92.71 169.33,92.71 169.34,92.7
  BOTTOM w0.127: 169.34,92.7 169.34,92.7 170.02,92.7 170.31,92.99 v4(172.18,92.99) 176.1,92.99 CC3.1
PEG_CTX_GRX_P7: length 6.7
  BOTTOM w0.076: UC1.A17 167.86,93.98 167.69,93.98 167.61,93.9 167.61,93.79 167.7,93.7 167.8,93.6 168.18,93.6 168.27,93.7 169.26,93.7 169.31,93.75
  BOTTOM w0.127: 169.31,93.75 169.63,93.75 170.2,94.32 v4(172.22,94.32) 172.99,94.32 CC1.1
PEG_RCOMP: length 8.6
  BOTTOM w0.127: v1(169.2,77.82) 168.46,78.56 RC9.2
  BOTTOM w0.203: 167.72,80.92 167.47,81.18 165.9,81.18 164.72,82.35 164.72,82.67 164.23,83.17 UC1.G2
  BOTTOM w0.381: 167.72,80.92 168.46,80.19 RC9.2
PEX_TREMP: length 2.8
  BOTTOM w0.254: UG1.AP29 192.18,98.84 191.77,98.84 191.02,99.59 RG10.2
PG_+2.5V: length 28.7
  TOP w0.127: v2(99.61,24.2) v1(100.79,23.02) 102.65,21.16 106.68,21.16 107.5,20.34 107.5,17.5 106.91,16.91 PU2501.5 106.21,16.91 105.87,16.57 PR2504.2
  BOTTOM w0.127: PDM2.1 90.13,19.76 96.32,19.76 99.21,22.65 99.21,23.81 v2(99.61,24.2)
PIRQA#: length 3.1
  TOP w0.127: RH169.1 198.18,21.78 v2(198.4,21.99) 198.92,21.99 v1(199.09,21.83)
  BOTTOM w0.127: v2(198.4,21.99) 197.37,20.97 UH1.BA36
PLT_RST#: length 484.4
  TOP w0.102: 96.66,19.94 96.66,19.74 101.55,14.85 101.55,13.99 101.75,13.79 102.96,13.79 v2(103.23,13.79) ; 96.66,19.94 91.14,19.94 86.72,24.35 75.54,24.35 75.02,24.87 74.24,24.87 72.69,23.32 64.95,23.32 63.3,21.67 63.3,19.82 61.12,17.64 v1(61.02,17.64) 60.1,17.64 58.5,16.04 v2(58.28,16.04) ; 96.66,19.94 97.8,21.07 97.8,26.19 v2(97.66,26.34) ; v2(223.43,10.24) 220.37,7.18 215.35,7.18 215.19,7.33 CH79.2 RH7.2 216.62,8.63 UH3.4 ; UK1.13 142.04,7.13 141.84,6.93 CK4.1 RK31.2 143.08,6.55 143.29,6.35 143.29,4.85 ; 143.29,4.85 143.06,4.62 139.37,4.62 v2(138.26,5.73) ; 143.29,4.85 143.52,4.62 152.74,4.62 152.91,4.8 152.91,5.49 155.68,8.26 155.68,8.9 156.8,10.02 166.87,10.02 168.12,8.77 168.12,5.65 v2(168.7,5.07) ; v2(128.04,13.57) 128.81,14.34 R28.1
  IN1 w0.127: v2(32.86,60.7) 32.83,60.67 32.83,59.98 33.17,59.64 33.53,59.64 34.37,58.8 34.37,58.03 37.23,55.17 38.93,55.17 40.29,54.15 41.58,53.24 43.95,51.77 46.75,50.33 48.79,49.48 49.45,49.23 52.76,45.92 52.76,43.75 54.38,42.13 56.22,42.13 58,43.91 65.03,43.91 67.35,41.59 67.35,31.09 70.3,28.14 85.1,28.14 86.93,26.31 89.54,26.31 90.87,24.97 94.81,24.97 95.88,26.05 97.37,26.05 v2(97.66,26.34) ; v2(58.28,16.04) 58.28,15.72 56.75,14.18 50.31,14.18 49.48,15.01 45.98,15.01 45.42,14.44 44.36,14.44 44,14.07 v2(43.88,14.07) 43.48,13.66 v2(35.69,13.66)
  IN2 w0.127: v2(131.66,7.52) 131.66,6.79 133.4,5.06 137.59,5.06 v2(138.26,5.73)
  IN3 w0.127: v2(234.65,51.28) 234.65,50.33 234.1,49.77 234.1,49.2 234.64,48.66 234.64,47.19 234.88,46.95 234.88,41.38 233.69,40.19 233.69,39.04 227.09,32.45 227.09,30.98 223.48,27.36 223.48,20.83 224.69,19.61 v2(224.69,18.48) ; v2(168.7,5.07) 169.14,4.63 218.39,4.63 221.29,7.53 223.72,7.53 224.07,7.88 224.07,8.76 223.43,9.4 v2(223.43,10.24) 225.24,12.05 225.7,12.05 227.06,13.42 234.06,13.42 234.49,13.85 236.42,13.85 238.49,15.92 257.14,15.92 257.98,15.08 263.55,15.08 264.86,16.38 274.76,16.38 278.25,12.9 278.67,12.47 281.81,12.47 282.16,12.82 282.61,12.82 285.99,9.44 291.25,9.44 292.39,10.59 298.2,10.59 298.66,11.05 304.58,11.05 305.79,12.26 307.24,12.26 307.86,11.63 v2(308.87,11.63) ; v2(103.23,13.79) 103.71,13.79 104.88,14.96 111.69,14.96 112.34,14.32 114.6,14.32 114.75,14.47 119.4,14.47 119.86,14.01 125.19,14.01 125.65,13.56 128.02,13.56 v2(128.04,13.57)
  BOTTOM w0.102: JWLAN1.44 309.09,11.85 v2(308.87,11.63) ; UL1.19 56.31,17.23 56.83,16.71 57.02,16.71 57.21,16.52 57.86,16.52 58.28,16.09 v2(58.28,16.04) ; RV19.2 31.73,59.58 v2(32.86,60.7) ; UG2.1 234.94,51.57 v2(234.65,51.28) ; v2(224.69,18.48) 224.76,18.42 224.76,17.47 223.43,16.14 223.43,10.24 v2(223.43,10.24) ; v2(131.66,7.52) 131.66,9.19 131.03,9.83 131.03,10.58 v2(128.04,13.57) ; R5218.2 35.57,13.79 v2(35.69,13.66)
  BOTTOM w0.127: v2(43.88,14.07) 43.45,14.07 43.01,14.51 UR1.1
PLT_RST#_R: length 25.7
  BOTTOM w0.102: R5218.1 34.52,13.2 34.23,12.91 34.23,12.16 34.11,12.05 32.95,12.05 v1(32.19,11.29) 31.75,10.85 21.27,10.85 20.72,10.3 20.72,7.7 23.6,4.81 JSSD1.50
PLT_RST#_TPM: length 3.5
  TOP w0.102: UT1.17 126.25,15.16 127.04,14.37 R28.2 127.89,14.18 127.55,13.84 v1(127.55,13.4)
PLTRST_VGA#_1V8: length 109.8
  IN2 w0.127: v2(236.13,60.98) 234.8,60.98 233.68,59.87 233.68,56.28 235.21,54.76 235.21,51.18 234.82,50.79 231.68,50.79 230.34,49.44 224.49,49.44 221.58,52.35 195.87,52.35 192.91,55.31 192.91,70.03 193.81,70.93 193.81,73.63 191.46,75.98 191.46,76.33 192.05,76.92 192.05,78.1 v2(191.7,78.45)
  BOTTOM w0.127: UG1.AJ12 196,84.41 196,83.9 196.15,83.75 196.15,82.8 195.99,82.64 195.99,82.2 195.72,81.94 194.57,81.94 194.36,81.73 194.36,81.31 194.14,81.09 192.02,81.09 191.42,80.49 191.42,79.97 191.7,79.69 v2(191.7,78.45) 191.05,78.45 190.89,78.61 190.38,78.61 v1(189.36,79.63) 186,79.63 185.42,79.05 UG8.1 ; v2(236.13,60.98) 236.13,61.13 236.88,61.87 UG28.2 236.92,61.36 236.81,61.25 CG200.1 236.81,60.35 RG16.1 236.01,60.35 UG13.4 235.79,59.83 236.02,59.59 RG100.2 236.74,59.58 RG14.1 238.47,59.58 239.18,60.29 239.89,60.29 240.22,59.96 UG29.2
PLUG_IN#: length 47
  TOP w0.127: v2(282.12,26.12) v3(282.8,26.12)
  TOP w0.135: RA17.2 v2(291.17,14.63)
  IN2 w0.127: v2(282.12,26.12) 282.98,25.27 282.98,19.22 284.93,17.27 286.05,17.27 288.23,15.09 290.7,15.09 291.16,14.63 v2(291.17,14.63)
  BOTTOM w0.135: v2(282.12,26.12) 282.81,25.44 286.4,25.44 293.63,32.67 300.82,32.67 301.32,33.17 303.49,33.17 303.99,32.67 305.64,32.67 306.06,32.25 JIO1.28
PLUG_IN#_R: length 4.4
  TOP w0.135: RA16.1 RA17.1 291.17,16.46 291.31,16.6 v1(291.31,17.04) 291.59,17.32 291.59,18.87 291.75,19.03 UA1.48
PM_BATLOW#: length 7.2
  TOP w0.127: v2(191.41,15.52) 191.56,15.38 191.56,14.2 190.97,13.61 190.73,13.61 RH41.1
  BOTTOM w0.102: 192.43,17.42 192.49,17.49 192.78,17.49 192.84,17.55 192.84,18.03 UH1.BF44
  BOTTOM w0.127: 192.43,17.42 191.74,16.73 191.74,15.85 v2(191.41,15.52)
PM_CLKRUN#: length 2.5
  TOP w0.127: v1(199.1,23.17) 198.55,22.61 v2(198.39,22.61) 197.77,22.61 RH44.1
  BOTTOM w0.127: v2(198.39,22.61) 198.58,22.42 UH1.AV32
PM_SLP_A#: length 4.6
  BOTTOM w0.102: 194.88,16.22 194.93,16.28 194.93,17.32 195.12,17.52 195.12,18.95 UH1.BE40
  BOTTOM w0.127: 194.88,16.22 194.72,16.06 194.72,15.56 194.84,15.44 194.84,15.27 195.13,14.98 RH200.1
PM_SLP_S0#: length 5
  BOTTOM w0.102: UH1.BC28 200.96,19.68 200.96,19.09 200.86,18.99 200.86,18.11 201.19,17.78 201.19,17.13 200.75,16.69
  BOTTOM w0.127: 200.75,16.69 200.75,16.18 201.18,15.76 TH4972.1
PM_SLP_S3#: length 81.5
  TOP w0.127: RH197.2 191.98,13.22 v1(192.47,13.71) 192.74,13.98 v2(192.74,14.78) ; UK1.6 139.24,10.22 142.36,13.34 142.36,15.15 143.41,16.2 145.01,16.2 v2(145.48,16.68)
  IN1 w0.127: v2(192.74,14.78) 192.38,14.42 192.12,14.42 189.72,12.03 185.38,12.03 183.79,10.44 181.34,10.44 180.3,9.41 177.21,9.41 174.67,6.87 174.67,6.39 174.56,6.28 v2(170.86,6.28)
  BOTTOM w0.127: v2(170.86,6.28) 170.29,6.28 170.03,6.55 170.03,9.62 167.31,12.35 165.11,12.35 163.59,13.87 151.76,13.87 150.52,12.62 144.45,12.62 143.74,13.33 143.74,15 145.42,16.68 v2(145.48,16.68) ; v2(192.74,14.78) 192.23,15.29 192.23,15.65 193.16,16.57 193.16,16.95 193.81,17.6 193.81,18.05 UH1.BF42
PM_SLP_S4#: length 152
  TOP w0.127: PR2501.1 108,12.62 112.6,12.62 113.77,13.78 v3(113.77,14.25) 113.77,14.84 v2(114.32,15.39) 114.32,16.27 114.02,16.57 114.02,19.21 115,20.2 v2(115,22.86) ; v2(140.2,18.69) 140.29,18.59 140.29,17.62 139.32,16.64 139.32,14.51 136.63,11.82 UK1.123 ; v2(192.74,16.89) 192.74,16.79 192.23,16.28 192.23,15.27 192.35,15.16 192.35,14.24 191.22,13.11 RH198.2
  IN2 w0.127: v2(182.1,22.36) 182.09,22.36 181.46,22.36 180.82,21.73 180.82,19.93 184.25,16.51 188.1,16.51 188.48,16.89 v2(192.74,16.89)
  IN3 w0.127: v2(182.1,22.36) 181.88,22.58 180.14,22.58 179.81,22.25 177.83,22.25 177.31,22.77 169.67,22.77 169.45,22.99 166.15,22.99 165.82,22.67 161.71,22.67 161.47,22.91 160.09,22.91 159.64,23.36 152.59,23.36 150.11,20.88 147.49,20.88 146.16,19.55 144.8,19.55 143.81,18.55 141.4,18.55 140.83,19.12 140.63,19.12 v2(140.2,18.69) 140.29,18.59 140.29,17.84 136.62,14.17 133.97,14.17 133.59,13.79 132.15,13.79 131.69,14.26 128.69,14.26 127.46,15.49 125.71,15.49 125.01,14.8 120.17,14.8 119.72,15.24 114.46,15.24 v2(114.32,15.39)
  BOTTOM w0.127: v2(115,22.86) 114.09,23.77 111.17,23.77 109.99,24.95 106.66,24.95 105.67,25.93 104.88,25.93 104.8,26.01 103.7,26.01 103.18,25.5 102.97,25.5 101.88,24.41 100.19,24.41 99.98,24.62 99.43,24.62 98.95,24.14 98.95,22.76 96.34,20.14 94.66,20.14 94.47,20.33 PDM1.1 ; UH1.BE42 193.53,18.31 193.53,17.64 193.09,17.19 192.79,16.89 v2(192.74,16.89)
PM_SLP_S5#: length 64.3
  TOP w0.127: v1(183.12,16.31) RH199.2 184.14,16.72 v2(184.38,16.96) ; v2(144.52,13.89) 144.52,12.76 142.23,10.48 142.23,9.33 142.44,9.13 UK1.14
  IN3 w0.127: v2(144.52,13.89) 146.34,15.71 149.6,15.71 153.18,19.29 153.81,19.29 154.25,18.86 155.03,18.86 155.27,19.09 158.07,19.09 158.32,18.85 160.43,18.85 160.67,19.09 164.52,19.09 164.66,18.96 172.6,18.96 172.74,19.09 174.22,19.09 174.93,18.39 181.4,18.39 182.83,16.96 v2(184.38,16.96) 184.8,17.38 186.59,17.38 189.48,20.27 191.32,20.27 191.85,20.81 192.83,20.81 193.02,20.62 v2(193.82,20.62)
  BOTTOM w0.102: UH1.BC42 194.31,20.05 194.2,20.15 194.2,20.21 194.16,20.26 194.16,20.29 v2(193.82,20.62)
PM_SLP_SUS#: length 65.9
  TOP w0.127: v2(145.86,13.89) 145.86,13.28 142.76,10.18 142.76,9.55 143.24,9.07 UK1.16
  IN3 w0.127: v2(195.08,20) 195.17,19.91 195.17,16.98 194.48,16.29 190.48,16.29 189.16,14.98 181,14.98 180.6,15.38 180.6,16.36 178.84,18.12 152.7,18.12 149.76,15.18 147.15,15.18 v2(145.86,13.89)
  BOTTOM w0.122: v2(195.08,20) 195.5,20 195.83,19.67 UH1.BD39
  BOTTOM w0.127: v1(145.51,14.6) 145.86,14.25 v2(145.86,13.89)
PROC_SELECT#: length 8.7
  BOTTOM w0.137: TC97.1 124.89,77.4 124.89,79.16 127.09,81.36 128.64,81.36 129.3,82.02 UC1.BN1
PWM1_1PH/ICCMAX1: length 23.5
  TOP w0.127: v2(173.23,129.11) v1(174.08,129.11)
  IN1 w0.254: v2(173.23,129.11) 173.02,129.11 172.7,128.79 172.22,128.79 171.46,129.56 171.46,131.26 170.33,132.4 164.89,132.4 163.02,134.26 161.07,134.26 160.56,133.75 159.96,133.75 159.47,134.25 v2(159.47,134.39)
  BOTTOM w0.203: PUZ1.44 172.33,130.24 172.42,130.15 173.13,130.15 173.52,129.75 173.62,129.75 PRZ24.1 173.47,129.11 v2(173.23,129.11)
  BOTTOM w0.254: v2(159.47,134.39) 159.47,134.14 159.85,133.75 PUA1.2
PWM1_2PH/ICCMAX2: length 120
  TOP w0.254: v2(164.29,130.73) 164.39,130.83 PRZ58.1 165.1,131.04 161.88,134.26 161.37,134.26 160.74,133.63 158.39,133.63 157.37,134.65 154.1,134.65 153.29,133.84 152.06,133.84 151.31,134.58 146.92,134.58 146.2,133.86 144.52,133.86 143.78,134.6 139.27,134.6 138.48,133.81 137.1,133.81 136.37,134.54 131.91,134.54 131.24,133.86 129.38,133.86 128.82,134.42 124.41,134.42 122.99,133 122.99,124.89 126.35,121.53 126.35,117.15 121.7,112.49 121.7,112.49 121.03,111.82 121.03,111.82 119.18,109.97 115.73,109.97 112.07,106.31 109.56,106.31 107.16,103.91 v1(107.16,96.02) 107.16,91.83 107.8,91.18 115.8,91.18 116.49,91.87 119.99,91.87 120.6,92.48 120.6,94 120.2,94.4 PUG1.2
  BOTTOM w0.203: v2(164.29,130.73) 164.39,130.64 PUZ1.23
PWM1_4PH/ICCMAX4: length 27.7
  TOP w0.203: v2(162.89,128.5) 163.45,127.94 PRZ61.1
  IN2 w0.203: v2(152.22,136.43) 152.22,136.18 152.74,135.66 153.58,135.66 154.09,135.15 158.2,135.15 159.57,136.52 161.87,136.52 162.94,135.45 163.87,135.45 165.31,134.01 165.31,133.32 165.64,132.99 165.64,129.33 164.68,128.37 163.02,128.37 v2(162.89,128.5)
  BOTTOM w0.203: PUZ1.18 164.47,128.64 164.28,128.45 163.9,128.45 163.73,128.61 v1(163.47,128.61) 163.01,128.61 v2(162.89,128.5)
  BOTTOM w0.254: v2(152.22,136.43) 152.23,136.42 PUZ2.2
PWM2_2PH/ROSC1: length 1.8
  BOTTOM w0.203: PRZ65.1 163.8,130.58 164.1,130.27 164.48,130.27 164.52,130.24 PUZ1.22
PWM2_4PH/ADDR: length 32.4
  TOP w0.254: PRZ62.1 164.19,128.8 v2(164.09,128.9)
  IN2 w0.203: v2(144.61,136.5) 144.61,135.91 144.75,135.77 145.51,135.77 146.39,134.9 150.51,134.9 150.9,135.28 153.43,135.28 153.94,134.77 158.35,134.77 159.75,136.17 161.73,136.17 162.83,135.06 163.74,135.06 164.95,133.86 164.95,133.17 165.29,132.84 165.29,129.5 164.69,128.9 v2(164.09,128.9)
  BOTTOM w0.203: PUZ1.19 164.44,129.04 164.42,129.02 164.3,129.02 164.18,128.9 v2(164.09,128.9)
  BOTTOM w0.254: v2(144.61,136.5) 144.61,136.5 PUZ3.2
PWM3_4PH/VBOOT: length 40.5
  TOP w0.127: v2(163.05,129.13) v1(162.37,129.13)
  IN2 w0.203: v2(163.05,129.13) 163.28,129.36 164.52,129.36 164.89,129.73 164.89,132.11 162.74,134.26 161.45,134.26 160.53,135.18 159.36,135.18 158.58,134.39 153.78,134.39 153.27,134.9 151.05,134.9 150.67,134.52 146.16,134.52 145.4,135.28 143.77,135.28 142.88,134.39 138.89,134.39 137.88,135.41 137.62,135.41 136.99,136.04 v2(136.99,136.42)
  BOTTOM w0.203: PUZ1.20 164.37,129.44 164.29,129.36 163.91,129.36 163.48,129.79 PRZ63.1 163.05,129.39 v2(163.05,129.13)
  BOTTOM w0.254: PUZ4.2 136.99,136.41 v2(136.99,136.42)
PWM4_4PH/ROSCM: length 43.1
  TOP w0.254: v2(164.1,129.82) 164.1,129.83 164.34,130.07 PRZ64.1
  IN2 w0.203: v2(164.1,129.82) 163.29,130.63 163.29,132.75 162.92,133.12 160.08,133.12 159.19,134.01 153.62,134.01 153.5,133.88 151.85,133.88 151.59,134.14 146,134.14 145.24,134.9 143.9,134.9 143.01,134.01 138.64,134.01 137.75,134.9 136.48,134.9 135.72,134.14 131.65,134.14 129.62,136.17 v2(129.62,136.39)
  BOTTOM w0.203: PUZ1.21 164.12,129.84 v2(164.1,129.82)
  BOTTOM w0.254: v2(129.62,136.39) 129.63,136.38 PUZ5.2
PWR_LED#: length 263.4
  TOP w0.127: v2(126.5,6.83) v3(126.5,7.98) 122.93,11.56 117.16,11.56 115.36,13.36 115.36,15.97 114.54,16.79 114.54,18.99 115.92,20.37 115.92,23.91 v2(115.77,24.07) ; v2(139.02,22.52) 138.84,22.7 UK1.92
  IN3 w0.127: v2(126.5,6.83) 126.04,6.36 125.52,6.36 92.61,6.36 89.87,9.11 88.27,9.11 87.01,10.37 83.97,10.37 80.25,14.1 74.08,14.1 72.89,15.28 66.8,15.28 62.39,19.68 62.39,19.95 61.06,21.29 61.06,23.71 60.41,24.37 58.64,24.37 53.65,29.36 53.65,30.98 53.93,31.26 53.93,34.93 52.7,36.16 52.7,37.43 52.4,37.73 52.4,39.11 50.5,41.02 50.5,43.44 49.76,44.18 47.83,44.18 46.65,45.36 43.97,45.36 43.08,44.48 42.46,44.48 42.17,44.77 42.17,47.17 41.33,48.01 40.54,48.01 39.96,48.58 39.96,51.21 39.46,51.71 39.24,51.71 38.31,52.65 36.83,52.65 35.05,54.44 31.74,54.44 30.71,55.47 28.74,55.47 28.05,56.15 28.05,57.27 26.78,58.54 23.91,58.54 23.43,59.03 23.43,64.4 23.24,64.59 23.24,65.09 21.39,66.95 20.88,66.95 19.76,68.07 19.76,69.61 20.3,70.15 20.3,72.77 19.4,73.67 19.4,78.75 19.27,78.88 19.27,82.82 18.55,83.54 18.55,85 18.82,85.27 18.82,116.49 17.83,117.48 17.83,118.96 17.1,119.69 17.1,120.23 16.87,120.46 16.87,121.59 14.85,123.61 13.44,123.61 12.31,122.48 v2(11.51,122.48)
  BOTTOM w0.127: JPWR1.4 11.25,122.74 v2(11.51,122.48) ; v2(139.02,22.52) 138.86,22.52 138.32,21.99 135.69,21.99 134.68,23 125.05,23 125.02,23.04 116.8,23.04 v2(115.77,24.07)
PWROK_DDR: length 3.1
  BOTTOM w0.135: PUM1.10 89.49,24.04 PTPM1.1
QPCN:
  vias: v1(238.42,13.59)
REFCLK_CNV: length 156.9
  TOP w0.127: RWL29.1 310.85,9.44 312.32,10.91 312.32,30.27 v1(311.47,31.12) v2(307.96,34.63) ; RH173.1 211.28,34.17 v2(211.67,33.78)
  IN1 w0.127: v2(219.5,29.11) 219.1,29.11 217.56,27.57 214,27.57 212.95,26.52 211.76,26.52 211.49,26.25 210.11,26.25 209.4,26.96 209.4,27.69 210.46,28.75 210.46,29.62 211.11,30.26 211.11,32.77 211.67,33.33 v2(211.67,33.78)
  IN2 w0.127: v2(219.5,29.11) 220.93,29.11 227.68,35.86 242.99,35.86 243.83,35.01 246.87,35.01 247.91,36.05 252.68,36.05 253.57,35.16 256.33,35.16 258.4,37.23 275.82,37.23 v2(277.09,38.5)
  IN3 w0.127: v2(277.09,38.5) 276.71,38.88 276.71,40.04 281.99,45.31 302.54,45.31 303.81,44.04 303.81,42.61 304.04,42.38 307.75,42.38 308.24,41.9 308.24,34.91 v2(307.96,34.63)
  BOTTOM w0.127: v2(211.67,33.78) 211.67,33.45 UH1.R6
REFCLK_CNV_R: length 3.4
  TOP w0.127: v1(310.56,9.93) 309.94,9.31 RWL29.2
  TOP w0.135: v2(309.15,8.79) RWL29.2
  BOTTOM w0.127: v2(309.15,8.79) 309.21,8.85 JWLAN1.56
RJ45_RX1+: length 70
  IN1 w0.102: v2(36.66,28.32) 36.47,28.13 36.18,28.13 36.01,28.31 36.01,35.92 37.15,37.07 37.15,43.06 35.52,44.69 31.57,44.69 30.76,45.51 28.18,45.51 27.72,45.97 27.33,45.97 26.58,46.72 19.8,46.72 18.78,47.74 17.18,47.74 16.24,48.68 16.24,51.13 15.56,51.81 15.56,53.74 12.68,56.61 12.68,62.08 13.92,63.33 13.92,65.5 15.83,67.41 15.83,71.21 14.3,72.75 JRJ45.3
  BOTTOM w0.102: TSL1.17 37.41,28.5 37.06,28.15 36.82,28.15 v2(36.66,28.32)
RJ45_RX1-: length 70
  IN1 w0.102: JRJ45.6 14.6,69.69 14.79,69.88 14.79,71.27 15,71.47 15.14,71.47 15.53,71.09 15.53,67.54 13.62,65.62 13.62,63.45 12.37,62.21 12.37,56.49 15.25,53.61 15.25,51.69 15.93,51 15.93,48.55 17.05,47.44 18.65,47.44 19.67,46.41 26.46,46.41 27.2,45.66 27.59,45.66 28.05,45.2 30.63,45.2 31.44,44.39 35.4,44.39 36.85,42.93 36.85,37.19 35.7,36.05 35.7,28.18 36.06,27.83 36.56,27.83 v2(36.66,27.73)
  BOTTOM w0.102: TSL1.16 37.41,27.5 37.06,27.85 36.77,27.85 v2(36.66,27.73)
RJ45_TX0+: length 69.5
  IN3 w0.102: v2(36.73,25.24) 36.59,25.1 36.23,25.1 36.03,25.31 36.03,26.3 36.65,26.92 36.99,26.92 37.97,27.9 37.97,36.61 37.29,37.28 37.29,43.19 34.68,45.79 33.75,45.79 32.39,47.15 31.86,47.15 30.8,48.21 28.02,48.21 27.67,48.56 25.13,48.56 20.06,53.64 20.06,54.02 19.43,54.65 19.43,60.34 16.3,63.47 16.3,65.68 16.99,66.38 16.99,69.82 16.03,70.78 16.03,73.88 14.93,74.99 13.8,74.99 13.6,74.79 JRJ45.1
  BOTTOM w0.102: v2(36.73,25.24) 36.84,25.13 37.05,25.13 37.42,25.5 TSL1.14
RJ45_TX0-: length 69.5
  IN3 w0.102: JRJ45.2 13.62,74.09 13.62,74.37 13.93,74.68 14.8,74.68 15.73,73.75 15.73,70.65 16.69,69.69 16.69,66.5 15.99,65.81 15.99,63.34 19.13,60.21 19.13,54.52 19.75,53.89 19.75,53.51 25,48.26 27.54,48.26 27.89,47.9 30.68,47.9 31.73,46.85 32.26,46.85 33.62,45.49 34.56,45.49 36.99,43.06 36.99,37.16 37.66,36.48 37.66,28.02 36.86,27.23 36.52,27.23 35.73,26.43 35.73,25.18 36.11,24.8 36.59,24.8 v2(36.73,24.66)
  BOTTOM w0.102: v2(36.73,24.66) 36.89,24.82 37.1,24.82 37.43,24.5 TSL1.13
RJ45_TX2+: length 58.4
  IN3 w0.102: v2(36.72,31.27) 36.6,31.14 36.2,31.14 36.05,31.29 36.05,32.26 37.22,33.43 37.22,36.26 35.92,37.55 35.92,43.23 34.5,44.64 31.8,44.64 30.28,46.16 27.5,46.16 26.85,46.82 25.77,46.82 19.25,53.34 19.25,53.83 18.72,54.35 18.72,60.04 15.45,63.32 15.45,65.92 16.28,66.76 16.28,69.41 14.86,70.83 13.85,70.83 13.63,71.05 13.63,71.41 JRJ45.4
  BOTTOM w0.102: v2(36.72,31.27) 36.86,31.13 37.09,31.13 37.46,31.5 TSL1.20
RJ45_TX2-: length 58.4
  IN3 w0.102: JRJ45.5 13.54,70.71 13.72,70.53 14.74,70.53 15.98,69.29 15.98,66.88 15.14,66.05 15.14,63.19 18.42,59.92 18.42,54.23 18.94,53.7 18.94,53.21 25.64,46.51 26.72,46.51 27.38,45.86 30.15,45.86 31.67,44.34 34.38,44.34 35.61,43.1 35.61,37.43 36.91,36.13 36.91,33.55 35.74,32.39 35.74,31.17 36.07,30.84 36.57,30.84 v2(36.72,30.68)
  BOTTOM w0.102: TSL1.19 37.47,30.5 37.09,30.87 36.91,30.87 v2(36.72,30.68)
RJ45_TX3+: length 54.7
  IN3 w0.102: JRJ45.7 13.58,68.67 13.72,68.81 14.84,68.81 15.46,68.19 15.46,67.09 13.98,65.6 13.98,61.72 13.45,61.19 13.45,57.65 20.49,50.61 20.49,49.06 23.51,46.04 26.38,46.04 28.52,43.91 34.21,43.91 35.18,42.93 35.18,34.91 35.92,34.17 36.33,34.17 v2(36.47,34.32)
  BOTTOM w0.102: v2(36.47,34.32) 36.66,34.13 36.93,34.13 37.3,34.5 TSL1.23
RJ45_TX3-: length 54.7
  IN3 w0.102: JRJ45.8 13.63,67.97 13.63,68.29 13.85,68.51 14.71,68.51 15.16,68.06 15.16,67.21 13.67,65.73 13.67,61.85 13.14,61.32 13.14,57.52 20.19,50.48 20.19,48.94 23.39,45.74 26.26,45.74 28.39,43.6 34.08,43.6 34.88,42.81 34.88,34.79 35.8,33.87 36.34,33.87 v2(36.47,33.73)
  BOTTOM w0.102: v2(36.47,33.73) 36.61,33.87 37,33.87 37.38,33.5 TSL1.22
ROM_SCLK: length 27.3
  TOP w0.102: v2(213.6,77.73) 214.38,76.95 214.38,76.58 214.89,76.06 215.69,76.06 217.17,74.59 217.17,74.42 217.85,73.74
  TOP w0.127: 217.85,73.74 218.44,73.15 219.44,73.15 220.02,72.58 223.73,72.58 228.69,67.62 228.69,64.61 v2(228.59,64.51)
  BOTTOM w0.102: UG1.H4 v2(213.6,77.73)
  BOTTOM w0.127: RG132.1 226.49,63.65 RG138.2 226.76,64.77 v1(227.23,64.77) 227.83,64.77 228.09,64.51 v2(228.59,64.51)
ROM_SI: length 29.5
  TOP w0.102: 218.61,75.56 218.35,75.81 218.35,76.26 217.28,77.33 215.91,77.33 215.67,77.57 215.67,78.67 215.43,78.91 214.86,78.91 v2(214.48,78.54)
  TOP w0.127: v2(230.57,62.98) 230.46,63.08 v1(230.46,66.1) 230.46,66.96 224.06,73.36 220.34,73.36 219.77,73.94 219.28,73.94 218.94,74.28 218.94,75.22 218.61,75.56
  BOTTOM w0.109: UG1.H5 214.08,78.94 v2(214.48,78.54)
  BOTTOM w0.127: RG130.1 230.99,62.24 230.99,63.43 RG136.2 230.57,63.28 v2(230.57,62.98)
ROM_SO: length 31.9
  TOP w0.102: v2(214.48,80.27) 214.7,80.27 215.06,80.62 215.57,80.62 215.71,80.76 217.06,80.76 217.86,79.96 217.86,79.11 218.99,77.98 218.99,76.35 218.97,76.34 218.97,75.92 220.07,74.81 220.07,74.37
  TOP w0.127: 220.07,74.37 220.56,73.89 224.27,73.89 232.83,65.33 v1(232.83,63.93) 232.83,63.07 v2(232.96,62.94)
  BOTTOM w0.109: UG1.H7 214.11,80.64 v2(214.48,80.27)
  BOTTOM w0.127: RG131.1 232.4,63.4 RG137.2 232.96,63.16 v2(232.96,62.94)
RSET: length 6.1
  BOTTOM w0.127: v1(49.55,21.91) 50.86,21.91 51.33,22.38 RL11.2
  BOTTOM w0.203: 53.12,20.94 UL1.31
  BOTTOM w0.254: RL11.2 51.52,22.48 52.43,22.48 52.5,22.55 52.94,22.55 53.2,22.29 53.2,21.82 52.94,21.55 52.94,21.13 53.12,20.94
RTD3_CIO_PWR_EN: length 1.5
  TOP w0.127: v2(194.04,27.92) 193.33,27.92 TH4962.1
  BOTTOM w0.127: v2(194.04,27.92) 193.89,28.08 UH1.AE43
RTD3_USB_PWR_EN: length 2.7
  TOP w0.135: TH4960.1 200.86,20.91 v2(201.13,21.18)
  BOTTOM w0.127: v2(201.13,21.18) 200.58,20.63 200.58,19.39 UH1.BD29
S3_DDR: length 4.4
  BOTTOM w0.203: PUM1.7 92.05,24.99 92.67,24.36 v1(92.68,24.36) 92.71,24.33 93.12,24.33 93.54,23.91 PCM18.1 PRM11.2 PRM12.2
S5_DDR: length 6
  BOTTOM w0.203: PUM1.8 91.65,24.15 v2(91.67,24.13) 91.68,24.11 PCM17.1 PRM8.2 91.68,22.22 91.1,21.64 PDM2.2 91.1,20.94 PDM1.2
SA0_CHA_DIM1: length 6.4
  TOP w0.127: RD1.2 169.87,38.85 169.87,38.53 169.4,38.06 v1(169.4,37.95)
  TOP w0.137: v2(170.69,39.63) 170.68,39.63 170.54,39.77 RD3.1 169.88,38.91 RD1.2
  BOTTOM w0.135: v2(170.69,39.63) 170.1,39.63 169.56,40.17
  BOTTOM w0.137: 169.56,40.17 169.37,40.36 169.37,40.79 169.77,41.19 JDIMM1.256
SA0_CHB_DIM2: length 7.3
  TOP w0.127: RD19.2 167.04,35.23 167.2,35.06 RD22.1 167.76,34.55 167.76,33.78 167.68,33.7 167.68,32.42 168.44,31.66 v1(168.44,31.09) 168.44,30.72 v2(168.28,30.56)
  BOTTOM w0.127: JDIMM2.256 v2(168.28,30.56)
SA1_CHA_DIM1: length 5.1
  TOP w0.137: v2(171.4,41.93) 171.34,41.87 v1(169.93,41.87) 169.31,41.87 RD5.1 168.86,41.68 RD4.2
  BOTTOM w0.137: JDIMM1.260 170.77,41.42 170.9,41.3 171.11,41.3 171.4,41.59 v2(171.4,41.93)
SA1_CHB_DIM2: length 10.6
  TOP w0.127: RD20.2 168.47,36.37 RD23.1 169,35.99 v1(169.66,35.34) 170.91,34.09 v2(171.55,34.09)
  BOTTOM w0.127: JDIMM2.260 169.28,30.32 171.65,32.69 171.65,33.99 v2(171.55,34.09)
SA2_CHA_DIM1: length 6.5
  TOP w0.127: RD2.2 v1(146.99,38.2)
  TOP w0.381: v2(145.85,39.36) 146.1,39.36 146.64,39.9 RD6.1 147.02,39.16 RD2.2
  BOTTOM w0.356: JDIMM1.166 147.28,40.53 146.1,39.36 v2(145.85,39.36)
SA2_CHB_DIM2: length 3.8
  TOP w0.127: RD21.2 v1(147.66,28.7)
  TOP w0.305: v2(145.85,28.05) 145.88,28.08 RD24.1 145.9,28.7 RD21.2
  BOTTOM w0.305: v2(145.85,28.05) 145.78,28.13 JDIMM2.166
SATA_LED#: length 313
  TOP w0.127: v2(40.62,7.45) 40.39,7.68 v1(40.39,8.79) 40.39,10.03 43.15,12.79 45.66,12.79 46.8,13.93 52.77,13.93 53.2,13.5 53.77,13.5 54.59,12.69 56.95,12.69 60.63,16.36 61.66,16.36 64.58,19.29 64.58,20.32 65.7,21.44 65.7,21.8 v2(65.76,21.87)
  IN2 w0.127: v2(65.76,21.87) 65.7,21.93 65.7,22.37 67.26,23.92 72.51,23.92 73.33,23.1 84.58,23.1 87.55,20.14 97.54,20.14 98.53,21.13 99.55,21.13 100,21.58 108.67,21.58 112.71,17.54 116.07,17.54 116.69,16.93 117.91,16.93 118.2,17.22 120.32,17.22 120.74,17.64 121.88,17.64 122.65,18.41 123.68,18.41 124.76,19.49 130.53,19.49 130.77,19.73 131.46,19.73 132.43,18.76 134.54,18.76 135.65,17.65 140.97,17.65 142.74,19.42 145.69,19.42 146.91,20.63 151.33,20.63 152.87,22.17 160.32,22.17 160.94,21.56 175.71,21.56 179.91,25.76 180.48,25.76 183.03,28.31 184.61,28.31 185.94,26.98 188.1,26.98 v2(188.65,27.53) 189.54,28.42 194.14,28.42 195.74,26.82 197.86,26.82 198.02,26.66 198.02,26.2 198.71,25.5 205.41,25.5 205.74,25.83 211.04,25.83 211.73,25.14 213.42,25.14 213.97,24.59 216.74,24.59 217.73,25.58 218.66,25.58 219.69,26.6 219.69,27.48 227.79,35.59 242.88,35.59 243.73,34.73 247,34.73 248.06,35.78 252.57,35.78 253.46,34.89 256.45,34.89 258.52,36.96 276.14,36.96 277.72,38.53 277.72,39.23 277.91,39.42 278.75,39.42 v2(279.18,38.99)
  BOTTOM w0.127: v2(279.18,38.99) 279.18,40.58 282.59,43.98 291.31,43.98 294.64,40.65 303.9,40.65 305.5,42.25 JIO1.8 ; v2(40.62,7.45) 38.82,5.65 D513.2 ; UH1.AK48 189.8,26.37 v2(188.65,27.53) 188.65,28.08 188.33,28.39 RH170.1
