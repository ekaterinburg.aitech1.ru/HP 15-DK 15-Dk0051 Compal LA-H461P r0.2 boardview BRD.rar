# Allegro board LA-H461P Rev02.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR303  100K_0402_5%  [R_0402]  253.55 34.2 180 bottom
PR304  1K_0402_1%  [R_0402]  253.63 28.99 180 bottom
PR305  0_0402_5%  [R0402_0OHM]  77.47 6.67 180 top
PR306  499K_0402_1%  [R_0402]  76.04 13.73 180 bottom
PR307  4.7_1206_5%  [R_1206]  72.64 6.49 180 top
PR308  150K_0402_1%  [R_0402]  74.98 12.58 0 bottom
PR309  0_0402_5%  [R_0402]  74.21 11.87 90 bottom
PR310  2.2K_0402_5%  [R_0402]  255.53 29.79 180 bottom
PR311  0_0402_5%  [R0402_0OHM]  255.53 30.55 180 bottom
PR312  1K_0402_1%  [R_0402]  77.82 12.73 270 bottom
PR313  1M_0402_1%  [R_0402]  253.42 30.66 90 bottom
PR314  0_0402_5%  [R_0402]  252.65 32.54 90 bottom
PR1002  0_0402_5%  [R_0402]  240.34 22.79 270 bottom
PR1003  0_0402_5%  [R_0402]  241.71 23.56 180 bottom
PR1004  0_0402_5%  [R_0402]  241.18 21.87 90 bottom
PR1005  1M_0402_1%  [R_0402]  240.77 24.86 0 bottom
PR1006  100K_0402_1%  [R_0402]  237.93 22.95 90 bottom
PR1007  133K_0402_1%  [R_0402]  239.55 23.83 270 bottom
PR1009  0_0402_5%  [R0402_0OHM]  236.47 30.12 180 bottom
PR1013  4.7_1206_5%  [R_1206]  232.34 28.39 270 top
PR1020  1K_0402_1%  [R_0402]  238.72 22.95 90 bottom
PR1801  100K_0402_5%  [R_0402]  266.95 23.4 270 bottom
PR1802  4.7_0603_5%  [R_0603]  262.76 18.7 0 bottom
PR1803  21K_0402_1%  [R_0402]  265.19 23.35 0 bottom
PR1804  0_0402_5%  [R_0402]  264.37 23.39 180 bottom
PR1805  1M_0402_5%  [R_0402]  262.68 22.49 180 bottom
PR1806  10K_0402_1%  [R_0402]  266.56 21.36 0 bottom
PR2501  200K_0402_5%  [R_0402]  107.02 13.6 90 top
PR2502  0_0402_5%  [R_0402]  107.84 13.59 90 top
PR2503  1M_0402_1%  [R_0402]  108.64 14.51 270 top
PR2504  100K_0402_5%  [R_0402]  104.25 16.57 0 top
PR2505  4.7_0402_5%  [R_0402]  111.37 19.66 180 top
PR2506  32.4K_0402_1%  [R_0402]  106.02 13.96 90 top
PR2507  10K_0402_1%  [R_0402]  105.16 15.77 180 top
PRA1  2.2_0603_5%  [R_0603]  158.07 134.2 270 bottom
PRA2  0_0603_5%  [R_0603]  159.59 129.75 90 top
PRA3  4.7_1206_5%  [R_1206]  157.97 121.43 90 top
PRB01  1M_0402_1%  [R_0402]  266.17 38.02 270 top
PRB02  3M_0402_5%  [R_0402]  265.4 37.11 90 top
PRB03  0.005_1206_1%  [R_1206_4P-D]  261.42 34.54 180 top
PRB04  4.12K_0603_1%  [R_0603]  266.1 30.9 180 top
PRB06  100_0402_1%  [R_0402]  240.65 14 90 top
PRB07  4.12K_0603_1%  [R_0603]  266.1 29.63 180 top
PRB08  0.01_1206_1%  [R_1206_4P-D]  266.55 6.87 0 bottom
PRB10  422K_0402_1%  [R_0402]  234.54 10.53 0 bottom
PRB11  10_1206_5%  [R_1206]  240.74 8.35 180 bottom
PRB12  53.6K_0402_1%  [R_0402]  235.67 11.41 0 bottom
PRB13  2.2_0603_5%  [R_0603]  241.99 13.82 0 top
PRB14  0_0603_5%  [R_0603]  241.79 12.58 0 top
PRB15  0_0402_5%  [R0402_0OHM]  233.63 11.46 0 top
PRB16  0_0402_5%  [R0402_0OHM]  233.63 10.7 0 top
PRB17  0_0402_5%  [R_0402]  228.05 14.36 270 bottom
PRB18  100K_0402_1%  [R_0402]  242.31 8.65 0 top
PRB19  0_0402_5%  [R0402_0OHM]  243.22 7.88 180 top
PRB20  2_0402_5%  [R_0402]  241.14 6.5 270 top
PRB21  4.7_1206_5%  [R_1206]  257.58 6.89 180 top
PRB22  0_0402_5%  [R0402_0OHM]  239.41 5.62 0 top
PRB23  100K_0402_1%  [R_0402]  233.63 12.99 0 top
PRB25  120K_0402_1%  [R_0402]  234.55 12.23 180 top
PRB27  200K_0402_1%  [R_0402]  242.82 6.24 0 top
PRB28  200K_0402_1%  [R_0402]  236.13 5.66 90 top
PRB29  300K_0402_1%  [R_0402]  242.82 7 0 top
PRB30  301K_0402_1%  [R_0402]  236.89 6.57 270 top
PRB31  100_0402_1%  [R_0402]  235.37 6.57 270 top
PRB34  0_0402_5%  [R0402_0OHM]  237.66 6.57 270 top
PRB35  150K_0402_1%  [R_0402]  234.91 7.95 180 top
PRB37  4.7_0402_1%  [R_0402]  244.04 9.07 90 top
PRB38  1_0402_1%  [R_0402]  233.66 13.93 0 top
PRB39  2_0402_5%  [R_0402]  233.69 15.84 0 top
PRB40  0_0402_5%  [R0402_0OHM]  155.41 25.59 90 top
PRB41  0_0402_5%  [R0402_0OHM]  156.2 24.57 0 top
PRB43  0_0402_5%  [R_0402]  231.59 14.37 270 bottom
PRB44  100K_0402_5%  [R_0402]  227.39 12.62 0 bottom
PRF1  0_0402_5%  [R_0402]  178.36 103.63 225 bottom
PRF2  100K_0402_5%  [R_0402]  174.2 104.16 315 bottom
PRF3  4.7_0402_5%  [R_0402]  176.13 98.07 225 bottom
PRF4  13.7K_0402_1%  [R_0402]  177.2 104.82 225 bottom
PRF5  1M_0402_1%  [R_0402]  178.27 102.44 45 bottom
PRF6  20K_0402_1%  [R_0402]  175.47 104.04 135 bottom
PRG1  2.2_0603_5%  [R_0603]  118.32 92.68 180 top
PRG2  4.7_1206_5%  [R_1206]  112.48 96.54 180 top
PRG3  10_0402_1%  [R_0402]  114.08 100.23 180 top
PRH2  4.7_1206_5%  [R_1206]  183.86 108.96 135 top
PRH3  0_0402_5%  [R0402_0OHM]  187.43 104.1 0 bottom
PRH4  12K_0402_1%  [R_0402]  181.13 105.25 270 bottom
PRH5  0_0402_5%  [R_0402]  183.47 98.32 180 bottom
PRH6  1K_0402_1%  [R_0402]  180.55 103.53 0 bottom
PRH7  1M_0402_1%  [R_0402]  182.55 99.11 0 bottom
PRH8  20.5K_0402_1%  [R_0402]  181.46 102.74 180 bottom
PRH9  0_0402_5%  [R_0402]  180.55 101.19 0 bottom
PRH10  0_0402_5%  [R_0402]  181.46 101.95 180 bottom
PRM1  2.2_0402_5%  [R_0402]  90.71 30.99 0 bottom
PRM2  11.5K_0402_1%  [R_0402]  89.99 26.2 90 top
PRM3  4.7_1206_5%  [R_1206]  90.91 31.13 0 top
PRM4  5.1_0603_5%  [R_0603]  87.41 24.95 90 bottom
PRM5  2.2_0603_5%  [R_0603]  84.43 26.09 0 bottom
PRM6  6.04K_0402_1%  [R_0402]  94.98 24.54 90 bottom
PRM7  470K_0402_1%  [R_0402]  90.87 22.49 90 bottom
PRM8  100K_0402_5%  [R_0402]  92.6 22.53 180 bottom
PRM9  10K_0402_1%  [R_0402]  95.74 24.54 90 bottom
PRM11  0_0402_5%  [R_0402]  94.43 22.58 90 bottom
PRM12  0_0402_5%  [R_0402]  95.19 22.58 90 bottom
PRP2  0_0402_5%  [R_0402]  78.87 32.79 0 top
PRP3  100K_0402_1%  [R_0402]  80.65 32.79 0 top
PRP4  27K_0402_1%  [R_0402]  84.14 32.12 90 top
PRP5  2.7K_0402_1%  [R_0402]  84.72 33.87 180 top
PRP6  4.7_0603_5%  [R_0603]  86.5 36.09 180 top
PRV1  2.2_0603_5%  [R_0603]  223.73 53.41 180 bottom
PRV2  0_0603_5%  [R_0603]  209.52 54.04 180 bottom
PRV3  4.7_1206_5%  [R_1206]  204.93 62.58 270 top
PRV5  10K_0402_1%  [R_0402]  225.44 54.51 90 top
PRV6  2.2_0603_5%  [R_0603]  232.21 54.05 270 bottom
PRV7  20.5K_0402_1%  [R_0402]  224.45 59.52 90 bottom
PRV8  0_0402_5%  [R0402_0OHM]  223.34 56.09 180 bottom
PRV9  0_0603_5%  [R_0603]  201.6 54.02 180 bottom
PRV10  4.32K_0402_1%  [R_0402]  223.61 58.69 90 bottom
PRV11  6.19K_0402_1%  [R_0402]  222.42 57.71 0 bottom
PRV12  10K_0402_1%  [R_0402]  224.76 56.19 0 top
PRV13  16.5K_0402_1%  [R_0402]  223.41 57.87 180 top
PRV14  4.7K_0402_1%  [R_0402]  223.3 54.4 180 bottom
PRV15  309_0402_1%  [R_0402]  222.49 57.05 0 top
PRV16  432K_0402_1%  [R_0402]  225.25 60.52 270 bottom
PRV17  4.7_1206_5%  [R_1206]  192.97 59.99 270 bottom
PRV18  2.2_0603_5%  [R_0603]  227.71 61.72 270 bottom
PRV19  0_0402_5%  [R0402_0OHM]  230.1 60.51 180 bottom
PRV20  100_0402_1%  [R_0402]  226.75 56.82 90 top
PRV21  0_0402_5%  [R_0402]  227.01 51.89 180 bottom
PRV22  100_0402_1%  [R_0402]  232.16 58.59 180 bottom
PRV23  0_0603_5%  [R_0603]  217.46 53.8 180 bottom
PRV24  2.2_0603_5%  [R_0603]  218.98 55.79 0 bottom
PRV26  8.06K_0402_1%  [R_0402]  227.51 57.74 270 top
PRV27  5.1_0402_1%  [R_0402]  221.67 61.1 180 bottom
PRV28  10K_0402_1%  [R_0402]  229.16 57.64 270 top
PRV29  100K_0402_5%  [R_0402]  232.29 55.31 180 bottom
PRV30  4.7_1206_5%  [R_1206]  212.37 62.65 270 top
PRV31  10K_0402_1%  [R_0402]  232.2 57.71 180 bottom
PRV32  100K_0402_5%  [R_0402]  231.48 55.3 90 top
PRV33  1_0402_5%  [R_0402]  228.89 54.82 270 top
PRV34  1_0402_5%  [R_0402]  229.43 52.52 0 top
PRV35  10K_0402_1%  [R_0402]  231.39 56.9 0 bottom
PRV36  10K_0402_1%  [R_0402]  231.39 56.14 0 bottom
PRV37  0_0402_5%  [R0402_0OHM]  223.34 56.91 180 bottom
PRV38  0_0402_5%  [R0402_0OHM]  231.8 60.25 270 bottom
PRW1  10K_0402_5%  [R_0402]  237.97 56.24 0 bottom
PRW2  2.2_0603_5%  [R_0603]  238.9 50.46 270 bottom
PRW3  200K_0402_1%  [R_0402]  243.66 56.1 0 bottom
PRW4  97.6K_0402_1%  [R_0402]  238.74 58.04 270 bottom
PRW5  100_0402_1%  [R_0402]  240.5 58.68 180 bottom
PRW6  1M_0402_1%  [R_0402]  240.5 57.86 180 bottom
PRW7  49.9_0402_1%  [R_0402]  243.21 59.03 180 bottom
PRW8  90.9K_0402_1%  [R_0402]  241.45 58.08 90 bottom
PRW9  100_0402_1%  [R_0402]  243.77 60.08 180 bottom
PRW10  18.7K_0402_1%  [R_0402]  242.28 58.22 270 bottom
PRW11  20K_0402_1%  [R_0402]  244 57.29 90 bottom
PRW12  10K_0402_1%  [R_0402]  236.19 52 270 bottom
PRW13  4.7_1206_5%  [R_1206]  259.79 55.75 90 bottom
PRW14  0_0402_5%  [R0402_0OHM]  237.29 52.3 0 bottom
PRW15  0_0402_5%  [R_0402]  241.86 59.81 90 bottom
PRW16  200K_0402_1%  [R_0402]  237.98 55.47 0 bottom
PRZ2  12K_0402_1%  [R_0402]  176.56 128.55 180 bottom
PRZ3  7.5K_0603_1%  [R_0603]  160.23 121.12 270 top
PRZ4  10_0402_1%  [R_0402]  176.56 127.79 180 bottom
PRZ5  499_0402_1%  [R_0402]  172.98 133.31 0 top
PRZ6  100_0402_1%  [R_0402]  173.89 132.55 180 top
PRZ7  45.3_0402_1%  [R_0402]  172.98 131.79 0 top
PRZ8  45.3_0402_1%  [R_0402]  172.98 131.02 0 top
PRZ9  0_0402_5%  [R0402_0OHM]  175.42 126.52 180 bottom
PRZ10  499_0402_1%  [R_0402]  173.64 125.63 180 bottom
PRZ11  0_0402_5%  [R0402_0OHM]  176.23 126.46 270 bottom
PRZ12  1.65K_0402_1%  [R_0402]  173.64 125.75 180 top
PRZ13  31.6K_0402_1%  [R_0402]  170.95 130.83 0 top
PRZ14  100_0402_1%  [R_0402]  172.98 133.31 0 bottom
PRZ16  1.65K_0402_1%  [R_0402]  174.45 125.7 270 top
PRZ17  49.9_0402_1%  [R_0402]  172.98 131.02 0 bottom
PRZ18  10K_0402_1%  [R_0402]  173.89 130.26 180 top
PRZ19  0_0402_5%  [R0402_0OHM]  172.98 131.79 0 bottom
PRZ20  12.4K_0402_1%  [R_0402]  170.95 127.4 0 top
PRZ21  10_0402_1%  [R_0402]  172.98 132.55 0 bottom
PRZ22  1.5K_0402_1%  [R_0402]  170.13 126.59 270 top
PRZ24  34.8K_0402_1%  [R_0402]  173.87 129.5 0 bottom
PRZ25  0_0402_5%  [R0402_0OHM]  175.47 123.77 90 bottom
PRZ26  0_0402_5%  [R_0402]  173.87 130.26 0 bottom
PRZ27  0_0402_5%  [R0402_0OHM]  175.42 122.96 180 bottom
PRZ28  1K_0402_1%  [R_0402]  172.8 123.01 90 bottom
PRZ31  0_0402_5%  [R0402_0OHM]  174.2 134.44 90 bottom
PRZ32  1K_0402_1%  [R_0402]  171.45 135.41 0 bottom
PRZ33  0_0402_5%  [R0402_0OHM]  173.23 136.17 0 bottom
PRZ35  49.9_0402_1%  [R_0402]  171.15 122.27 270 bottom
PRZ36  1K_0402_1%  [R_0402]  171.07 123.09 0 bottom
PRZ37  27.4K_0402_1%  [R_0402]  168.36 126.59 270 top
PRZ38  3.3K_0402_1%  [R_0402]  172.36 122.84 270 top
PRZ39  49.9_0402_1%  [R_0402]  170.64 134.44 90 bottom
PRZ40  32.4K_0402_1%  [R_0402]  168.86 132.56 270 top
PRZ41  1K_0402_1%  [R_0402]  168.98 134.5 0 bottom
PRZ42  3.3K_0402_1%  [R_0402]  168.99 135.33 90 top
PRZ43  18.7K_0402_1%  [R_0402]  169.42 123.09 0 bottom
PRZ44  13K_0402_1%  [R_0402]  168.26 134.51 180 bottom
PRZ45  75K_0402_1%  [R_0402]  169.42 122.32 0 bottom
PRZ46  75K_0402_1%  [R_0402]  168.01 135.28 90 bottom
PRZ47  1K_0402_1%  [R_0402]  164.29 135.23 270 bottom
PRZ48  113K_0603_1%  [R_0603]  167.72 120.74 90 top
PRZ49  165K_0402_1%  [R_0402]  170.21 120.99 180 top
PRZ50  187K_0402_1%  [R_0402]  167.25 136.2 270 bottom
PRZ51  113K_0603_1%  [R_0603]  165.94 120.74 90 top
PRZ52  165K_0402_1%  [R_0402]  165.18 134.58 90 top
PRZ53  113K_0603_1%  [R_0603]  164.17 120.74 90 top
PRZ54  113K_0603_1%  [R_0603]  162.51 120.74 90 top
PRZ55  1K_0402_1%  [R_0402]  162.56 127.53 0 bottom
PRZ56  2.2_0603_5%  [R_0603]  165.24 125.63 90 top
PRZ57  24.9K_0402_1%  [R_0402]  163.48 131.34 180 bottom
PRZ58  25.5K_0402_1%  [R_0402]  165.1 130.83 0 top
PRZ59  7.5K_0402_1%  [R_0402]  167.72 120.6 90 bottom
PRZ60  1K_0402_1%  [R_0402]  168.62 122.26 180 bottom
PRZ61  110K_0402_1%  [R_0402]  163.45 127.84 270 top
PRZ62  4.3K_0402_1%  [R_0402]  165.1 128.8 0 top
PRZ63  24.9K_0402_1%  [R_0402]  163.48 129.82 180 bottom
PRZ64  97.6K_0402_1%  [R_0402]  165.1 130.07 0 top
PRZ65  97.6K_0402_1%  [R_0402]  163.48 130.58 180 bottom
PRZ66  3.74K_0402_1%  [R_0402]  165.18 135.07 90 bottom
PRZ67  7.5K_0402_1%  [R_0402]  165.94 120.6 90 bottom
PRZ69  1K_0402_1%  [R_0402]  166.84 122.26 180 bottom
PRZ70  7.5K_0402_1%  [R_0402]  164.17 120.6 90 bottom
PRZ71  1K_0402_1%  [R_0402]  165.07 122.26 180 bottom
PRZ72  1K_0402_1%  [R_0402]  162.56 133.88 0 bottom
PRZ73  7.5K_0402_1%  [R_0402]  162.39 120.6 90 bottom
PRZ74  0_0402_5%  [R0402_0OHM]  163.78 125.83 270 bottom
PRZ75  0_0402_5%  [R0402_0OHM]  163.48 133.12 180 bottom
PRZ76  1K_0402_1%  [R_0402]  163.29 122.26 180 bottom
PRZ77  8.66K_0402_1%  [R_0402]  162.97 124.86 180 bottom
PRZ78  8.66K_0402_1%  [R_0402]  161.75 132.94 270 bottom
PRZ79  2.2_0603_5%  [R_0603]  150.58 136.1 270 bottom
PRZ80  4.7_1206_5%  [R_1206]  151.81 125.65 180 top
PRZ81  10_0402_1%  [R_0402]  148.92 115.97 270 bottom
PRZ82  2.2_0603_5%  [R_0603]  142.96 136.1 270 bottom
PRZ83  4.7_1206_5%  [R_1206]  146.77 125.75 180 top
PRZ84  10_0402_1%  [R_0402]  147.78 115.97 270 bottom
PRZ85  2.2_0603_5%  [R_0603]  135.34 136.1 270 bottom
PRZ86  4.7_1206_5%  [R_1206]  140.67 124.8 90 bottom
PRZ87  10_0402_1%  [R_0402]  133.56 115.99 270 bottom
PRZ88  2.2_0603_5%  [R_0603]  127.97 136.1 270 bottom
PRZ89  4.7_1206_5%  [R_1206]  126.26 126.54 90 top
PRZ90  10_0402_1%  [R_0402]  132.42 115.99 270 bottom
PTPM1  PAD  [TPC12]  89.49 22.88 270 bottom
PU301  SY8286BRAC_QFN20_3X3  [SY8284BRAC_QFN20_3X3]  247.9 29.19 0 bottom
PU302  -  [SY8270CTMC_QFN13_4X3]  75.83 6.28 90 bottom
PU1001  -  [SY8288RAC_QFN20_3X3]  236.92 28.69 270 bottom
PU1801  -  [SY8003ADFC_DFN8_2X2]  265.35 21.32 270 bottom
PU2501  -  [G5719CTB1U_SOT23-6]  109.47 15.96 180 top
PUA1  -  [NCP81253MNTBG_DFN8_2X2]  159.35 133.33 0 bottom
PUB01  -  [ISL88739AHRZ-T_QFN32_4X4]  236.24 11.83 0 top
PUF1  -  [G5719CTB1U_SOT23-6]  178.2 100.53 135 bottom
PUG1  -  [NCP81151MNTBG_DFN8_2X2]  119.61 93.9 90 top
PUH1  -  [SY8286RAC_QFN20_3X3]  186.16 103.86 180 bottom
PUM1  G5616BRZ1U_TQFN20_3X3  [RT8207PGQW_WQFN20_3X3]  93.2 27.75 270 bottom
PUP1  -  [APW7237QBI-TRG_TDFN6_2X2]  81.57 36.11 270 top
PUV1  -  [RT8813DGQW_WQFN24_4X4]  225.08 54.79 0 bottom
PUV2  -  [RT9610CGQW_WDFN8_2X2]  220.48 57.67 180 bottom
PUW1  RT8237EZQW(2)_WDFN10_3X3  [RT8237EZQW-2_WDFN10_3X3]  240.45 55.3 0 bottom
PUZ1  -  [NCP81215MNTXG_QFN52_6X6]  170.63 126.36 90 bottom
PUZ2  -  [NCP81151MNTBG_DFN8_2X2]  151.73 135.49 0 bottom
PUZ3  -  [NCP81151MNTBG_DFN8_2X2]  144.11 135.49 0 bottom
PUZ4  -  [NCP81151MNTBG_DFN8_2X2]  136.49 135.49 0 bottom
PUZ5  -  [NCP81151MNTBG_DFN8_2X2]  129.12 135.49 0 bottom
Q7  -  [L2N7002DW1T1G_SC88-6]  180.73 122.32 90 top
Q32  -  [2N7002K_SOT23-3]  107.02 23.11 90 top
Q73  AO3416L 1N SOT-23  [MMBF170-7-F_SOT23-3]  215.73 13.1 270 top
Q79  L2N7002SWT1G_SC-70-3  [L2N7002WT1G_SC-70-3]  21.42 6.63 270 top
Q80  -  [2N7002H_SOT23-3]  15.05 120.84 25.7 top
QA2  -  [MMBT3904WH_SOT323-3]  290.91 13.87 0 top
QA3  L2N7002SWT1G_SC-70-3  [L2N7002WT1G_SC-70-3]  288.37 12.22 180 top
QC7  -  [L2N7002DW1T1G_SC88-6]  204.68 8.66 90 top
QC8  -  [L2N7002DW1T1G_SC88-6]  203.94 13.49 0 top
QC9  -  [L2N7002DW1T1G_SC88-6]  228.62 11.77 90 top
QC10  -  [L2N7002DW1T1G_SC88-6]  209.67 8.47 90 top
QC11  -  [L2N7002DW1T1G_SC88-6]  181.84 12.94 0 top
QC12  -  [MMBT3904W_SOT323-3]  15.53 121.66 270 bottom
QG1  PJT138KA 2N SOT363-6  [DMN66D0LDW-7_SOT363-6]  183.47 83.51 0 bottom
QG2  PJT138KA 2N SOT363-6  [DMN66D0LDW-7_SOT363-6]  219.44 62.52 90 bottom
QG3  LBSS139WT1G_SOT323-3  [MESS138W-G_SOT323-3]  183.34 129.69 0 bottom
QG4  LBSS139WT1G_SOT323-3  [MESS138W-G_SOT323-3]  242.65 64.03 180 bottom
QG7  PJT138KA 2N SOT363-6  [DMN66D0LDW-7_SOT363-6]  229.15 42.06 0 bottom
QG8  PJT138KA 2N SOT363-6  [DMN66D0LDW-7_SOT363-6]  233.9 52.82 315 top
QG16  L2N7002SWT1G_SC-70-3  [L2N7002WT1G_SC-70-3]  234.06 39.66 180 bottom
QG17  L2N7002DW1T1G 2N SC88-6  [2N7002DWH_SOT363-6]  237.19 38 180 bottom
QG55  LBSS139WT1G_SOT323-3  [MESS138W-G_SOT323-3]  234.4 64.29 180 bottom
QG56  LBSS139WT1G_SOT323-3  [MESS138W-G_SOT323-3]  239.35 64.79 180 bottom
QH2  AO3416L _SOT23-3  [AP2302GN-HF_SOT23-3]  209.12 12.6 270 top
QK1  -  [2N7002_SOT23-3]  127.63 23.72 90 top
QR2  -  [2N7002H_SOT23-3]  48.85 16.41 0 bottom
QS1  L2N7002DW1T1G 2N SC88-6  [2N7002DWH_SOT363-6]  17.1 81.05 270 top
QT2  -  [LP2305LT1G_SOT23-3]  37.53 47 180 top
QV1  L2N7002SWT1G_SC-70-3  [L2N7002WT1G_SC-70-3]  15.96 117.56 0 bottom
QV2  -  [PJT138KA_SOT363-6]  18.85 66.35 0 top
QV7  -  [L2N7002DW1T1G_SC88-6]  73.55 29.6 90 top
QWL1  -  [2N7002H_SOT23-3]  302.09 15.26 180 top
QWL2  ME2301DC-G_SOT23-3  [LP2301ALT1G_SOT23-3]  307.55 10.82 90 top
QWL3  L2N7002SWT1G_SC-70-3  [L2N7002WT1G_SC-70-3]  302.72 9.29 0 top
R1  0_0402_5%  [R0402_0OHM]  36.91 14.63 0 bottom
R13  470K_0402_5%  [R_0402]  109.03 26.15 180 top
R23  100K_0402_5%  [R_0402]  219.74 11.85 180 bottom
R24  0_0603_5%  [R0603_0OHM]  211.23 12.46 0 bottom
R28  0_0402_5%  [R_0402]  128.81 14.37 180 top
R124  10K_0402_5%  [R_0402]  109.44 20.72 0 top
R125  10K_0402_5%  [R_0402]  109.03 26.95 180 top
R295  1K_0402_5%  [R_0402]  132.49 11.67 180 top
R4960  0_0402_5%  [R_0402]  146.56 6.57 270 top
R5094  0_0402_5%  [R0402_0OHM]  145.76 6.56 270 top
R5178  0_0201_5%  [R0201_0OHM]  145.85 25.49 0 top
R5202  0_0402_5%  [R_0402]  128.81 15.14 180 top
R5216  10K_0402_5%  [R_0402]  35.64 11.71 180 bottom
R5217  0_0402_5%  [R0402_0OHM]  34.75 12.47 0 bottom
R5218  0_0201_5%  [R_0201]  35.09 13.2 90 bottom
R5219  100K_0402_5%  [R_0402]  22.56 7.03 270 top
R5220  100K_0402_5%  [R_0402]  17.48 6.35 90 top
R5221  0_0603_5%  [R0603_0OHM]  258.68 16.52 180 bottom
R5222  0_0603_5%  [R0603_0OHM]  258.68 15.25 180 bottom
R5236  0_0402_5%  [R0402_0OHM]  92.74 11.58 180 top
R5237  3.3K_0402_5%  [R_0402]  199.22 7.64 90 top
R5238  3.3K_0402_5%  [R_0402]  200.11 7.64 90 top
R5242  4.7K_0402_5%  [R_0402]  204.68 129.94 0 top
R5243  100K_0402_5%  [R_0402]  12.05 121.49 296.4 top
R5247  0_0402_5%  [R_0402]  180.57 50.26 270 top
R5253  0_0402_5%  [R0402_0OHM]  270.9 43.8 180 top
R5284  10K_0402_5%  [R_0402]  180.39 125.26 90 top
R5285  10K_0402_5%  [R_0402]  179.58 125.26 90 top
R5287  0_0402_5%  [R_0402]  205.57 129.18 180 top
R5798  10K_0402_5%  [R_0402]  178.15 44.42 270 top
R5799  0_0402_5%  [R0402_0OHM]  180.77 43.53 90 top
R5800  0_0402_5%  [R0402_0OHM]  177.26 43.53 90 top
R5801  0_0402_5%  [R_0402]  179.04 43.53 90 top
R5802  0_0402_5%  [R_0402]  179.8 44.42 270 top
R5804  21K_0402_1%  [R_0402]  65.49 40.21 90 top
R5806  100_0402_5%  [R_0402]  66.5 40.21 90 top
R5807  100K_0402_5%  [R_0402]  67.77 36.68 270 top
RA3  0_0603_5%  [R0603_0OHM]  294.85 16.18 180 bottom
RA4  2.2K_0201_5%  [R_0201]  295.86 25.68 90 top
RA9  33_0201_5%  [R_0201]  297.39 25.68 90 top
RA11  33_0201_5%  [R_0201]  296.63 25.68 90 top
RA12  33_0201_5%  [R_0201]  299.48 17.25 0 top
RA14  100K_0201_5%  [R_0201]  289.77 23.01 0 bottom
RA15  0_0201_5%  [R_0201]  291.93 15.64 0 top
RA16  100K_0201_5%  [R_0201]  290.53 15.77 270 top
RA17  0_0201_5%  [R_0201]  291.17 15.77 270 top
RA19  47K_0201_5%  [R_0201]  288.5 26.82 0 top
RA20  10K_0201_5%  [R_0201]  289.13 27.46 180 top
RA22  0_0201_5%  [R_0201]  302.65 32.34 270 bottom
RA23  0_0201_5%  [R_0201]  298.28 21.36 90 bottom
RA24  0_0201_5%  [R_0201]  308.47 30.12 180 top
RA25  10K_0201_5%  [R_0201]  290.15 10.69 90 top
RA26  100K_0201_5%  [R_0201]  292.56 15.01 180 top
RA30  TAI-TECH FCM1608KF-221T06_2P  [TAI-T_HCB1608KF-221T20_2P]  292.13 37.27 0 top
RA31  TAI-TECH FCM1608KF-221T06_2P  [TAI-T_HCB1608KF-221T20_2P]  292.13 39.13 0 top
RA32  TAI-TECH FCM1608KF-221T06_2P  [TAI-T_HCB1608KF-221T20_2P]  292.13 41.14 0 top
RA33  TAI-TECH FCM1608KF-221T06_2P  [TAI-T_HCB1608KF-221T20_2P]  292.13 42.99 0 top
RA37  470K_0402_5%  [R_0402]  289.13 15.26 180 top
RA54  100K_0201_5%  [R_0201]  297.64 16.17 90 top
RA55  BLM15AX221SN1D_2P  [MURAT_BLM15AX221SN1D_2P]  295.48 16.62 270 top
RA56  0_0402_5%  [R_0402]  294.59 15.77 90 top
RC1  24.9_0402_1%  [R_0402]  164.67 106.27 270 top
RC2  20_0402_5%  [R_0402]  175.34 102.59 180 top
RC3  121_0402_1%  [R_0402]  167.37 77.98 90 bottom
RC4  75_0402_1%  [R_0402]  165.44 77.98 90 bottom
RC5  100_0402_1%  [R_0402]  166.35 77.98 90 bottom
RC8  30_0402_5%  [R_0402]  165.61 97.05 90 top
RC9  24.9_0402_1%  [R_0402]  169.37 79.4 180 bottom
RC10  100_0402_1%  [R_0402]  149.94 111.28 90 bottom
RC11  100_0402_1%  [R_0402]  149.05 111.28 90 bottom
RC12  100_0402_1%  [R_0402]  147.02 111.28 90 bottom
RC13  100_0402_1%  [R_0402]  148.29 111.28 90 bottom
RC14  0.01_1206_1%  [R_1206]  114.87 71.82 180 top
RC15  100_0402_1%  [R_0402]  160.48 111.4 0 bottom
RC16  100_0402_1%  [R_0402]  159.59 111.4 90 bottom
RC18  1K_0402_5%  [R_0402]  120.22 101.12 0 bottom
RC19  49.9_0402_1%  [R_0402]  124.3 98 180 bottom
RC20  1K_0402_5%  [R_0402]  177.73 84.71 270 bottom
RC21  60.4_0402_1%  [R_0402]  176.04 84.71 180 bottom
RC22  20_0402_5%  [R_0402]  122.64 105.18 0 bottom
RC31  1K_0402_5%  [R_0402]  124.29 98.78 180 bottom
RC32  1K_0402_5%  [R_0402]  124.3 99.58 180 bottom
RC33  1K_0402_5%  [R_0402]  124.3 96.45 180 bottom
RC34  1K_0402_5%  [R_0402]  124.31 95.58 180 bottom
RC35  1K_0402_5%  [R_0402]  124.3 97.21 180 bottom
RC36  1K_0402_5%  [R_0402]  124.31 94.82 180 bottom
RC37  0_0402_5%  [R0402_0OHM]  122.64 107.59 0 bottom
RC38  0_0402_5%  [R0402_0OHM]  122.64 105.94 0 bottom
RC39  220_0402_5%  [R_0402]  122.64 106.83 0 bottom
RC40  56_0402_1%  [R_0402]  120.45 106.83 0 bottom
RC41  100_0402_5%  [R_0402]  121.37 105.94 180 bottom
RC42  499_0402_1%  [R_0402]  121.14 101.9 180 bottom
RC43  100K_0402_5%  [R_0402]  122.33 85.37 180 bottom
RC45  0_0402_5%  [R0402_0OHM]  175.35 101.82 180 top
RC81  10K_0402_5%  [R_0402]  202.01 7.52 0 top
RC82  10K_0402_5%  [R_0402]  204.59 7.24 180 top
RC140  0_0402_5%  [R0402_0OHM]  175.35 100.28 180 top
RC143  0_0402_5%  [R0402_0OHM]  175.35 101.06 180 top
RC369  15_0402_5%  [R_0402]  133.43 8.46 90 top
RC370  0_0402_5%  [R0402_0OHM]  253.08 35.96 90 top
RC371  0_0402_5%  [R0402_0OHM]  255.07 35.89 90 top
RC373  0_0402_5%  [R0402_0OHM]  180.73 107.54 180 top
RC374  0_0402_5%  [R0402_0OHM]  118.32 89.86 90 top
RC375  0_0402_5%  [R_0402]  117.18 89.86 90 top
RC376  10K_0402_5%  [R_0402]  206.08 16.41 180 top
RC377  10K_0402_5%  [R_0402]  203.94 12.47 0 top
RC380  51_0402_5%  [R_0402]  122.64 101.24 270 bottom
RC381  51_0402_5%  [R_0402]  121.87 101.24 270 bottom
RC383  1K_0402_1%  [R_0402]  218.27 24.92 180 top
RC384  100_0402_1%  [R_0402]  123.4 101.24 270 bottom
RC390  51_0402_5%  [R_0402]  124.16 101.24 270 bottom
RC391  51_0402_5%  [R_0402]  217.38 26.31 0 bottom
RC392  51_0402_5%  [R_0402]  123.53 103.4 180 bottom
RC393  10K_0402_5%  [R_0402]  182.58 11.96 180 top
RC934  0_0402_5%  [R_0402]  119.04 19.97 180 top
RD1  0_0402_5%  [R_0402]  168.99 38.89 0 top
RD2  0_0402_5%  [R_0402]  147.91 39.14 180 top
RD3  0_0402_5%  [R_0402]  169.88 39.77 180 top
RD4  0_0402_5%  [R_0402]  167.34 41.68 0 top
RD5  0_0402_5%  [R_0402]  168.99 41.55 270 top
RD6  0_0402_5%  [R_0402]  147.02 39.9 0 top
RD7  240_0402_1%  [R_0402]  136.73 39.65 180 top
RD8  1K_0402_1%  [R_0402]  145.5 41.68 180 top
RD9  2_0402_1%  [R_0402]  145.5 42.44 180 top
RD10  1K_0402_1%  [R_0402]  146.26 43.33 270 top
RD11  24.9_0402_1%  [R_0402]  129.58 91.1 0 top
RD19  0_0402_5%  [R_0402]  167.04 36.74 270 top
RD20  0_0402_5%  [R_0402]  167.93 36.74 0 top
RD21  0_0402_5%  [R_0402]  146.64 29.61 270 top
RD22  0_0402_5%  [R_0402]  167.25 35.06 270 top
RD23  0_0402_5%  [R_0402]  168.47 35.99 270 top
RD24  0_0402_5%  [R_0402]  145.88 28.73 90 top
RD25  240_0402_1%  [R_0402]  134.83 29.74 270 top
RD26  1K_0402_1%  [R_0402]  142.07 28.85 90 top
RD27  2_0402_1%  [R_0402]  140.38 29.07 270 top
RD28  1K_0402_1%  [R_0402]  142.83 29.74 270 top
RD29  24.9_0402_1%  [R_0402]  140.43 30.79 270 top
RE1  10K_0402_5%  [R_0402]  273.99 43.24 90 top
RE2  10K_0402_5%  [R_0402]  273.17 43.23 90 top
RE3  10K_0402_5%  [R_0402]  45.22 39.24 90 bottom
RE4  10K_0402_5%  [R_0402]  38.07 43.58 0 bottom
RG5  2K_0402_5%  [R_0402]  219.45 65.18 0 bottom
RG6  2K_0402_5%  [R_0402]  219.45 65.97 0 bottom
RG7  10K_0402_5%  [R_0402]  181.59 83.64 0 bottom
RG9  10K_0402_5%  [R_0402]  211.85 78.67 90 top
RG10  2.49K_0402_1%  [R_0402]  189.06 99.59 0 bottom
RG11  10K_0402_5%  [R_0402]  221.85 69.88 270 bottom
RG12  200K_0402_1%  [R_0402]  237.49 52.03 315 top
RG14  0_0402_5%  [R_0402]  237.53 59.58 270 bottom
RG15  10K_0402_5%  [R_0402]  232.96 59.93 90 bottom
RG16  100K_0402_5%  [R_0402]  236.81 60.35 0 bottom
RG34  10K_0402_5%  [R_0402]  223.13 61.62 90 top
RG35  1.8K_0402_1%  [R_0402]  218.49 61.41 90 bottom
RG36  1.8K_0402_1%  [R_0402]  218.51 64.49 270 bottom
RG37  10K_0402_5%  [R_0402]  225.82 61.15 90 top
RG38  10K_0402_5%  [R_0402]  221.84 61.95 90 top
RG39  10K_0402_5%  [R_0402]  220.37 66.76 180 bottom
RG40  1_0603_1%  [R_0603]  233.9 42.19 270 bottom
RG42  10K_0402_5%  [R_0402]  187.37 80.66 90 bottom
RG43  10K_0402_5%  [R_0402]  188.35 83.73 180 bottom
RG45  0_0402_5%  [R_0402]  242.86 60.89 0 bottom
RG47  40.2_0402_1%  [R_0402]  212.25 97.18 0 top
RG48  40.2_0402_1%  [R_0402]  213.87 98.91 225 top
RG49  60.4_0402_1%  [R_0402]  215.73 96.5 225 top
RG50  549_0402_1%  [R_0402]  228.94 128.67 270 bottom
RG51  931_0402_1%  [R_0402]  228.17 128.67 270 bottom
RG52  1.33K_0402_1%  [R_0402]  227.41 127.79 90 bottom
RG53  549_0402_1%  [R_0402]  182.1 127.79 0 bottom
RG54  931_0402_1%  [R_0402]  182.07 128.55 0 bottom
RG55  1K_0402_5%  [R_0402]  200.51 126.13 90 bottom
RG56  1.33K_0402_1%  [R_0402]  183.88 127.79 90 bottom
RG57  1K_0402_5%  [R_0402]  227.31 126.17 0 bottom
RG58  121_0402_1%  [R_0402]  227.31 126.96 0 bottom
RG59  1K_0402_5%  [R_0402]  211.54 128.04 270 bottom
RG60  1K_0402_5%  [R_0402]  190.35 134.64 180 top
RG61  121_0402_1%  [R_0402]  184.13 125.88 270 bottom
RG62  40.2_0402_1%  [R_0402]  189.09 116.01 225 bottom
RG63  40.2_0402_1%  [R_0402]  221.81 115.71 270 bottom
RG64  549_0402_1%  [R_0402]  240.49 65.43 0 bottom
RG65  931_0402_1%  [R_0402]  243.16 65.05 180 bottom
RG66  1.33K_0402_1%  [R_0402]  242.27 65.81 0 bottom
RG67  549_0402_1%  [R_0402]  244.18 66.19 0 bottom
RG68  931_0402_1%  [R_0402]  245.83 65.07 90 bottom
RG69  1K_0402_5%  [R_0402]  240.24 89.69 0 bottom
RG70  1.33K_0402_1%  [R_0402]  245.06 65.43 180 bottom
RG71  1K_0402_5%  [R_0402]  233.24 98.38 90 bottom
RG72  121_0402_1%  [R_0402]  240.49 105.56 180 bottom
RG73  1K_0402_5%  [R_0402]  233.1 72.72 270 bottom
RG74  121_0402_1%  [R_0402]  241.76 68.6 90 top
RG75  1K_0402_5%  [R_0402]  242.18 81.91 180 bottom
RG76  40.2_0402_1%  [R_0402]  230.26 72.7 0 bottom
RG77  40.2_0402_1%  [R_0402]  230.26 71.94 0 bottom
RG80  0_0402_5%  [R_0402]  221.32 68.22 0 bottom
RG83  10K_0402_5%  [R_0402]  183.11 78.12 180 bottom
RG85  2K_0402_5%  [R_0402]  218.6 67.44 0 top
RG86  2K_0402_5%  [R_0402]  218.59 66.64 0 top
RG87  10K_0402_5%  [R_0402]  211.66 127.15 90 top
RG88  10K_0402_5%  [R_0402]  199.47 129.44 270 top
RG89  10K_0402_5%  [R_0402]  211.66 129.94 270 top
RG90  10K_0402_5%  [R_0402]  199.47 126.64 90 top
RG91  10K_0402_5%  [R_0402]  243.16 81.56 180 top
RG92  10K_0402_5%  [R_0402]  243.41 90.96 180 top
RG93  10K_0402_5%  [R_0402]  240.62 81.56 0 top
RG94  10K_0402_5%  [R_0402]  240.87 90.96 0 top
RG95  40.2_0402_1%  [R_0402]  222.57 115.71 270 bottom
RG96  40.2_0402_1%  [R_0402]  189.62 115.47 225 bottom
RG97  40.2_0402_1%  [R_0402]  231.97 101.54 270 bottom
RG98  40.2_0402_1%  [R_0402]  232.86 101.54 270 bottom
RG99  0_0402_5%  [R_0402]  235.51 57.9 0 bottom
RG100  10K_0402_5%  [R_0402]  236.73 58.68 90 bottom
RG103  15K_0402_5%  [R_0402]  238.14 44.18 0 bottom
RG105  1K_0402_5%  [R_0402]  237.1 40.66 180 bottom
RG106  10K_0402_5%  [R_0402]  234.14 43.08 180 bottom
RG108  10K_0402_5%  [R_0402]  234.79 46.94 0 bottom
RG111  10K_0402_5%  [R_0402]  236.19 51.95 45 top
RG113  10K_0402_5%  [R_0402]  235.66 51.38 225 top
RG114  0_0402_5%  [R_0402]  234.4 61.11 0 bottom
RG118  100K_0402_5%  [R_0402]  230.09 64.48 270 bottom
RG122  100K_0402_5%  [R_0402]  219.96 68.41 180 bottom
RG123  100K_0402_5%  [R_0402]  231.79 64.48 270 bottom
RG124  100K_0402_5%  [R_0402]  219.43 67.57 0 bottom
RG125  100K_0402_5%  [R_0402]  231.62 62.11 270 bottom
RG126  100K_0402_5%  [R_0402]  230.08 62.4 270 bottom
RG127  100K_0402_5%  [R_0402]  227.78 63.63 270 bottom
RG128  100K_0402_5%  [R_0402]  225.44 63.34 270 bottom
RG129  100K_0402_5%  [R_0402]  220.52 70.68 270 bottom
RG130  100K_0402_5%  [R_0402]  230.86 62.11 270 bottom
RG131  100K_0402_5%  [R_0402]  232.4 62.51 270 bottom
RG132  100K_0402_5%  [R_0402]  226.95 63.65 270 bottom
RG133  100K_0402_5%  [R_0402]  228.59 63.89 270 bottom
RG134  100K_0402_5%  [R_0402]  225.28 64.99 270 bottom
RG135  100K_0402_5%  [R_0402]  219.74 69.77 90 bottom
RG136  100K_0402_5%  [R_0402]  230.85 64.48 270 bottom
RG137  100K_0402_5%  [R_0402]  232.55 64.48 270 bottom
RG138  100K_0402_5%  [R_0402]  226.07 64.99 270 bottom
RG148  49.9K_0402_5%  [R_0402]  247 38.76 180 bottom
RG179  10K_0402_5%  [R_0402]  243.32 39.44 90 bottom
RG180  10K_0402_5%  [R_0402]  236.3 64.67 180 bottom
RG200  10K_0201_5%  [R_0201]  219.39 63.62 0 top
RG214  100K_0402_5%  [R_0402]  236.13 36.9 0 bottom
RG381  1K_0402_1%  [R_0402]  188.05 79 180 bottom
RG391  20_0402_5%  [R_0402]  238.33 39.52 90 bottom
RG392  10K_0402_5%  [R_0402]  185.72 83.11 270 bottom
RG393  0_0402_5%  [R_0402]  219.48 64.28 90 top
RG394  10K_0402_5%  [R_0402]  241 63.78 90 bottom
RG395  0_0402_5%  [R_0402]  238.59 61.75 270 bottom
RG396  10K_0402_5%  [R_0402]  234.74 55.77 90 bottom
RG397  10K_0402_5%  [R_0402]  233.92 55.78 90 bottom
RG398  10K_0402_5%  [R_0402]  235.55 55.77 90 bottom
RG399  10K_0402_5%  [R_0402]  220.25 67.45 0 top
RG400  10K_0402_5%  [R_0402]  222.28 64.11 0 top
RG401  10K_0402_5%  [R_0402]  225.28 63.91 90 top
RG402  10K_0402_5%  [R_0402]  234.03 54.27 45 top
RG403  10K_0402_5%  [R_0402]  223.91 60.99 90 top
RG404  1K_0402_1%  [R_0402]  198.68 78.98 0 top
RG405  100K_0402_5%  [R_0402]  190.67 71.08 0 bottom
RG406  100K_0402_5%  [R_0402]  190.65 72.35 0 bottom
RH1  30_0402_5%  [R_0402]  217.38 25.3 0 bottom
RH2  33_0402_5%  [R_0402]  181.41 48.28 0 bottom
RH3  1K_0402_5%  [R_0402]  188.37 45.16 270 bottom
RH4  1K_0402_5%  [R_0402]  182.33 52.47 180 bottom
RH6  1M_0402_5%  [R_0402]  186.52 17.17 0 top
RH7  0_0402_5%  [R_0402]  216.03 9.55 270 top
RH8  113_0402_1%  [R_0402]  213.44 37.87 270 top
RH11  10K_0201_5%  [R_0201]  194.51 14.84 270 bottom
RH12  10K_0201_5%  [R_0201]  193.87 14.26 90 bottom
RH13  13_0402_5%  [R_0402]  217.38 27.07 0 bottom
RH14  13_0402_5%  [R_0402]  214.26 29.46 180 top
RH15  30_0402_5%  [R_0402]  217.38 27.84 0 bottom
RH16  1M_0402_5%  [R_0402]  218.18 34.16 270 bottom
RH17  33_0402_5%  [R_0402]  217.4 34.11 180 bottom
RH18  33_0402_5%  [R_0402]  217.4 33.32 180 bottom
RH19  10M_0402_5%  [R_0402]  187.49 20.47 270 bottom
RH20  60.4_0402_1%  [R_0402]  213.23 34.08 0 top
RH21  100_0402_1%  [R_0402]  206.33 43.36 270 bottom
RH22  200_0402_1%  [R_0402]  213.44 20.47 90 top
RH23  200_0402_1%  [R_0402]  213.09 18.26 0 top
RH24  200_0402_1%  [R_0402]  214.81 18.2 270 top
RH25  150_0402_1%  [R_0402]  217.76 18.31 0 bottom
RH26  4.7K_0402_5%  [R_0402]  218.1 21.58 90 bottom
RH27  22_0402_5%  [R_0402]  194.48 15.19 90 top
RH28  30_0402_5%  [R_0402]  218.29 24.53 180 bottom
RH29  30_0402_5%  [R_0402]  218.29 23.77 180 bottom
RH31  20K_0402_1%  [R_0402]  186.52 17.93 0 top
RH32  20K_0402_1%  [R_0402]  186.52 19.33 90 top
RH33  2.2K_0402_5%  [R_0402]  214.2 23.77 180 top
RH34  2.2K_0402_5%  [R_0402]  214.2 23.01 180 top
RH35  2.2K_0402_5%  [R_0402]  209.38 26.06 270 top
RH36  2.2K_0402_5%  [R_0402]  210.9 26.69 270 top
RH37  2.2K_0402_5%  [R_0402]  214.2 24.53 180 top
RH38  2.2K_0402_5%  [R_0402]  214.2 25.3 180 top
RH39  470_0402_1%  [R_0402]  186.59 17.37 180 bottom
RH40  0_0402_5%  [R0402_0OHM]  186.12 16.34 180 bottom
RH41  8.2K_0402_5%  [R_0402]  189.95 12.82 180 top
RH44  100K_0402_5%  [R_0402]  197.77 22.61 90 top
RH45  100K_0402_5%  [R_0402]  191.98 10.41 180 top
RH46  0_0402_5%  [R_0402]  191.98 9.65 180 top
RH47  100K_0402_5%  [R_0402]  186.97 15.95 270 top
RH48  0_0402_5%  [R_0402]  185.58 16.1 270 top
RH50  100K_0402_5%  [R_0402]  192.13 21.7 270 top
RH52  0_0402_5%  [R_0402]  191.36 21.04 90 top
RH53  100K_0402_5%  [R_0402]  201.5 18.84 270 top
RH54  0_1206_5%  [R1206_0OHM]  202.41 37.87 90 top
RH55  0_1206_5%  [R1206_0OHM]  204.8 38.34 90 top
RH56  0_0402_5%  [R0402_0OHM]  189.31 31.65 0 top
RH57  0_0402_5%  [R0402_0OHM]  207.47 30.5 270 top
RH58  0_0402_5%  [R0402_0OHM]  204.93 33.55 270 top
RH59  0_0402_5%  [R0402_0OHM]  189.31 35.08 0 top
RH61  0_0402_5%  [R0402_0OHM]  187.53 35.08 90 bottom
RH63  150K_0201_1%  [R_0201]  198.66 14.23 90 bottom
RH64  10K_0402_5%  [R_0402]  194.39 11.96 180 top
RH65  0_0402_5%  [R0402_0OHM]  194.39 12.72 180 top
RH67  10K_0402_5%  [R_0402]  195.92 12.47 270 top
RH76  49.9K_0402_1%  [R_0402]  213.59 9.5 270 top
RH78  49.9K_0402_1%  [R_0402]  214.36 9.5 270 top
RH79  49.9K_0402_1%  [R_0402]  204.93 18.84 270 top
RH81  49.9K_0402_1%  [R_0402]  204.17 18.84 270 top
RH82  10K_0402_5%  [R_0402]  203.41 17.93 90 top
RH83  0_0402_5%  [R0402_0OHM]  219.95 37.85 270 bottom
RH84  0_0402_5%  [R0402_0OHM]  219.33 38.68 180 bottom
RH85  0_0402_5%  [R0402_0OHM]  206.84 31.27 180 top
RH86  0_0402_5%  [R0402_0OHM]  218.14 43.08 270 bottom
RH87  0_0402_5%  [R0402_0OHM]  205.95 34.06 270 top
RH88  0_0402_5%  [R0402_0OHM]  217.05 44.5 180 bottom
RH90  0_0402_5%  [R0402_0OHM]  209.25 18.44 90 top
RH91  0_0402_5%  [R0402_0OHM]  203.15 33.55 270 top
RH92  1K_0402_5%  [R_0402]  177.91 14.96 90 top
RH93  4.7K_0402_5%  [R_0402]  208.23 22.5 270 top
RH94  4.7K_0201_5%  [R_0201]  200.94 14.23 90 bottom
RH95  100K_0201_5%  [R_0201]  203.56 14.21 90 bottom
RH96  150K_0402_1%  [R_0402]  202.27 17.93 90 top
RH97  4.7K_0201_5%  [R_0201]  204.32 14.21 90 bottom
RH98  100K_0402_5%  [R_0402]  185.63 24.03 180 top
RH99  100K_0402_5%  [R_0402]  187.66 31.39 90 bottom
RH100  4.7K_0402_5%  [R_0402]  188.55 32.31 270 bottom
RH117  1K_0402_1%  [R_0402]  208.23 15.01 270 top
RH118  0_0402_5%  [R_0402]  212.93 11.33 90 top
RH119  0_0402_5%  [R0402_0OHM]  189.31 30.12 0 top
RH120  0_0402_5%  [R0402_0OHM]  189.31 30.88 0 top
RH125  0_0402_5%  [R0402_0OHM]  209.12 17.68 0 top
RH138  0_0402_5%  [R0402_0OHM]  182.83 24.03 0 top
RH139  0_0402_5%  [R0402_0OHM]  189.31 34.19 0 top
RH140  0_0402_5%  [R0402_0OHM]  189.31 29.36 0 top
RH141  0_0402_1%  [R_0402]  204.63 24.81 270 top
RH143  0_0402_5%  [R0402_0OHM]  196.93 14.32 90 top
RH146  0_0402_1%  [R_0402]  193.9 31.49 90 top
RH147  0_0402_1%  [R_0402]  195.53 27.07 90 top
RH148  0_0402_5%  [R0402_0OHM]  205.44 24.03 0 top
RH150  0_0402_1%  [R_0402]  199.19 25.55 0 top
RH153  10K_0201_5%  [R_0201]  199.42 14.23 90 bottom
RH154  10K_0201_5%  [R_0201]  200.18 14.23 90 bottom
RH155  10K_0402_5%  [R_0402]  196.78 12.6 0 top
RH156  10K_0402_5%  [R_0402]  196.78 11.71 0 top
RH158  620_0402_5%  [R_0402]  217.38 28.6 0 bottom
RH160  0_1206_5%  [R1206_0OHM]  208.28 37.81 90 top
RH161  0_0402_5%  [R0402_0OHM]  220.93 21.74 180 top
RH162  0_0402_5%  [R0402_0OHM]  186.39 14.12 0 top
RH163  0_0402_5%  [R0402_0OHM]  208.49 18.69 180 top
RH164  10K_0402_5%  [R_0402]  187 27.63 0 bottom
RH166  1K_0402_5%  [R_0402]  220.55 28.47 180 top
RH167  20K_0402_5%  [R_0402]  217.76 19.84 0 bottom
RH168  100K_0402_5%  [R_0402]  217.76 19.07 0 bottom
RH169  10K_0402_5%  [R_0402]  198.18 21.35 270 top
RH170  10K_0402_5%  [R_0402]  187.91 28.39 180 bottom
RH171  1K_0402_5%  [R_0402]  188.17 12.85 270 top
RH172  0_0402_1%  [R_0402]  204.42 28.73 270 top
RH173  10K_0402_5%  [R_0402]  211.28 34.44 180 top
RH174  0_0402_5%  [R0402_0OHM]  205.19 25.68 180 top
RH175  4.7K_0402_5%  [R_0402]  183.96 24.13 270 bottom
RH176  1K_0402_5%  [R_0402]  182.35 51.71 180 bottom
RH177  0_0201_5%  [R_0201]  197.64 14.24 90 bottom
RH178  100K_0402_5%  [R_0402]  214.2 22.25 180 top
RH179  10K_0402_5%  [R_0402]  205.69 17.93 90 top
RH180  10K_0402_5%  [R_0402]  203.23 24.61 270 top
RH181  10K_0402_5%  [R_0402]  198.07 18.57 90 top
RH182  1K_0201_5%  [R_0201]  196.55 14.83 270 bottom
RH186  0_0402_5%  [R0402_0OHM]  200.74 21.99 90 top
RH187  0_0402_5%  [R0402_0OHM]  200.28 19.84 270 top
RH191  10K_0402_5%  [R_0402]  190.2 27.71 90 top
RH192  10K_0402_5%  [R_0402]  200.74 24.53 270 top
RH193  10K_0402_5%  [R_0402]  187.41 25.55 180 bottom
RH194  10K_0201_5%  [R_0201]  205.09 14.21 90 bottom
RH195  10K_0402_5%  [R_0402]  184.71 30.12 0 top
RH196  30K_0402_5%  [R_0402]  213.7 12.22 270 top
RH197  100K_0402_5%  [R_0402]  191.98 11.83 90 top
RH198  100K_0402_5%  [R_0402]  191.22 11.83 90 top
RH199  100K_0402_5%  [R_0402]  184.14 15.4 90 top
RH200  100K_0201_5%  [R_0201]  195.13 14.84 270 bottom
RH202  10K_0201_5%  [R_0201]  187.54 33.64 180 bottom
RH203  10K_0201_5%  [R_0201]  187.54 33.01 180 bottom
RH204  100K_0402_5%  [R_0402]  187.41 24.79 180 bottom
RH205  10K_0402_5%  [R_0402]  198.96 14.32 90 top
RH206  10K_0402_5%  [R_0402]  200.49 14.32 90 top
RH207  10K_0402_5%  [R_0402]  198.2 14.32 90 top
RH208  10K_0402_5%  [R_0402]  199.73 14.32 90 top
RH209  10K_0402_5%  [R_0402]  215.6 17.3 90 top
RH210  10K_0402_5%  [R_0402]  191.6 17.55 0 top
RH211  10K_0402_5%  [R_0402]  189.03 11.96 0 top
RH212  10K_0402_5%  [R_0402]  189.95 17.68 270 top
RH213  10K_0402_5%  [R_0402]  214.2 21.49 0 top
RH214  10K_0402_5%  [R_0402]  185.63 29.36 180 top
RH215  10K_0402_5%  [R_0402]  185.63 30.88 180 top
RH216  10K_0402_5%  [R_0402]  185.63 27.84 180 top
RH217  10K_0402_5%  [R_0402]  185.63 28.6 180 top
RH218  10K_0402_5%  [R_0402]  185.63 26.31 180 top
RH219  10K_0402_5%  [R_0402]  185.63 25.55 180 top
RH220  10K_0402_5%  [R_0402]  185.63 27.07 180 top
RH221  10K_0402_5%  [R_0402]  185.63 24.79 180 top
RH222  1K_0402_5%  [R_0402]  201.63 15.14 270 top
RH223  1K_0402_5%  [R_0402]  202.39 15.14 270 top
RH224  1K_0201_5%  [R_0201]  202.14 14.78 270 bottom
RH225  1K_0201_5%  [R_0201]  202.9 14.78 270 bottom
RH226  1K_0402_5%  [R_0402]  205.54 8.58 90 top
RH227  1K_0402_5%  [R_0402]  203.64 10.92 180 top
RH228  1K_0402_5%  [R_0402]  212.83 9.5 270 top
RH229  1K_0402_5%  [R_0402]  212.07 9.5 270 top
RH230  1K_0402_5%  [R_0402]  208.87 6.63 90 top
RH231  1K_0402_5%  [R_0402]  206.84 9.17 270 top
RH232  2.2K_0402_5%  [R_0402]  145.16 25.5 90 top
RH233  2.2K_0402_5%  [R_0402]  143.92 25.58 90 top
RH234  2.2K_0402_5%  [R_0402]  142.65 25.58 90 top
RH235  2.2K_0402_5%  [R_0402]  141.89 25.58 90 top
RH236  33_0402_5%  [R_0402]  181.44 46.28 0 bottom
RH237  33_0402_5%  [R_0402]  187.42 44.25 90 bottom
RH238  33_0402_5%  [R_0402]  181.41 50.95 0 bottom
RH239  33_0402_5%  [R_0402]  186.64 42.73 0 bottom
RH240  0_0402_5%  [R_0402]  183.49 44.99 270 bottom
RH241  0_0402_5%  [R_0402]  186.66 45.16 270 bottom
RH242  0_0402_5%  [R_0402]  185.08 44.26 90 bottom
RH243  0_0402_5%  [R_0402]  182.32 47.46 180 bottom
RH244  33_0402_5%  [R_0402]  215.14 14.63 0 bottom
RH245  33_0402_5%  [R_0402]  215.14 13.87 0 bottom
RH246  33_0402_5%  [R_0402]  215.14 13.1 0 bottom
RH247  33_0402_5%  [R_0402]  209.97 14.21 315 bottom
RH252  0_0402_5%  [R_0402]  184.1 14.25 270 top
RH253  BLM15AX221SN1D_2P  [MURAT_BLM15AX221SN1D_2P]  206.59 15.44 270 top
RH254  0_0402_5%  [R_0402]  207.45 15.44 270 top
RH255  10K_0402_5%  [R_0402]  195.01 10.54 270 top
RH256  10K_0402_5%  [R_0402]  195.77 10.54 270 top
RH257  10K_0402_5%  [R_0402]  193.68 10.42 270 top
RH258  10K_0402_5%  [R_0402]  192.92 9.51 90 top
RH259  0_0402_5%  [R_0402]  185.86 44.25 90 bottom
RK1  0_0603_5%  [R0603_0OHM]  129 10.62 90 top
RK2  100K_0402_1%  [R_0402]  152.71 25.64 90 top
RK4  0_0402_5%  [R_0402]  153.68 26.55 270 top
RK7  330K_0402_5%  [R_0402]  153.69 10.72 225 top
RK8  0_0402_5%  [R0402_0OHM]  130.25 20.88 90 top
RK9  0_0402_5%  [R0402_0OHM]  130.25 23.49 270 top
RK12  4.7K_0402_5%  [R_0402]  140.53 25.59 90 top
RK13  4.7K_0402_5%  [R_0402]  139.72 25.59 90 top
RK14  10K_0402_5%  [R_0402]  144.02 5.64 90 top
RK17  43_0402_1%  [R_0402]  132.51 12.71 180 top
RK20  100K_0402_5%  [R_0402]  149.03 5.65 90 top
RK21  10K_0402_5%  [R_0402]  132.39 19.74 0 top
RK23  100K_0402_5%  [R_0402]  136.49 25.59 90 top
RK26  100K_0402_5%  [R_0402]  147.35 6.57 270 top
RK27  100K_0402_5%  [R_0402]  132.51 13.51 180 top
RK28  100K_0402_5%  [R_0402]  154.03 12.01 180 top
RK29  100K_0402_5%  [R_0402]  132.64 15.21 180 top
RK30  100K_0402_5%  [R_0402]  132.39 18.97 0 top
RK31  100K_0402_5%  [R_0402]  142.7 5.64 90 top
RK32  0_0402_5%  [R_0402]  110.19 26.25 90 top
RK33  0_0402_5%  [R_0402]  107.64 27.89 0 top
RK34  6.8K_0402_5%  [R_0402]  148.01 26.41 270 top
RL6  0_0201_5%  [R0201_0OHM]  59.64 19.88 0 bottom
RL7  1M_0402_5%  [R_0402]  49.99 19.58 270 bottom
RL11  2.49K_0402_1%  [R_0402]  50.5 22.38 0 bottom
RL15  10K_0402_5%  [R_0402]  53.73 18.16 0 top
RL30  20_0402_5%  [R_0402]  9.73 57.58 0 top
RL31  220_0402_5%  [R_0402]  11.89 61.19 270 top
RL55  0_0805_5%  [R0805_0OHM]  42.55 36.04 180 top
RL56  4.7K_0402_5%  [R_0402]  53.44 19.71 90 top
RL57  0_0402_5%  [R_0402]  51.77 20.34 270 bottom
RL58  75_0402_1%  [R_0402]  37.85 35.58 0 top
RL59  75_0402_1%  [R_0402]  37.85 32.54 0 top
RL60  75_0402_1%  [R_0402]  37.85 29.49 0 top
RL61  75_0402_1%  [R_0402]  37.72 26.57 0 top
RM6  1K_0402_5%  [R_0402]  57.05 17.3 90 top
RM11  15K_0402_5%  [R_0402]  55.38 18.16 0 top
RR1  0_0402_5%  [R0402_0OHM]  46.31 20.47 180 bottom
RR2  0_0402_5%  [R_0402]  46.31 19.71 180 bottom
RR3  0_0402_5%  [R0402_0OHM]  45.42 16.15 0 bottom
RR4  0_0402_5%  [R_0402]  36.91 19.07 0 bottom
RR5  0_0402_5%  [R_0402]  36.91 19.84 0 bottom
RR6  33_0402_5%  [R_0402]  39.45 20.72 90 bottom
RR7  0_0402_5%  [R_0402]  40.98 20.72 90 bottom
RR8  0_0402_5%  [R_0402]  41.74 20.72 90 bottom
RR9  0_0402_5%  [R_0402]  42.5 20.72 90 bottom
RR10  191_0402_5%  [R_0402]  37.8 13.74 180 bottom
RR11  10K_0402_5%  [R_0402]  45.42 17.04 0 bottom
RR12  10K_0402_5%  [R_0402]  45.42 15.39 0 bottom
RR14  0_0402_5%  [R0402_0OHM]  37.8 15.77 90 top
RR15  100K_0402_5%  [R_0402]  46.33 14.63 180 bottom
RS9  0_0402_5%  [R_0402]  21.54 76.99 270 bottom
RS10  0_0402_5%  [R_0402]  23.7 80.92 180 bottom
RS13  48.7K_0402_1%  [R_0402]  23.7 79.39 180 bottom
RS14  19.1K_0402_1%  [R_0402]  23.7 78.5 180 bottom
RS16  0_0402_5%  [R0402_0OHM]  15.96 78.89 0 bottom
RS17  10K_0402_5%  [R_0402]  18.28 77.17 180 bottom
RS27  0_0201_5%  [R0201_0OHM]  20.27 89.56 180 bottom
RS28  0_0201_5%  [R0201_0OHM]  20.27 90.19 180 bottom
RS32  0_0201_5%  [R0201_0OHM]  20.27 88.54 180 bottom
RS34  0_0201_5%  [R0201_0OHM]  20.27 87.91 180 bottom
RS39  470K_0402_5%  [R_0402]  19.08 83.28 180 top
RS40  100K_0402_5%  [R_0402]  18.24 78.76 180 top
RS41  100K_0402_5%  [R_0402]  15.96 79.78 0 bottom
RS42  100K_0402_5%  [R_0402]  15.96 80.54 0 bottom
RS43  100K_0402_5%  [R_0402]  17.61 83.28 0 bottom
RT6  0_0603_5%  [R0603_0OHM]  36.24 56.47 270 top
RT799  0_0201_5%  [R_0201]  35.26 55.65 90 top
RT800  0_0201_5%  [R_0201]  33.36 55.65 90 top
RT801  0_0201_5%  [R_0201]  32.47 57.33 90 top
RT803  0_0201_5%  [R_0201]  26.84 52.26 0 bottom
RT807  100K_0201_5%  [R_0201]  30.76 55.65 90 top
RT808  100K_0201_5%  [R_0201]  34.63 55.65 90 top
RT809  100K_0201_5%  [R_0201]  33.99 55.65 90 top
RT810  100K_0201_5%  [R_0201]  32.47 55.65 90 top
RT812  100K_0201_5%  [R_0201]  31.83 55.65 90 top
RT813  1K_0201_5%  [R_0201]  29.95 46.62 180 bottom
RT814  1K_0201_5%  [R_0201]  27.65 45.29 90 top
RT815  2M_0201_5%  [R_0201]  26.14 54.27 180 top
RT816  2M_0201_5%  [R_0201]  30.15 55.65 90 top
RT817  20K_0201_5%  [R_0201]  28.08 47.08 180 bottom
RT818  1K_0201_5%  [R_0201]  28.08 47.65 180 bottom
RT838  1K_0201_5%  [R_0201]  28.85 45.87 270 top
RT839  0_0201_5%  [R_0201]  26.84 51.67 0 bottom
RT840  20K_0201_5%  [R_0201]  28.25 45.87 270 top
RT841  1K_0201_5%  [R_0201]  26.57 49.73 270 bottom
RT845  20K_0201_5%  [R_0201]  26.87 47.74 180 bottom
RT846  1K_0201_5%  [R_0201]  26.87 47.1 180 bottom
RT847  1K_0201_5%  [R_0201]  29.44 45.29 90 top
RT848  20K_0201_5%  [R_0201]  30.69 45.87 270 top
RT849  1K_0201_5%  [R_0201]  30.05 45.87 270 top
RT850  1K_0201_5%  [R_0201]  26.84 50.47 0 bottom
RT851  20K_0201_5%  [R_0201]  29.33 50.26 0 bottom
RT852  1K_0201_5%  [R_0201]  29.33 49.63 0 bottom
RT853  1K_0201_5%  [R_0201]  26.84 51.1 0 bottom
RT854  20K_0201_5%  [R_0201]  29.33 51.53 0 bottom
RT855  1K_0201_5%  [R_0201]  29.33 50.9 0 bottom
RT856  1K_0201_5%  [R_0201]  29.95 47.76 180 bottom
RT857  20K_0201_5%  [R_0201]  28.08 48.23 180 bottom
RT858  1K_0201_5%  [R_0201]  27.77 48.8 180 bottom
RT859  100K_0201_5%  [R_0201]  27.28 54.19 0 top
RT860  100K_0201_5%  [R_0201]  27.68 53.55 180 top
RT1111  220K_0201_5%  [R_0201]  25.44 52.97 90 top
RT1112  220K_0201_5%  [R_0201]  25.44 52.38 270 top
RT1113  220K_0201_5%  [R_0201]  26.48 48.11 270 top
RT1114  220K_0201_5%  [R_0201]  26.48 48.74 90 top
RTT6  33_0402_5%  [R_0402]  128.81 15.9 180 top
RTT7  33_0402_5%  [R_0402]  128.81 16.66 180 top
RTT8  33_0402_5%  [R_0402]  128.81 17.42 180 top
RTT9  33_0402_5%  [R_0402]  128.4 19.07 180 top
RTT10  4.7K_0402_5%  [R_0402]  119.03 16.41 180 top
RTT12  4.7K_0402_5%  [R_0402]  119.03 15.64 180 top
RTT35  4.7K_0402_5%  [R_0402]  118.11 14.88 0 top
RU51  10K_0402_5%  [R_0402]  53.43 42.97 180 top
RU52  0_0402_5%  [R_0402]  42 46.95 90 top
RU53  0_0402_5%  [R_0402]  41.24 46.95 90 top
RU54  0_0402_1%  [R0402_0OHM]  52.52 41.44 0 top
RU55  0_0402_1%  [R0402_0OHM]  52.52 42.21 0 top
RU57  10K_0402_5%  [R_0402]  43.47 37.74 90 top
RU58  20K_0402_5%  [R_0402]  44.26 37.74 90 top
RU61  10K_0402_5%  [R_0402]  45.74 37.68 90 top
RU62  0_0402_1%  [R0402_0OHM]  52.34 45.91 0 top
RU63  100K_0402_5%  [R_0402]  49.44 48.27 180 top
RU64  0_0201_5%  [R0201_0OHM]  48.9 49.11 180 top
RU65  0_0402_5%  [R_0402]  39.89 45.05 90 top
RU66  10K_0402_1%  [R_0402]  40.7 45.18 0 top
RU67  10K_0402_1%  [R_0402]  36.28 42.95 0 top
RU68  3.3K_0402_1%  [R_0402]  54.13 28.32 0 bottom
RU69  3.3K_0402_1%  [R_0402]  54.13 27.53 0 bottom
RU70  3.3K_0402_1%  [R_0402]  54.13 26.72 0 bottom
RU71  3.3K_0402_1%  [R_0402]  58.83 29.56 0 bottom
RU72  100K_0402_1%  [R_0402]  41.62 44.42 180 top
RU73  100K_0402_1%  [R_0402]  37.98 42.95 0 top
RU78  10K_0402_5%  [R_0402]  53.42 39.85 180 top
RU79  100K_0402_1%  [R_0402]  53.42 40.61 180 top
RV2  33_0402_5%  [R_0402]  73.04 24.01 90 bottom
RV3  10K_0402_5%  [R_0402]  73.83 24.01 90 bottom
RV4  0_0402_5%  [R0402_0OHM]  73.38 22.33 90 bottom
RV5  100K_0402_5%  [R_0402]  72.52 23.24 270 bottom
RV6  0_0201_5%  [R0201_0OHM]  71.84 27.57 90 bottom
RV7  100K_0402_5%  [R_0402]  75 24.87 270 bottom
RV8  2.2_0201_1%  [R_0201]  18.75 106.58 180 bottom
RV9  2.2_0201_1%  [R_0201]  18.75 107.34 180 bottom
RV10  2.2_0201_1%  [R_0201]  18.75 108.23 180 bottom
RV11  0_0402_5%  [R_0402]  33.02 57.8 180 bottom
RV12  2.2_0201_1%  [R_0201]  18.75 108.99 180 bottom
RV13  2.2_0201_1%  [R_0201]  18.75 111.53 180 bottom
RV14  10K_0402_1%  [R_0402]  31.62 61.86 180 bottom
RV15  2.2_0201_1%  [R_0201]  18.75 112.29 180 bottom
RV16  10K_0402_1%  [R_0402]  30.39 63.6 270 bottom
RV17  2.2_0201_1%  [R_0201]  18.75 109.88 180 bottom
RV18  4.99K_0402_1%  [R_0402]  32.71 59.11 0 bottom
RV19  0_0402_5%  [R0402_0OHM]  30.66 59.58 0 bottom
RV20  2.2_0201_1%  [R_0201]  18.75 110.77 180 bottom
RV21  4.7K_0402_5%  [R_0402]  22.13 64.46 180 top
RV22  4.7K_0402_5%  [R_0402]  20.43 64.82 270 top
RV23  4.7K_0402_5%  [R_0402]  31.62 61.1 180 bottom
RV24  4.7K_0402_5%  [R_0402]  23.63 59.97 180 top
RV25  4.7K_0402_5%  [R_0402]  28.02 62.66 0 top
RV26  4.7K_0402_5%  [R_0402]  31.62 60.34 180 bottom
RV27  2K_0402_1%  [R_0402]  17.66 115.59 0 bottom
RV28  2K_0402_1%  [R_0402]  17.66 114.7 0 bottom
RV29  20K_0402_5%  [R_0402]  17.66 116.99 0 bottom
RV30  0_0402_5%  [R0402_0OHM]  26.93 55.85 90 top
RV31  10K_0402_1%  [R_0402]  22.07 57.11 270 top
RV33  20K_0402_1%  [R_0402]  22.1 55.45 180 top
RV34  4.7K_0402_5%  [R_0402]  31.58 59.71 180 top
RV35  4.7K_0402_5%  [R_0402]  31.58 60.48 180 top
RV36  10K_0402_1%  [R_0402]  19.48 70 270 top
RV37  10K_0402_1%  [R_0402]  17.84 67.21 270 top
RV38  1M_0402_5%  [R_0402]  15.77 120.51 0 bottom
RV39  0_0402_5%  [R0402_0OHM]  21.16 67.26 0 top
RV40  0_0402_5%  [R0402_0OHM]  17.93 69.08 90 top
RV41  0_0402_5%  [R_0402]  21.16 66.24 0 top
RV42  0_0402_5%  [R_0402]  18.72 69.08 90 top
RV43  220_0402_1%  [R_0402]  17.35 106.5 90 bottom
RV44  220_0402_1%  [R_0402]  17.35 108.15 90 bottom
RV45  220_0402_1%  [R_0402]  17.35 111.45 90 bottom
RV46  220_0402_1%  [R_0402]  17.35 109.8 90 bottom
RV47  100K_0402_5%  [R_0402]  70.52 40.54 180 top
RV48  4.7_0402_5%  [R_0402]  70.52 38.5 180 top
RV49  133K_0402_1%  [R_0402]  78.01 39.65 180 top
RV50  27K_0402_1%  [R_0402]  77.09 40.54 0 top
RV51  100K_0402_5%  [R_0402]  75.47 30.88 180 top
RV52  47_0805_5%  [R_0805]  68.83 30.38 0 top
RV56  100K_0402_5%  [R_0402]  70.75 24.33 270 bottom
RV57  0_0402_5%  [R_0402]  64.47 30.83 180 top
RV58  0_0402_5%  [R_0402]  63.83 22.42 90 bottom
RV59  0_0402_5%  [R_0402]  64.61 22.42 90 bottom
RV60  0_0402_5%  [R_0402]  66.64 23.34 90 bottom
RV61  0_0402_5%  [R_0402]  65.84 23.33 90 bottom
RV135  10K_0402_5%  [R_0402]  178.64 121.51 270 bottom
RV136  10K_0402_5%  [R_0402]  179.53 129.64 270 bottom
RWL1  71.5K_0402_1%  [R_0402]  310.09 21.87 0 top
RWL2  71.5K_0402_1%  [R_0402]  310.09 21.11 0 top
RWL3  4.7K_0402_5%  [R_0402]  308.06 22.31 90 top
RWL4  10K_0402_5%  [R_0402]  305.52 13.23 180 top
RWL5  0_0402_5%  [R_0402]  309.96 11.58 0 top
RWL7  68K_0402_5%  [R_0402]  302.85 11.33 0 top
RWL8  0_0603_5%  [R_0603]  307.29 8.02 180 top
RWL12  20K_0402_5%  [R_0402]  307.93 16.79 180 top
RWL13  20K_0402_5%  [R_0402]  307.8 17.68 180 top
RWL18  0_0402_5%  [R_0402]  306.91 18.44 0 top
RWL20  0_0402_5%  [R_0402]  310.98 16.53 180 top
RWL21  0_0402_5%  [R_0402]  307.04 16.03 0 top
RWL22  0_0402_5%  [R_0402]  307.04 15.26 0 top
RWL29  0_0402_5%  [R_0402]  310.85 8.79 180 top
RWL30  0_0402_5%  [R_0402]  302.09 10.56 90 top
RWL31  200K_0402_5%  [R_0402]  303.74 10.56 180 top
RWL32  0_0402_5%  [R_0402]  310.98 18.44 180 top
RWL33  0_0402_5%  [R_0402]  310.98 15.77 180 top
T153  PAD~D  [TPC12]  53.02 46.96 0 top
T154  PAD~D  [TPC12]  51.7 46.95 0 top
T155  PAD~D  [TPC12]  52.12 48.17 0 top
T156  PAD~D  [TPC12]  50.51 48.25 0 top
T158  PAD~D  [TPC12]  44.33 50.48 0 top
T159  PAD~D  [TPC12]  43.27 49.64 0 top
T160  PAD~D  [TPC12]  43.36 48.36 0 top
T161  PAD~D  [TPC12]  45.74 50.43 0 top
T162  PAD~D  [TPC12]  51.62 41.12 0 top
T163  PAD~D  [TPC12]  51.73 37.81 0 top
T164  PAD~D  [TPC12]  52.49 36.59 0 top
T165  PAD~D  [TPC12]  46.75 38.12 0 top
T166  PAD~D  [TPC12]  46.44 36.45 0 top
T167  PAD~D  [TPC12]  47.55 37.08 0 top
TC1  PAD~D  [TPC12]  171.13 106.45 180 bottom
TC24  PAD~D  [TPC12]  170.98 81.52 180 bottom
TC25  PAD~D  [TPC12]  170.91 80.22 180 bottom
