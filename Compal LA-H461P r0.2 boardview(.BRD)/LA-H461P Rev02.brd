# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VALWP: length 17.9
  TOP w0.254: v2(64.1,12.19) 64.1,12.43 65.36,13.69 72.22,13.69 74.2,11.71 77.07,11.71 77.45,11.33 v2(77.45,11.07)
  BOTTOM w0.254: PU302.8 76.53,10.36 76.74,10.56 76.94,10.56 v2(77.45,11.07) 77.82,11.45 PR312.2
  vias: v1(65.73,10.32) v2(62.84,10.26) v2(62.84,8.99) v2(62.84,7.72) v2(64.17,10.26) v2(64.17,8.99) v2(64.17,7.72) v2(64.86,12.19) v2(65.31,6.19) v2(65.31,5.56) v2(65.5,12.19) v2(65.95,6.19) v2(65.95,5.56) v2(66.13,12.19) v2(66.58,6.19) v2(66.58,5.56) v2(67.22,6.19) v2(67.22,5.56) v2(67.85,6.19) v2(67.85,5.56)
+5VL: length 94.2
  IN2 w0.508: v2(24.14,75.92) 23.25,75.92 22.35,75.02 22.35,74.09 23.31,73.12 23.31,71.18 23.9,70.59 23.9,70.07 24.24,69.73 24.24,66.22 24.75,65.71 27.25,65.71 29.14,63.82 29.14,59.82 29.67,59.29 29.75,59.29 29.76,59.3 30.38,59.3 30.68,59.6 31.96,59.6 32.83,58.73 32.83,57.68 33.39,57.12 33.39,56.73 34.19,55.93 35.1,55.93 36.45,54.59 38.19,53.93 44.92,49.32 45.63,49.32 47.06,47.89 48.89,47.89 49.54,47.24 50.03,47.24 52.46,44.81 56.4,44.81 56.84,45.25 66,45.25 v6(66.21,45.04)
  IN3 w0.508: v6(66.21,45.04) 66.8,44.45 66.8,42.98 67.59,42.19 67.59,29.02 71.15,25.45 71.15,25.23 75.87,20.51 v2(75.9,20.51)
  vias: v2(79.16,13.18) v2(79.79,13.21) v3(78.38,13.68)
+5VLP: length 3
  BOTTOM w0.127: v1(80.4,14.09) 80.4,11.78 80.01,11.39 79.82,11.39
+5VS: length 167.4
  TOP w0.508: LA2.2 290.37,26.22 289.3,26.22 DA1.1 287.64,24.56 v3(285.57,24.56) 284.25,23.25 284.25,19.15 285.1,18.3 v2(285.1,16.79) ; v2(243.98,39.54) 247.19,39.54 249.44,41.79 v2(249.44,44.39) ; RE2.1 v2(273.17,42.54)
  IN2 w0.508: v2(261.26,42.98) 259.79,42.98 259.06,43.71 252.41,43.71 252.39,43.74 250.1,43.74 v2(249.44,44.39)
  IN2 w1.016: 16.03,111.99 15.67,111.62 15.67,96.96 16.55,96.08 16.55,85.53 15.79,84.77 15.79,81.7 16.18,81.31 16.18,75.7 16.93,74.95 16.93,72.48 18.08,71.33 18.08,70.19 18.69,69.58 18.69,67.4 17.61,66.32 17.61,66.11 16.92,65.42 16.92,63.71 20.14,60.49 20.14,53.87 23.58,50.42 24.41,50.42 24.58,50.59 ; 58.98,30.41 73.23,30.41 74.4,29.24 78.28,29.24
  BOTTOM w0.203: UG27.4 244.02,40.77 244.61,40.18 CG337.1
  BOTTOM w0.381: v2(243.98,39.54) 244.32,39.88 CG337.1
  BOTTOM w0.508: R23.1 219.74,11.5 219.29,11.04 v2(218.93,11.04) ; R24.1 210.7,12.46 v2(210.36,12.8) ; RG214.2 237.87,36.9 238.75,37.78 242.91,37.78 243.98,38.85 v2(243.98,39.54) ; JFAN2.1 31.41,49.6 30.9,49.1 30.9,46.4 CE8.1 ; RE4.1 37.41,43.58 37.24,43.75 35.97,43.75 35.26,44.46 32.2,44.46 31.92,44.74 ; CE3.1 29.24,45.65 27.54,45.65 26.73,46.47 25.96,46.47 25.03,47.41 v2(25.03,49.48)
  BOTTOM w1.016: 274.66,15.25 277.85,15.25 278.56,15.97 279.29,15.97 280.13,16.81 284.28,16.81
  vias: v2(16.59,113.08) v2(17.17,113.08) v2(55.26,40.3) v2(55.26,39.7) v2(56.69,32.29) v2(56.7,31.69) v2(96.4,24.31) v2(96.93,24.1) v2(97.07,11.8) v2(97.36,24.47) v2(97.62,11.75) v2(98.18,11.83) v2(201.21,11.06) v2(201.8,11.05) v2(205.7,11.38) v2(206.24,11.53) v2(259.33,15.63) v2(259.92,15.63) v2(260.5,15.63) v2(261.09,15.63) v2(261.64,43.45) v2(261.67,15.63) v2(262.13,43.77) v2(262.13,43.19) v2(262.25,15.63) v2(262.69,43.76) v2(262.69,43.18) v2(263.25,43.78) v2(263.25,43.2) v2(263.82,43.77) v2(263.82,43.18) v2(275.75,45.4) v2(276.03,44.89) v2(276.33,45.4) v2(276.61,44.89) v2(285.74,16.79)
+5VS_AVDD: length 9.2
  TOP w0.203: UA1.33 294.02,24.99 v2(293.83,25.17) ; UA1.40 291.21,22.23 290.99,22.45 290.81,22.45 290.4,22.86 CA11.1
  TOP w0.381: CA11.1 290.4,23.75 CA12.2
  TOP w0.508: v2(291.18,24.79) 290.45,24.79 290.43,24.76 ; 290.43,24.76 CA12.2 ; 290.43,24.76 LA2.1
  IN1 w0.508: v2(293.83,25.17) 293.35,24.69 291.55,24.69 291.45,24.79 v2(291.18,24.79)
  BOTTOM w0.127: v2(293.83,25.17) 293.44,25.17 v1(293.15,25.46)
+5VS_HDD1:
  vias: v2(248.52,12.93) v3(246.32,13.47) v3(247.16,15.11) v3(248.01,13.47)
+5VS_KBL: length 0.9
  TOP w0.127: v3(214.84,11.34) 214.38,11.8 v2(214.38,12.08)
+5VS_PVDD: length 5.5
  TOP w0.203: UA1.46 291.55,19.83 290.99,19.28 290.99,18.64 CA22.1 ; UA1.41 290.07,21.83 289.87,21.64
  TOP w0.381: CA21.1 289.36,21.12 289.87,21.64
  vias: v1(288.88,20)
+16.8V_BATT: length 57.8
  TOP w0.381: v2(242.21,14.99) 240.72,14.99 PRB06.2
  IN1 w0.381: v2(242.21,14.99) 242.14,14.93 v2(236.15,14.93)
  BOTTOM w0.381: PDB01.3 235.54,7.84 233.94,9.45 233.94,13.06 235.8,14.93 v2(236.15,14.93)
  BOTTOM w0.508: PL13.2 272.3,5.12 272.01,4.83 260.42,4.83 259.81,5.43 250.45,5.43 249.85,4.83 245.72,4.83 244.36,6.2 242.4,6.2 241.64,5.44 237.17,5.44 236.06,6.55 236.06,7.19 PDB01.3
  vias: v1(272.71,8.02) v2(269.73,9.58) v2(269.73,8.85) v2(269.73,8.09) v2(270.49,9.58) v2(270.49,8.85) v2(270.49,8.09) v2(271.25,9.61) v2(271.25,8.85) v2(271.25,8.09)
+16.8V_BATT+: length 2.3
  TOP w0.127: v3(279.81,9.26) v2(280.99,9.26) v3(282.12,9.26)
  vias: v2(275.2,8.02) v2(275.2,7.44) v2(275.79,8.02) v2(275.79,7.44) v3(274.97,6.84)
+16.8V_BATT_CHG:
  vias: v1(264.89,5.95)
+19V_ADPIN:
  vias: v3(277.69,36.75) v3(278.34,38.4) v3(279.37,37.07)
+19V_P1: length 8.3
  TOP w0.508: PRB04.1 266.1,31.9 ; PQB02.3 264.64,38.36 264.98,38.02 PRB02.2 265.4,38.33 265.73,38.66 265.77,38.66 265.79,38.68 267.03,38.68 v1(267.37,38.34) 267.82,37.89 267.82,36.74 267.38,36.29 PCB02.1
+19V_P2:
  vias: v1(261.17,32.79)
+19V_VIN: length 77.9
  TOP w0.127: PCB01.1 v3(267.96,28.06)
  TOP w0.381: 276.33,30.44 276.83,29.94 276.83,28.62 276.44,28.24 274.89,28.24 273.5,26.85 273.5,23.88 277.12,20.26 277.12,6.85 275.04,4.76 260.58,4.76 259.97,5.37 250.42,5.37 249.81,4.76 247.44,4.76 v2(246.72,5.48)
  BOTTOM w0.381: v2(246.72,5.48) 246.72,5.77 244.99,7.5 244.02,7.5 243.45,6.93 242.31,6.93 241.4,6.02 237.41,6.02 236.84,6.59 PDB01.2 236.06,8.49 235.62,8.49 234.54,9.57 PRB10.1
  vias: v3(274.82,31.74) v3(274.86,33.74)
+19VB: length 224.6
  TOP w0.381: v2(19,84.86) 19,84.48 18.17,83.64 RS39.2
  TOP w0.508: RS40.1 18.24,78.23 v2(18.61,77.87)
  TOP w1.524: 173.22,64.37 173.22,66.57 170.4,69.39 170.4,77.76 174.03,81.39 176.19,81.39 ; 170.39,94.83 172.57,97.01 180.47,97.01 182.44,95.04 186.68,95.04
  TOP w7.62: 107.55,62.15 169.26,62.15
  IN1 w1.524: 177.39,83.78 177.39,84.51 169.58,92.32 169.58,92.33
  IN2 w0.508: v2(83.91,48.82) 82.57,48.82 81.42,47.68 81.42,47.01 80.18,45.76 68.43,45.76 66.72,44.06 62.68,44.06 62.58,44.16 52.19,44.16 49.76,46.59 49.17,46.59 48.52,47.24 45.98,47.24 45.45,47.77 44.53,47.77 43.78,48.51 43.49,49.51 39.87,51.98 38.44,52.92 36.63,52.92 35.97,53.57 35.97,54.14 34.83,55.28 33.92,55.28 33.05,56.15 32.35,56.15 30.68,57.82 30.32,57.82 29.46,58.68 29.08,58.68 28.49,59.27 28.49,63.55 28.14,63.91 23.58,63.91 22.95,64.54 21.84,64.54 21.24,65.14 21.24,66.42 21.77,66.95 21.77,72.37 19.89,74.26 19.89,76.45 18.61,77.74 v2(18.61,77.87) 18.61,79.88 19.64,80.91 19.64,82.47 19,83.11 v2(19,84.86)
  BOTTOM w0.254: PR306.1 76.97,14.66 77.27,14.66 79,16.4 79.93,16.4 83.25,13.08 v2(83.28,13.08)
  vias: v1(185.41,55.22) v2(81.9,19.98) v2(82.31,20.39) v2(82.31,19.57) v2(82.73,19.98) v2(82.73,19.15) v2(83.14,19.57) v2(83.14,18.74) v2(83.55,19.15) v2(83.55,18.33) v2(83.97,18.74) v2(88.25,42.98) v2(88.25,42.39) v2(88.83,42.98) v2(88.83,42.39) v2(89.42,42.98) v2(89.42,42.39) v2(90,42.98) v2(90,42.39) v2(90.59,42.98) v2(90.59,42.39) v2(168.33,94.41) v2(168.84,94.14) v2(168.88,94.71) v2(176.26,82.89) v2(176.71,82.47) v2(177.33,82.45) v2(242.56,30.27) v2(243.15,30.27) v2(243.73,30.27) v2(244.31,30.26) v2(248.6,38.3) v2(249.19,38.89) v2(249.19,38.3) v2(249.77,38.89) v2(249.77,38.3) v2(250.36,38.89) v2(250.36,38.3) v2(266.55,12.73) v2(266.6,11.71) v2(266.81,13.26) v2(266.81,12.23) v2(267.11,12.73) v2(267.16,11.71) v2(267.37,13.26) v2(267.37,12.23) v2(267.68,12.74) v2(267.74,11.71) v2(267.93,12.24) v2(267.97,13.26) v2(268.25,12.73) v2(268.51,12.22) v6(185.91,93.85) v6(185.9,93.24) v6(186.61,93.85) v6(186.62,93.23)
+19VB_1.35VSDGPUP:
  vias: v1(255.83,46.2) v2(255.48,45.13) v2(256.04,45.11) v2(256.61,45.11)
+19VB_1V5: length 1.8
  BOTTOM w0.127: 238.29,31.25 238.15,31.25 237.24,32.16 v1(237.24,32.55)
+19VB_3V:
  vias: v1(246.45,33.98)
+19VB_5V:
  vias: v1(76.36,5.55) v2(74.84,5.18) v2(75.85,5.18) v2(76.87,5.18) v2(78.15,5.07) v2(78.78,5.07) v2(79.62,5.04) v2(80.25,5.04) v2(80.89,5.04) v2(81.49,5.03)
+19VB_CHG:
  vias: v1(247.39,11.9)
+19VB_CPU: length 13.6
  IN1 w0.254: v2(161.88,127.53) 162.9,127.53 163.53,128.17 163.53,130.58 162.13,131.98 161.63,131.98 161.12,131.47 157.69,131.47 v2(156.8,130.58)
  BOTTOM w0.254: PRZ55.1 v2(161.88,127.53)
  BOTTOM w0.508: PCZ48.1 v2(148.67,131.21)
  vias: v1(105.48,79.54) v2(110.1,91.75) v2(111.35,91.75) v2(112.59,91.75) v2(113.83,91.75) v2(115.45,92.31) v2(115.46,91.71) v2(124.29,132.61) v2(124.29,131.98) v2(124.29,131.34) v2(124.92,132.61) v2(124.92,131.98) v2(124.92,131.34) v2(125.56,132.61) v2(125.56,131.98) v2(125.56,131.34) v2(126.19,132.61) v2(126.19,131.98) v2(126.19,131.34) v2(127.63,130.5) v2(128.87,130.5) v2(130.12,130.5) v2(131.36,130.5) v2(133.11,131.47) v2(134.99,130.5) v2(136.24,130.5) v2(137.48,130.5) v2(138.73,130.5) v2(140.73,131.4) v2(142.61,130.5) v2(143.86,130.5) v2(145.1,130.5) v2(146.35,130.5) v2(150.23,130.5) v2(151.48,130.5) v2(152.72,130.5) v2(153.97,130.5) v2(154.07,132.1) v2(157.38,128.72) v2(157.97,128.75) v6(103.55,79.5) v6(103.54,78.88) v6(103.55,78.25) v6(103.56,77.61) v6(103.57,77) v6(103.58,76.38) v6(104.1,79.22) v6(104.09,78.61) v6(104.1,77.98) v6(104.11,77.34) v6(104.12,76.72) v6(104.67,78.99) v6(104.65,78.38) v6(104.67,77.75) v6(104.68,77.11) v6(104.69,76.49)
+19VB_DDR: length 18.2
  TOP w0.254: 94.25,34.53 95.83,34.53 96.53,33.82 96.53,30.07 95.17,28.71 95.17,26.39 93.54,24.77 v1(93.45,24.77) 90.98,24.77 v2(90.68,24.47)
  BOTTOM w0.254: PRM7.1 90.3,23.06 90.3,24.09 v2(90.68,24.47)
+19VB_GPU_NVVDD: length 22.4
  IN3 w0.254: v2(228.77,61.35) 228.83,61.41 230.6,61.41 231.78,60.23 233.39,60.23 233.84,59.78 233.84,58.53 234.07,58.3 234.07,54.93 232.64,53.49 232.64,49.71 v2(229.32,46.39)
  BOTTOM w0.254: v2(228.77,61.35) 228.08,61.35 PRV18.1
  vias: v1(223.26,51.43) v2(195.01,54.92) v2(196.26,54.92) v2(197.5,54.92) v2(198.74,54.92) v2(199.41,55.46) v2(199.39,54.73) v2(201.43,55.06) v2(202.18,55.05) v2(202.4,55.69) v2(202.98,54.97) v2(204.22,54.97) v2(205.47,54.97) v2(206.71,54.97) v2(207.33,55.33) v2(207.34,54.74) v2(207.39,55.93) v2(209.52,55) v2(210.27,55.61) v2(210.25,54.99) v2(210.91,54.96) v2(212.15,54.96) v2(213.4,54.96) v2(214.64,54.96) v2(215.24,55.33) v2(215.24,54.75) v2(215.26,55.9) v2(217.33,54.91) v2(217.91,54.92) v2(225.82,46.39) v2(225.82,45.81) v2(226.4,46.39) v2(226.4,45.81) v2(226.98,46.39) v2(226.98,45.81) v2(227.57,46.39) v2(227.57,45.81) v2(228.15,46.39) v2(228.15,45.81) v2(228.74,46.39) v2(228.74,45.81) v2(229.32,45.81)
+19VB_INVPWR: length 1.5
  TOP w0.127: PLP1.1 v1(79.49,39.01)
+19VB_VCCIOP:
  vias: v1(187.56,100.58)
+AVDD33: length 12.7
  IN1 w0.508: v2(44.81,15.14) 44.09,15.86 44.09,18.18 v2(44.73,18.82)
  BOTTOM w0.127: v1(45.78,21.59) 45.39,21.21 RR1.2
  BOTTOM w0.203: UR1.27 44.17,17.46 44.65,17.93 CR6.1 45.89,17.46 46.31,17.04 RR11.2
  BOTTOM w0.254: RR12.1 45.06,15.39 v2(44.81,15.14)
  BOTTOM w0.508: CR3.1 CR6.1 ; CR3.1 45.42,19.68 RR2.2 RR1.2 ; CR3.1 v2(44.73,18.82)
+DVDD: length 11.4
  TOP w0.127: CA2.1 294.09,13.42 v1(293.91,13.24)
  TOP w0.203: UA1.3 293.62,17.43 293.83,17.21
  TOP w0.381: CA2.1 294.09,14.35 294.01,14.43 294.01,14.9 v2(293.91,15.01) 293.91,16.21 CA1.1 293.83,17.21 ; v2(290.53,14.67) RA16.2
  IN2 w0.381: v2(293.91,15.01) 293.91,14.78 293.21,14.08 290.78,14.08 290.53,14.34 v2(290.53,14.67)
  BOTTOM w0.508: v2(293.91,15.01) 293.91,15.29 293.46,15.74 RA3.2
+V12_I: length 6.2
  TOP w0.127: v1(37.11,17.94) 37.8,17.26 RR14.2
  TOP w0.254: v2(38.42,17.46) 38.42,17.31 RR14.2
  BOTTOM w0.203: CR9.1 38.36,18.18 39.09,17.46 UR1.14
  BOTTOM w0.254: CR9.1 CR10.1 38.26,17.3 v2(38.42,17.46)
+V12_O: length 4.2
  TOP w0.127: v1(36.81,16.48) 36.81,16.37 37.41,15.77 RR14.1
  TOP w0.254: RR14.1 37.83,15.8 v2(38.61,15.8) 38.64,15.77 39.63,15.77 CR16.1
  BOTTOM w0.203: UR1.10 38.67,15.86 v2(38.61,15.8)
+VCC0: length 44.6
  TOP w0.254: RK33.2 108.92,27.52 109.47,27.52 109.82,27.16 RK32.2 111.14,27.16 111.63,27.65 v2(111.63,27.86) ; UK1.111 134.44,16.62 134,16.18 CK13.1 133.08,16.65 v2(133.29,16.86)
  IN3 w0.254: v2(133.29,16.86) 131.94,15.51 129.27,15.51 127.78,17.01 127.78,19.57 128.9,20.68 128.9,23.07 129.76,23.93 129.76,25.96 129.03,26.69 121.12,26.69 120.88,26.92 119.89,26.92 119.27,27.55 119.27,28.18 118.86,28.58 117.08,28.58 115.95,27.46 114.43,27.46 113.38,28.51 112.07,28.51 111.63,28.07 v2(111.63,27.86)
+VCC_CORE:
  vias: v2(126.95,113.94) v2(127.34,114.45) v2(127.34,113.43) v2(127.59,115.09) v2(127.59,113.94) v2(127.72,112.8) v2(127.97,115.72) v2(127.97,114.45) v2(127.97,113.43) v2(128.22,115.09) v2(128.22,113.94) v2(128.35,112.8) v2(128.61,115.72) v2(128.61,114.45) v2(128.61,113.43) v2(128.86,115.09) v2(128.86,113.94) v2(128.99,112.8) v2(129.24,115.72) v2(129.24,114.45) v2(129.24,113.43) v2(129.49,115.09) v2(129.49,113.94) v2(129.62,112.8) v2(129.88,115.72) v2(129.88,114.45) v2(129.88,113.43) v2(130.13,115.09) v2(130.13,113.94) v2(130.26,112.8) v2(130.51,115.72) v2(130.51,114.45) v2(130.51,113.43) v2(130.76,115.09) v2(130.76,113.94) v2(130.89,112.8) v2(131.15,115.72) v2(131.15,114.45) v2(131.15,113.43) v2(131.4,118.84) v2(131.4,118.23) v2(131.4,117.63) v2(131.4,116.99) v2(131.4,116.36) v2(131.4,115.09) v2(131.4,113.94) v2(131.78,114.45) v2(131.78,113.43) v2(132.03,113.94) v2(132.42,113.43) v2(134.32,115.09) v2(134.27,113.89) v2(134.55,118.72) v2(134.55,118.13) v2(134.52,116.33) v2(134.57,117.57) v2(134.57,116.94) v2(134.7,115.72) v2(134.7,114.45) v2(134.96,115.09) v2(134.98,113.87) v2(135.34,115.72) v2(135.34,114.45) v2(135.59,115.09) v2(135.62,113.87) v2(135.97,115.72) v2(135.97,114.45) v2(136.23,115.09) v2(136.25,113.87) v2(136.61,115.72) v2(136.61,114.45) v2(136.86,115.09) v2(137.24,115.72) v2(137.24,114.45) v2(137.5,115.09) v2(137.6,118.82) v2(137.88,115.72) v2(137.88,114.45) v2(138.13,115.09) v2(138.23,118.82) v2(138.51,115.72) v2(138.51,114.45) v2(138.77,115.09) v2(138.87,118.82) v2(138.94,118.26) v2(138.94,117.7) v2(138.94,117.14) v2(138.94,116.33) v2(139.15,115.72) v2(139.15,114.45) v2(139.4,115.09) v2(139.5,118.82) v2(139.58,118.26) v2(139.55,117.7) v2(139.55,117.14) v2(139.58,116.33) v2(139.78,115.72) v2(139.78,114.45) v2(140.04,115.09) v2(140.14,118.82) v2(140.21,118.26) v2(140.19,117.7) v2(140.19,117.14) v2(140.21,116.33) v2(140.42,115.72) v2(140.42,114.45) v2(140.67,115.09) v2(140.77,118.82) v2(140.85,118.26) v2(140.82,117.7) v2(140.77,117.12) v2(140.82,116.3) v2(141.05,115.72) v2(141.05,114.45) v2(141.31,115.09) v2(141.41,118.82) v2(141.43,118.23) v2(141.38,117.68) v2(141.38,117.12) v2(141.46,116.3) v2(141.69,115.72) v2(141.69,114.45) v2(141.91,117.5) v2(141.89,116.74) v2(141.94,115.09) v2(142.04,118.82) v2(141.99,118.23) v2(142.32,115.72) v2(142.32,114.45) v2(142.4,117.83) v2(142.4,117.12) v2(142.37,116.33) v2(142.58,115.09) v2(142.68,118.82) v2(142.68,99.18) v2(142.7,98.58) v2(142.7,97.94) v2(142.7,97.31) v2(142.7,96.67) v2(142.68,96.04) v2(142.68,95.4) v2(142.68,94.77) v2(142.7,94.13) v2(142.7,93.52) v2(142.96,115.72) v2(142.96,114.45) v2(143.21,115.09) v2(143.29,118.82) v2(143.59,115.72) v2(143.59,114.45) v2(143.66,109.47) v2(143.66,108.82) v2(143.66,108.17) v2(143.66,107.52) v2(143.66,105.57) v2(143.66,104.92) v2(143.85,115.09) v2(143.85,90.62) v2(143.87,118.82) v2(144.1,91.59) v2(144.23,115.72) v2(144.23,114.45) v2(144.44,109.47) v2(144.44,108.82) v2(144.44,108.17) v2(144.44,107.52) v2(144.44,106.87) v2(144.44,106.22) v2(144.44,105.57) v2(144.44,104.92) v2(144.48,115.09) v2(144.48,101.24) v2(144.48,99.97) v2(144.73,91.59) v2(144.67,90.65) v2(144.86,115.72) v2(144.86,114.45) v2(145.12,115.09) v2(145.23,108.17) v2(145.23,107.52) v2(145.23,106.87) v2(145.23,106.22) v2(145.23,105.57) v2(145.23,104.92) v2(145.23,104.22) v2(145.5,115.72) v2(145.5,114.45) v2(145.75,115.09) v2(146.02,109.47) v2(146.02,108.82) v2(146.02,108.17) v2(146.02,107.52) v2(146.02,105.57) v2(146.02,104.92) v2(146.13,115.72) v2(146.13,114.45) v2(146.39,115.09) v2(146.39,91.59) v2(146.54,98.19) v2(146.54,97.31) v2(146.51,96.29) v2(146.51,95.4) v2(146.51,94.38) v2(146.54,93.5) v2(146.58,99.21) v2(146.69,118.72) v2(146.69,118.16) v2(146.69,117.6) v2(146.72,117.02) v2(146.72,116.38) v2(146.77,115.72) v2(146.77,114.45) v2(146.81,108.82) v2(146.81,108.17) v2(146.81,107.52) v2(146.81,106.87) v2(146.81,106.22) v2(146.81,105.57) v2(146.81,104.92) v2(146.85,101.24) v2(146.85,99.97) v2(147.02,91.54) v2(147.59,108.82) v2(147.59,107.52) v2(147.59,106.87) v2(147.59,106.22) v2(147.59,105.57) v2(147.59,104.92) v2(147.59,104.22) v2(147.66,91.54) v2(148.29,91.51) v2(148.38,105.57) v2(148.38,104.92) v2(149.17,108.17) v2(149.17,107.52) v2(149.17,106.87) v2(149.17,106.22) v2(149.17,105.57) v2(149.17,104.92) v2(149.2,101.95) v2(149.18,99.97) v2(149.96,109.47) v2(149.96,108.82) v2(149.96,108.17) v2(149.96,107.52) v2(149.96,106.87) v2(149.96,106.22) v2(149.96,105.57) v2(149.96,104.92) v2(149.96,104.22) v2(150.07,115.59) v2(150.07,114.45) v2(150.2,118.79) v2(150.45,114.96) v2(150.7,115.59) v2(150.7,114.45) v2(150.74,109.47) v2(150.74,108.82) v2(150.74,108.17) v2(150.74,107.52) v2(150.74,105.57) v2(150.74,104.92) v2(150.78,118.82) v2(151.02,99.21) v2(150.96,95.53) v2(150.96,94.51) v2(150.96,93.5) v2(151.08,114.96) v2(151.13,91.31) v2(151.12,90.68) v2(151.34,115.59) v2(151.34,114.45) v2(151.36,118.79) v2(151.53,109.47) v2(151.53,108.82) v2(151.53,108.17) v2(151.53,107.52) v2(151.53,106.87) v2(151.53,106.22) v2(151.53,105.57) v2(151.53,104.92) v2(151.62,91.77) v2(151.72,114.96) v2(151.76,101.24) v2(151.76,99.97) v2(151.92,98.33) v2(151.92,97.32) v2(151.92,96.43) v2(151.97,115.59) v2(151.97,114.45) v2(151.97,91.31) v2(151.96,90.65) v2(152.32,108.17) v2(152.32,107.52) v2(152.32,106.87) v2(152.32,106.22) v2(152.32,105.57) v2(152.32,104.92) v2(152.32,104.22) v2(152.35,114.96) v2(152.48,91.59) v2(152.61,115.59) v2(152.61,114.45) v2(152.81,118.79) v2(152.91,90.65) v2(152.99,114.96) v2(152.99,91.34) v2(153.11,109.47) v2(153.11,108.82) v2(153.11,108.17) v2(153.11,107.52) v2(153.11,105.57) v2(153.11,104.92) v2(153.24,115.59) v2(153.24,114.45) v2(153.42,118.79) v2(153.62,114.96) v2(153.88,115.59) v2(153.88,114.45) v2(153.89,109.47) v2(153.89,108.82) v2(153.89,108.17) v2(153.89,107.52) v2(153.89,106.87) v2(153.89,106.22) v2(153.89,105.57) v2(153.89,104.92) v2(153.88,91.34) v2(154.01,118.77) v2(154.18,101.24) v2(154.18,99.97) v2(154.26,116.1) v2(154.26,114.96) v2(154.51,115.59) v2(154.51,114.45) v2(154.59,118.79) v2(154.64,91.34) v2(154.68,108.17) v2(154.68,107.52) v2(154.68,106.87) v2(154.68,106.22) v2(154.68,105.57) v2(154.68,104.92) v2(154.89,116.1) v2(154.89,114.96) v2(155.05,99.02) v2(155.15,115.59) v2(155.15,114.45) v2(155.06,98) v2(155.06,97.11) v2(155.07,96.19) v2(155.15,91.64) v2(155.17,118.79) v2(155.4,95.4) v2(155.4,94.38) v2(155.43,93.5) v2(155.53,116.1) v2(155.53,114.96) v2(155.47,109.47) v2(155.47,108.82) v2(155.47,108.17) v2(155.47,107.52) v2(155.47,105.57) v2(155.47,104.92) v2(155.66,91.34) v2(155.91,114.45) v2(156.25,109.47) v2(156.25,108.82) v2(156.25,108.17) v2(156.25,107.52) v2(156.25,106.87) v2(156.25,106.22) v2(156.25,105.57) v2(156.25,104.92) v2(156.55,91.34) v2(156.57,101.24) v2(156.57,99.97) v2(157.04,108.17) v2(157.04,107.52) v2(157.04,106.87) v2(157.04,106.22) v2(157.04,105.57) v2(157.04,104.92) v2(157.04,104.22) v2(157.13,91.46) v2(157.73,109.54) v2(157.71,91.46) v2(157.83,108.82) v2(157.83,108.17) v2(157.83,107.52) v2(157.83,105.57) v2(157.83,104.92) v2(158.32,91.34) v2(158.42,109.59) v2(158.62,108.82) v2(158.62,108.17) v2(158.62,107.52) v2(158.62,106.87) v2(158.62,106.22) v2(158.62,105.57) v2(158.62,104.92) v2(159.06,91.77) v2(159.4,108.17) v2(159.4,107.52) v2(159.4,106.87) v2(159.4,106.22) v2(159.4,105.57) v2(159.4,104.92) v2(159.4,104.22) v2(159.39,91.31) v2(161.14,91.34) v3(144.07,117.26)
+VCC_GT: length 6.9
  IN3 w0.508: v2(146.24,110.59) 142.74,110.59 142.08,109.93 v2(142.08,109.47)
  BOTTOM w0.508: RC12.2 146.82,112.19 146.24,111.61 v2(146.24,110.59)
  vias: v2(114,103.66) v2(114,103.02) v2(114,102.39) v2(114,101.75) v2(114.05,99.18) v2(114.51,103.4) v2(114.51,102.77) v2(114.51,102.13) v2(114.64,99.21) v2(114.64,98.58) v2(115.14,103.66) v2(115.14,103.02) v2(115.27,98.7) v2(115.27,98.07) v2(115.78,103.66) v2(115.78,103.02) v2(115.91,98.7) v2(115.91,98.07) v2(116.41,103.66) v2(116.41,103.02) v2(116.54,98.7) v2(116.54,98.07) v2(116.67,106.07) v2(116.67,105.43) v2(117.18,98.7) v2(117.17,98.07) v2(117.3,106.7) v2(117.3,106.07) v2(117.81,107.08) v2(117.81,106.45) v2(117.81,105.81) v2(118.32,108.61) v2(118.32,107.97) v2(118.32,107.34) v2(118.32,106.7) v2(118.32,106.07) v2(118.7,101.88) v2(118.7,101.24) v2(118.7,100.61) v2(118.7,99.97) v2(118.7,99.34) v2(126.93,108.97) v2(127.61,93.3) v2(127.61,92.51) v2(128.27,109.59) v2(128.26,93.3) v2(128.26,92.51) v2(128.79,107.7) v2(128.91,93.3) v2(128.91,92.51) v2(128.98,109.59) v2(129.56,93.3) v2(129.56,92.51) v2(129.7,109.61) v2(130.21,93.3) v2(130.21,92.51) v2(130.3,108.16) v2(130.31,107.53) v2(130.86,101.17) v2(130.86,98.81) v2(130.86,93.3) v2(130.86,92.51) v2(131.51,101.17) v2(131.51,98.81) v2(131.51,93.3) v2(131.51,92.51) v2(131.85,109.49) v2(131.85,108.79) v2(131.85,108.14) v2(132.24,101.17) v2(132.63,109.47) v2(132.63,108.82) v2(132.63,108.17) v2(132.63,107.52) v2(132.63,106.87) v2(132.63,106.22) v2(133.42,108.17) v2(133.42,107.52) v2(133.42,106.87) v2(133.42,106.22) v2(133.42,105.57) v2(133.42,104.92) v2(133.42,104.22) v2(134.21,109.47) v2(134.21,108.82) v2(134.21,108.17) v2(134.21,107.52) v2(134.21,105.57) v2(134.21,104.92) v2(134.57,91.59) v2(135,109.47) v2(135,108.82) v2(135,108.17) v2(135,107.52) v2(135,106.87) v2(135,106.22) v2(135,105.57) v2(135,104.92) v2(135.21,91.59) v2(135.78,108.17) v2(135.78,107.52) v2(135.78,106.87) v2(135.78,106.22) v2(135.78,105.57) v2(135.78,104.92) v2(135.78,104.22) v2(135.84,91.59) v2(136.38,101.85) v2(136.38,100.45) v2(136.38,93.95) v2(136.41,92.76) v2(136.46,91.57) v2(136.57,109.47) v2(136.57,108.82) v2(136.57,108.17) v2(136.57,107.52) v2(136.57,105.57) v2(136.57,104.92) v2(137.11,91.59) v2(137.36,109.47) v2(137.36,108.82) v2(137.36,108.17) v2(137.36,107.52) v2(137.36,106.87) v2(137.36,106.22) v2(137.36,105.57) v2(137.36,104.92) v2(137.75,91.59) v2(138.14,108.17) v2(138.14,107.52) v2(138.14,106.87) v2(138.14,106.22) v2(138.14,105.57) v2(138.14,104.92) v2(138.14,104.22) v2(138.16,94.56) v2(138.38,91.59) v2(138.84,94.18) v2(138.93,109.47) v2(138.93,108.82) v2(138.93,108.17) v2(138.93,107.52) v2(138.93,105.57) v2(138.93,104.92) v2(138.86,92.83) v2(139.02,91.59) v2(139.72,109.47) v2(139.72,108.82) v2(139.72,108.17) v2(139.72,107.52) v2(139.72,106.87) v2(139.72,106.22) v2(139.72,105.57) v2(139.72,104.92) v2(139.65,91.59) v2(140.29,91.59) v2(140.51,108.17) v2(140.51,107.52) v2(140.51,106.87) v2(140.51,106.22) v2(140.51,105.57) v2(140.51,104.92) v2(140.51,104.22) v2(140.92,91.59) v2(141.2,102) v2(141.2,100.78) v2(141.29,109.47) v2(141.29,108.82) v2(141.29,108.17) v2(141.29,107.52) v2(141.29,105.57) v2(141.29,104.92) v2(141.29,104.22) v2(142.08,108.82) v2(142.08,108.17) v2(142.08,107.52) v2(142.08,106.87) v2(142.08,106.22) v2(142.08,105.57) v3(117.47,99.77)
+VCC_SA: length 2
  BOTTOM w0.135: UC1.L36 160.99,107.53 v2(160.98,107.52) ; v2(160.98,107.52) 160.99,107.51 UC1.L35 ; v2(160.98,107.52) UC1.M35 ; v2(160.98,107.52) UC1.M36
  vias: v2(157.82,115.72) v2(157.82,115.09) v2(157.82,114.45) v2(158.45,115.72) v2(158.45,115.09) v2(158.45,114.45) v2(159.09,115.72) v2(159.09,115.09) v2(159.09,114.45) v2(159.72,115.72) v2(159.72,115.09) v2(159.72,114.45) v2(160.36,115.72) v2(160.36,115.09) v2(160.36,114.45) v2(160.99,115.72) v2(160.99,115.09) v2(160.99,114.45) v2(160.98,108.82) v2(160.98,108.17) v2(160.98,106.87) v2(160.98,106.22) v2(160.98,105.57) v2(160.98,104.92) v2(160.98,104.22) v2(160.98,103.57) v2(160.98,102.92) v2(161.63,115.72) v2(161.63,115.09) v2(161.63,114.45) v2(161.77,109.47) v2(161.77,108.82) v2(161.77,108.17) v2(161.77,107.52) v2(161.77,106.87) v2(161.77,105.57) v2(161.77,104.92) v2(161.77,104.22) v2(161.77,102.92) v2(162.52,105.59) v2(162.57,108.85) v2(162.55,107.52) v2(162.55,106.87) v2(162.55,106.22) v3(159.61,116.74)
+VCCRTCEXT: length 4.4
  BOTTOM w0.203: UH1.BF47 UH1.BG47
  BOTTOM w0.254: UH1.BG47 191.54,17.75 190.33,16.53 190.33,14.76 CH25.1
GND: length 2442.3
  TOP w0.127: CR4.2 38.8,20.72 v3(39.32,21.24) ; C408.2 v3(178.52,26.55) ; v3(57.83,34.31) v2(58.41,34.31)
  TOP w0.203: v2(9.38,53) 8.94,53.44 JUSBC1.5 ; 8.23,49.24 8.59,49.24 8.99,48.84 v2(9.24,48.84) ; JUSBC1.6 8.43,51.44 8.46,51.41 8.89,51.41 9.26,51.77 v2(9.26,51.87) ; v2(46.05,48.04) 46.34,47.75 UU4.51 46.34,45.69
  TOP w0.254: RT809.2 33.91,56.31 33.91,56.95 v2(34.04,57.07) 34.28,57.07 34.63,56.73 RT808.2 ; v2(138.13,22.5) 138.04,22.6 UK1.94 ; v2(12.86,52.5) 13.2,52.16 DU1.3 DU1.8 16.07,52.16 v2(16.08,52.15) ; U9.8 178.71,48.08 v2(179.32,48.69) ; v2(149.37,5.05) 149.53,5.22 149.53,5.6 CK1.2 ; CT274.2 35.61,53.53 v2(36.9,53.53) ; v2(146.18,9.82) 146.18,9.55 146.44,9.29 UK1.24 ; UT1.16 v2(125.02,13.59) 125.02,13.4 124.59,12.98 CTT323.2 ; v2(179.92,48.65) 179.21,47.93 U9.7 ; v2(121.52,13.49) 121.52,13.49 UT1.9 ; CU58.1 10.42,52.71 10.13,53 v2(9.96,53) ; v2(129.75,18.92) 129.75,18.67 129.27,18.18 CTT2.2 ; UT1.32 121.52,19.7 121.35,19.87 v2(121.02,19.87) ; UK1.113 134.46,15.82 134.13,15.49 v2(133.95,15.49) 133.65,15.49 133.55,15.38 132.81,15.38 RK29.1 ; v2(269.71,42.91) 269.71,43.12 269.32,43.51 C402.2 ; UK1.11 141.24,5.73 141.33,5.64 CK4.2 ; v2(288.33,28.53) 288.55,28.32 RA20.2 ; v2(180.66,47.46) 179.67,46.47 U9.5 ; v2(17.03,48.46) 17.01,48.44 DU3.3 ; U9.6 179.58,46.97 179.75,47.14 179.75,47.83 v2(180.56,48.64) ; v2(15.32,80.54) 15.83,81.05 QS1.1 ; PQ2.4 274.52,15.12 274.3,14.9 v2(274.3,14.39) ; RG48.1 213.87,99.23 v2(212.76,100.34) ; U11.5 177,30.2 v2(176.41,30.79) ; v2(215.2,81.05) 214.65,81.05 CG50.2 ; U4019.4 110.38,20.75 R124.2 ; PUG1.6 116.78,94.9 v2(116.67,95.02) ; RT860.2 27.1,53.58 26.72,53.96 v2(26.72,54.18) 26.72,54.48 27,54.76 CT271.2 ; PCZ3.1 173.88,133.86 174.79,133.86 v2(174.87,133.78) ; RT810.2 32.6,56.37 v2(32.6,56.78) ; UK1.35 150.21,10.62 149.1,11.73 v2(149.1,11.86) ; v2(232.48,11.71) 233,12.23 PRB25.2 ; UT1.2 120.27,18.16 v2(119.96,17.85) ; DU3.8 v2(13.9,48.44) ; UT1.23 v2(126.63,18.16)
  TOP w0.305: v2(137.13,33.1) 136.95,33.1 136.61,32.76 136.61,30.76 135.72,29.87 CD73.2 ; v2(142.64,39.37) 142.77,39.37 143.34,38.8 143.34,37.74 142.8,37.21 CD77.2 ; CD86.2 133.18,30.07 132.95,30.3 132.95,30.86 132.98,30.89 132.98,30.9 133.27,31.2 133.29,31.2 133.38,31.29 v2(133.51,31.29) ; CD90.2 143.4,36.96 143.4,34.73 v2(142.74,34.08) ; CC402.2 CC407.2 110.76,87.82 110.55,88.03 v2(110.44,88.03) ; v2(29.53,55.89) 29.62,55.89 29.97,56.24 RT816.2 ; CA93.2 300.33,17.88 300.77,17.45 300.77,17.22 300.97,17.02 v2(300.97,16.81) ; v2(139.37,30.27) 138.41,29.31 CD88.2 ; v2(61.11,31.69) 60.74,31.69 60.36,32.08 C5273.1 ; CA4.2 301.58,18.29 v2(302.06,18.29) ; CD83.2 130.26,29.87 130.64,30.25 130.64,30.86 130.21,31.29 v2(130.13,31.29) ; v2(132.21,34.95) 131.53,35.63 CD89.2 ; CD78.2 134.7,36.35 135.08,35.96 135.08,35.2 134.7,34.82 v2(134.45,34.82) ; CWL5.2 311,6.17 CWL3.2 v2(311.61,5.74) ; v2(117.48,43.36) 117.18,43.05 CD31.2 ; CA1.2 293.25,16.86 v2(293.12,16.99) 292.56,16.43 CA94.1 292.56,15.69 RA15.2 ; CD21.2 134.22,42.47 134.68,42.01 CD27.2 ; v2(129.42,33.75) 129.08,34.1 129.08,36.18 CD71.1 ; v2(144.61,34.44) 144.72,34.44 145.12,34.83 CD76.2 ; v2(290.43,17.07) 290.43,17.5 CA22.2 ; v2(304.61,20.86) 303.74,20.86 303.61,20.72 CA18.1 ; v2(24,52.09) 24.06,52.16 24.88,52.16 25.24,51.8 RT1112.2 ; CD74.2 131.78,29.77 131.27,30.27 131.27,30.86 131.68,31.27 v2(131.81,31.27) ; v2(137.14,31.34) 137.09,31.29 137.09,30.55 136.61,30.07 CD85.2
  TOP w0.356: CH30.2 211.74,17.5 CH85.2 CH31.2 211.74,19.21 v2(211.89,19.37) ; PCV35.2 204.55,86.91 v2(204.08,86.44) ; v2(196.88,98.64) 196.84,98.6 CG52.2 196.83,98.08 CG54.2 ; PCV34.2 208.36,77.99 v2(207.8,78.55) ; PCV41.2 207.58,79.55 v2(207.67,79.46) ; CG25.2 194.76,95.76 v2(195.16,96.16) ; v2(27.28,49.31) 27.27,49.32 RT1114.2 ; CH82.1 192.61,19.05 v2(193.41,19.85) ; 26.48,47.52 25.94,47.52 v2(25.72,47.74) ; CH86.2 CH29.2 207.9,19.45 v2(207.94,19.41) ; RT815.2 25.55,53.68 RT1111.2 ; PCV37.2 202.78,87.13 v2(203.08,87.44) ; CH9.1 191.6,18.06 RH210.1 ; CH26.2 CH84.2
  TOP w0.381: QV7.1 73.16,29.6 v2(72.99,29.43) ; RG94.1 240.94,91.02 v2(240.94,91.69) ; v2(254.35,35.74) 254.35,35.74 254.35,36.06 253.79,36.62 CC389.2 ; v2(216.98,92.77) 216.43,92.21 CG128.2 CG129.2 ; CD87.2 126.32,30.28 v2(125.69,30.91) ; CD69.1 142.96,29.61 RD28.1 ; CD69.1 CD72.1 ; CD69.1 144.23,29.87 CD70.1 144.07,30.38 143.51,30.93 143.51,31.5 143.92,31.91 v2(144.03,31.91) ; RD3.2 168.93,39.77 168.6,39.45 v2(168.28,39.45) ; CA32.1 295.07,28.41 295.39,28.73 v2(295.43,28.73) ; v2(169.18,34.61) 168.95,34.61 RD23.2 ; CG111.2 239.15,79.18 v2(239.04,79.07) ; v2(193.95,133.8) 193.92,133.83 CG77.2 ; CG108.2 237.05,91.68 v2(237.04,91.69) ; CG112.2 249.16,75.33 v2(249.17,75.34) ; CG187.2 243.84,96.49 v2(243.84,96.49) ; RH196.2 214.29,10.7 214.47,10.7 v2(215.04,10.13) ; v2(211.65,15.86) 211.82,16.03 CH30.2 ; CD64.2 CD100.2 v2(171.23,36.01) ; R5802.2 179.8,42.89 v2(180.43,42.26) ; RK20.1 148.79,5.41 v2(148.79,5.05) ; CD75.2 121.9,38.86 121.24,39.52 v2(120.99,39.52) ; v2(40.07,44.41) 40.11,44.41 40.11,44.4 40.68,44.4 RU72.2 ; v2(247.84,99.69) 247.81,99.65 CG94.2 ; CD14.1 148.04,42.59 v2(146.77,43.86) 146.26,43.36 RD10.1 ; v2(235.97,52.62) 235.97,53.05 236.17,53.25 QG8.4 ; CD84.2 140.08,37.54 v2(139.69,37.92) ; v2(166.29,38.85) 166.29,38.29 CD60.1 ; v2(141,86.82) 140.77,86.58 CC18.2 ; v2(185.95,124.6) 185.9,124.55 CG81.2 ; v2(207.72,80.25) 207.7,80.27 PCV33.2 206.88,80.27 PCV32.2 ; CV19.2 29.97,59.03 v2(30.31,58.69) ; CK10.2 v2(148.19,5.07) ; CV49.2 70.84,39.84 v2(71.18,39.84) ; UV1.2 71.57,39.39 71.46,39.28 v2(71.19,39.28) ; QS1.4 18.91,79.75 19.26,79.4 19.26,77.11 v2(18.71,76.56) ; v2(25.03,54.08) 25.22,54.27 RT815.2 ; CG118.2 244.03,89.72 v2(243.73,89.72) ; CG117.2 242.97,67.31 v2(242.97,67.88) ; v2(213.2,134.2) v2(212.6,134.2) 212.1,134.2 CG158.2 ; C366.2 v2(17.01,2.44) ; v2(304.27,7.37) 303.39,7.37 QWL3.3 ; RV57.1 64.47,31.13 64.14,31.47 v2(63.72,31.47) ; CC40.2 166.08,105.1 v2(166.3,105.33) ; RK26.2 147.35,5.06 v2(147.34,5.05) ; v2(212.6,131) 212.3,131 CG161.2 ; v2(153.22,11.34) 153.43,11.34 154.03,11.94 RK28.1 ; v2(166.29,40.09) 166.62,40.09 167.09,39.62 CD103.1 CD61.1 ; QT2.2 36.57,46.16 v2(36.66,46.26) ; v2(64.03,39.48) 64.03,40.13 C5254.2 ; CD96.2 136.23,44.04 135,45.26 v2(134.75,45.26) ; CD29.2 143.51,49.78 CD91.2 142.07,49.27 142.07,48.06 142.55,47.57 v2(142.64,47.57) ; CG169.2 199.35,123 v2(198.75,123) ; CG64.2 187.01,128.15 v2(186.57,128.6) ; PCV65.2 209.01,76.63 v2(209.32,76.94) ; C5246.1 178.28,50.03 v2(178.68,50.43) 178.92,50.2 C5247.1 ; CD80.2 116.52,29.77 v2(117.36,30.61) ; v2(51.23,36.8) 50.8,37.23 CU66.2 ; CA4.2 300.74,19.12 CA3.2 ; v2(238.64,91.69) 238.7,91.69 239.12,91.26 CG182.2 ; v2(139.69,48.62) 139.69,48.97 139.53,49.13 CD24.2 ; v2(214.48,97.84) 214.68,97.64 214.68,97.14 ; CA36.1 302.69,26.65 v2(303.07,26.65) ; v2(237.53,51.13) 237.88,51.13 RG12.2 ; v2(139.4,31.52) 140.03,31.52 140.43,31.12 RD29.1 ; v2(297.34,30.53) 297.53,30.72 CA37.1 ; v2(140.01,5) 140.01,5.59 CK2.2 ; CG61.2 189.15,120.54 v2(189.15,121) ; CG142.2 246.64,67.27 v2(246.64,67.87) ; CG19.2 218.01,91.35 v2(217.78,91.12) ; CA15.2 v2(300.07,15.76) ; v2(149.84,39.6) 148.65,40.79 CD12.1 ; v2(217.78,93.62) 217.78,93.99 217.33,94.44 CG202.2 ; v2(298.17,15.46) 298.28,15.57 CA88.1 ; C5245.1 179.63,50.26 v2(179.15,50.75) ; v2(139.69,43.95) 138.21,42.47 CD94.2 ; CG9.2 209.26,97.7 v2(209.41,97.84) ; v2(272.85,17.4) 273,17.55 PR20.2 ; Q73.3 216.86,15.02 v2(216.86,15.38) ; v2(246.24,99.69) 246.28,99.65 CG96.2 ; CG170.2 193.9,129.74 v2(193.95,129.8) ; CG115.2 245.36,82.24 CG90.2 ; CG115.2 245.76,81.55 v2(246.64,80.67) ; CG115.2 245.04,81.24 v2(245.04,80.67) ; v2(202.42,75.87) 202.04,76.26 PCV48.2 ; CD98.2 172.55,52.19 172.22,52.52 172.22,52.55 v2(172.19,52.58) ; CG101.2 234.75,79.98 v2(234.84,80.07) ; CD65.2 CD101.2 171.28,39.76 v2(171.29,39.77) ; v2(185.95,123) 185.3,123 CG62.2 ; v2(204.93,132.41) 204.65,132.13 C393.2 C394.2 ; v2(309.31,29.77) 308.97,30.12 RA24.1 ; CG177.2 243.84,75.46 v2(243.84,75.87) ; CG166.2 190.81,129.74 v2(190.75,129.8) ; v2(49.36,36.62) 49.7,36.97 CU73.2 ; v2(149.85,38.7) 149.74,38.7 148.54,39.9 RD6.2 ; CH73.1 193.5,18.57 193.5,19.76 v2(193.41,19.85) ; C365.2 v2(18.24,5.1) ; CD99.2 v2(171.79,47.65) ; CG156.2 243.46,74.24 CG178.2 243.46,73.09 v2(243.78,72.76) ; v2(237.04,80.67) 236.99,80.73 CG113.2 ; v2(144.35,47.9) 144.49,47.9 145.5,48.91 CD19.2 ; v2(141.94,5) 141.84,5.1 CK4.2 ; UH3.3 216.93,10.15 216.41,10.15 v2(216.41,10.15) ; v2(245.08,89.21) 245.48,89.61 CG157.2 ; RG401.1 225.28,63.87 v2(224.8,63.4) ; C5263.2 41.05,15.18 v2(40.49,15.74) ; v2(188.35,133.8) 189.2,134.64 RG60.2 ; v2(158.13,40.86) 158.15,40.84 CD22.2 ; PCB24.2 242.16,5.58 v2(242.64,5.58) ; v2(310.54,25.06) 311,24.6 CWL2.2 ; v2(234.84,91.69) 234.69,91.54 CG153.2 ; CU70.2 40.93,46.11 v2(40.52,46.52) ; v2(130.64,46.25) 131.41,46.25 CD30.2 ; v2(134.76,44.09) 134.47,44.09 133.69,43.31 CD21.2 ; RG74.2 241.76,69.79 v2(242.24,70.27) ; v2(198.75,131) 199.12,131.37 CG83.2 ; EC11.2 v2(18.37,5.92) ; v2(186.55,135) v2(186.55,134.2) v2(185.95,134.2) 185.36,134.2 CG82.2 ; CU69.2 53.82,44.02 v2(54.28,43.55) 54.49,43.76 CU74.2 ; v2(247.84,72.67) 247.68,72.84 CG100.2 ; C5251.2 64.06,40.8 64.06,41.14 v2(64.21,41.3) ; v2(266.78,38.07) 266.21,38.07 PRB01.1 ; v2(211.93,99.54) 211.33,98.94 CG10.2 ; QC11.4 v2(183.14,15.55) ; CC38.2 163.33,106.86 v2(163.35,106.88) ; CA38.1 302.5,24.97 304.22,24.97 v2(304.5,24.69) ; CG181.2 234.58,101.29 v2(235.04,101.29) ; CG109.2 v2(248.55,89.03) ; v2(166.32,33.94) 166.95,33.94 167.16,34.15 RD22.2 ; v2(205.3,135.86) 205.3,136.14 C395.2 ; PRB19.2 241.68,7.88 v2(241.68,7.89) ; RK27.2 131.54,13.57 v2(130.85,13.57) ; v2(142.64,43.29) 142.32,42.98 CD26.2 ; CD79.2 156.32,39.01 v2(156.87,39.01) ; CD6.2 v2(172.42,47.65) ; C368.2 v2(21.25,4.52) ; CD95.2 147.15,49.3 v2(146.76,48.92) ; CD5.2 171.53,51.64 171.73,51.84 171.73,52.12 v2(171.76,52.14) ; v2(9.24,123.05) 9.56,122.73 D1.1 ; QG8.1 234.25,53.17 v2(234.25,53.63) 234.25,54.05 RG402.1 ; CG162.2 212.18,121.4 v2(212.6,121.4) ; CH83.1 CH10.1 190.34,20.9 CK14.1 ; QC11.1 181.67,12.76 RC393.2 ; v2(168.01,40.75) 168.12,40.64 RD5.2 169.78,40.64 v2(169.8,40.61) 170.52,40.61 CD9.2 ; v2(198.75,126.9) 198.75,126.9 199.22,126.9 RG90.1 ; v2(279.81,30.53) 279.81,30.36 280.32,29.86 PC1.2 ; v2(213.19,120.75) 213.36,120.57 CG140.2 ; CR1.2 CR4.2 38.08,20.31 v2(38.45,19.94) ; v2(212.6,128.7) v2(213.2,128.7) 213.42,128.7 213.84,128.27 CG76.2 ; RWL2.2 v2(311.68,21.11) ; v2(32.6,56.78) 32.18,56.78 31.83,56.43 RT812.2 ; CG114.2 248.37,67.74 v2(248.24,67.87) ; PRB29.2 244.32,7 v2(244.37,6.95) ; v2(215,125) v2(215,124.2) ; v2(146.13,30.63) 146.13,30.38 145.88,30.12 RD24.2 ; v2(245.04,67.87) 245.04,67.03 CG148.2 ; v2(305.31,4.93) 305.08,4.93 304.73,5.28 304.73,5.9 CW1.2 ; v2(142.59,5.01) 142.7,5.13 RK31.1 ; RG93.1 240.94,81.23 v2(240.94,80.67) ; CV53.1 CV43.1 28.28,56.24 28.51,56.24 v2(28.8,56.52) ; v2(238.64,80.67) 238.69,80.72 CG116.2 ; v2(149.94,44.28) 149.33,43.67 149.33,43.36 149.81,42.87 CD28.2 ; v2(234.84,80.67) 234.79,80.71 234.79,81.52 CG151.2 ; v2(185.95,131) 185.95,131 CG63.2 ; CWL7.2 v2(311.57,23.52) ; v2(94.7,32.41) 94.68,32.4 PCM14.2 ; v2(250.59,100.42) 249.8,100.42 CG155.2 ; v2(188.32,19.93) 188.79,19.93 CH84.2 ; CG171.2 190.78,133.83 v2(190.75,133.8) ; CD92.2 134.14,49.61 134.14,47.94 134.43,47.65 v2(134.6,47.65) ; v2(139.36,52.32) 138.72,52.96 CD20.2 ; v2(21.73,88.66) 21.33,88.66 21.19,88.8 DS5.1 ; v2(169.36,53.79) 169.71,53.79 170.01,53.49 CD1.1 CD102.1 CD2.1 ; v2(198.75,124.6) 199.25,124.6 CG87.2 ; v2(272.29,17.36) 272.29,17.22 PQ2.1 ; CG152.2 243.48,98.72 CG97.2 243.84,99.68 v2(243.84,99.69) v2(243.84,100.49) ; CC36.2 164.32,90.72 v2(164.32,91.18) ; RK23.2 136.82,26.18 CK9.2 v2(137.87,26.18) ; v2(225.4,134.2) v2(224.8,134.2) v2(224.8,135) ; Q79.3 v2(20.29,5.98) ; RV47.2 v2(69.6,41.15) ; CG57.2 185.52,129.4 v2(185.95,129.4) ; D3.1 v2(206.84,128.93) ; RWL1.2 v2(311.68,21.87) ; RG89.1 211.66,129.95 v2(211.02,129.95) ; C5250.2 v2(17.01,1.8) ; v2(40.49,16.86) 40.15,16.86 40,16.71 CR16.2 ; v2(196.56,85.37) 197.36,85.37 CG136.2 ; v2(225.4,131) v2(224.8,131)
  TOP w0.406: CG137.2 210.22,80.63 v2(210.22,80.19)
  TOP w0.457: LK2.1 148.92,26.49 v2(148.62,26.19) 148.16,26.19 148.01,26.34 RK34.1 ; CC20.2 147.24,90.17 v2(147.41,90) ; v2(141.94,90.65) 141.94,90.87 CC17.2 ; v2(39.17,48.37) 39.43,48.1 CU71.2 ; 159.04,85.45 159.01,85.45 CC19.2 ; CC32.2 155.02,90.02 v2(155.67,89.37) ; v2(151.96,86.17) 151.97,86.15 151.97,85.21 ; RH198.1 191.22,11.44 v2(191.59,11.06) 191.98,11.45 RH197.1 ; v2(143.77,87.48) 143.26,86.98 CC25.2 ; v2(138.28,88.12) 138.87,88.12 CC154.2 ; v2(154.34,83.52) 154.61,83.52 155.02,83.92 CC28.2 ; v2(164.32,97.48) 164.27,97.43 CC34.2 ; CC153.2 150.09,86.13 v2(149.28,86.13) ; CC31.2 148.98,90.52 148.45,90 v2(148.33,90) ; v2(136.76,85.44) 136.99,85.21 CC152.2 ; v2(146.51,87.48) 146.77,87.23 146.77,86.26 CC26.2 ; v2(151.09,87.4) 151.08,87.41 CC27.2 ; RH258.1 192.92,9.23 193.27,8.88 v2(193.63,8.88) ; CH71.1 215.39,24.53 v2(214.82,25.11)
  TOP w0.508: v2(195.67,8.88) 195.77,8.98 RH256.2 ; v2(10.06,44.6) 10.88,44.6 DU13.1 ; C388.2 90.05,11.95 v2(90.05,12.16) ; v2(132.39,7.62) 132.39,8.44 CC144.2 ; CK5.1 154.03,12.65 RK28.1 ; PC5.2 285.16,41.16 v2(285.16,42.28) ; RG49.1 215.73,96.51 v2(216.16,96.94) ; U7.1 v2(210.67,136.34) ; CH64.2 207.27,21 v2(207.27,21.01) ; RL55.2 v2(40.85,35.01) ; v2(220.04,9.54) 219.32,9.54 CH1.2 ; CH70.2 194.37,19.05 v2(194.78,19.46) ; RM11.1 55.38,18.49 v2(55.71,18.83) ; C5278.1 215.08,27.32 215.54,27.79 v2(215.54,27.98) ; PR13.2 130.91,25.24 v2(130.33,24.67) ; v2(184.89,15.4) RH199.1 ; PCZ184.2 143.9,100.61 v2(144.48,100.61) ; RH23.2 214,17.9 213.37,17.27 v2(213.37,17.23) 213.15,17.45 CH36.2 ; R5804.2 65.49,41.18 v2(65.95,41.65) ; CU67.2 49.32,36.59 v2(49.36,36.62) ; v2(211.14,33.49) 210.37,34.26 RH173.2 ; PCB23.2 v2(238.53,4.83) ; v2(14.84,84.07) 16.58,82.33 CS108.2 ; CL29.2 50.79,16.11 v2(50.69,16.01) ; CD23.2 132.09,52.3 v2(131.45,52.3) ; CK12.2 128.86,22.25 128.83,22.22 CK11.1 127.41,22.22 v2(127.3,22.33) 126.87,22.76 QK1.3 ; CT270.2 37.18,53.81 v2(36.9,53.53) ; CH103.2 163.63,101.47 v2(163.7,101.4) ; CK13.2 131.68,16.18 v2(131.52,16.03) ; PRB34.2 v2(237.66,4.83) ; CD3.2 CD4.2 174.35,49.88 v2(175.21,49.02) ; PRZ61.2 163.17,126.64 v2(161.88,126.64) ; v2(108.47,18.56) 108.91,18.99 PC2503.2 ; RH8.2 212.88,36.95 v2(212.64,36.71) ; v2(128.56,27.98) 128.48,28.07 CD10.1 ; CC35.2 164.32,94.99 v2(164.32,95.12) ; v2(188.32,19.93) 188.07,20.18 CLRP2.1 ; PCZ191.2 148.94,101.31 v2(149.18,101.31) ; CC37.2 132.75,90.71 v2(132.8,90.66) ; v2(155.06,27.98) 155.43,27.98 157.12,26.29 PCB31.2 ; CH12.2 v2(202.42,36.45) ; PCB03.1 233.21,14.85 v2(232.91,15.14) ; v2(173.41,35.75) 173.42,35.75 173.84,36.17 CD63.2 CD62.2 ; v2(160.74,123.21) 160.56,123.39 PCA7.2 ; CH35.2 206.43,23.06 206.41,23.08 v2(206.41,23.32) ; RH20.1 213.18,34.08 v2(212.64,34.62) ; PCA27.2 161.06,93.7 160.67,93.31 PCZ286.2 161.14,92.81 v2(161.32,92.63) ; CC405.2 166.2,95.2 v2(166.27,95.12) ; v2(9.3,59.92) 9.25,59.97 DM16.1 ; v2(306.54,5.83) 305.9,6.47 305.9,6.75 ; v2(147.66,126.96) 147.66,126.54 PCZ47.2 ; PC325.2 71.7,8.13 71.79,8.22 v2(73.82,8.22) ; v2(151.76,101.88) 152.22,101.88 PCZ177.2 ; CV31.2 28.42,67.1 v2(28.74,66.79) ; CC397.2 180.7,106.8 v2(180.76,106.86) ; PCZ54.2 141.81,126.54 v2(141.81,126.13) ; DT1.1 94.88,14.2 v2(94.35,14.2) ; CH108.2 189.01,16.03 v2(188.5,16.03) ; PCG59.2 139.35,92.21 v2(138.87,92.21) ; v2(285.8,25.94) 285.81,25.93 DA1.2 ; RU79.1 53.52,40.51 v2(54.01,40.51) ; PR2507.2 103.38,15.77 v2(103.18,15.97) ; CH14.2 204.05,33.58 204.05,34.39 v2(204,34.44) ; CLRP1.1 189.16,17.19 189.64,17.68 RH212.1 190.42,17.68 v2(190.63,17.47) 191.51,17.47 RH210.1 ; PC2.2 281.89,29.86 282.55,30.52 v2(282.55,30.71) ; v2(294.59,14.97) 295,14.56 CA2.2 ; CD11.1 CD14.1 ; v2(189.57,21.56) 190.05,21.07 CK14.1 ; CC33.2 164.22,92.86 v2(164.32,92.76) ; 159.04,85.45 v2(159.39,85.45) ; v2(193.18,32.2) 192.92,32.2 192.36,32.76 192.36,32.92 191.95,33.32 CH32.2 ; PCZ68.2 128.06,127.43 126.88,127.43 v2(126.85,127.45) ; PCG66.2 139.36,93.52 v2(138.88,93.52) ; PCP7.2 85.38,34.82 v2(85.38,34.22) ; v2(117.53,14.05) 117.58,13.99 CTT1.2 ; v2(117.54,18.08) 117.65,18.19 CTT3.2 CTT4.2 ; v2(162.12,100.85) 161.74,101.23 PCA23.2 ; CH72.1 v2(218.9,23.39) ; RH22.2 212.77,21.38 v2(212.73,21.42) ; v2(178.04,31.3) 178.01,31.32 176.64,31.32 v2(176.62,31.34) 176.14,31.82 C5277.2 ; PCZ274.2 159.91,90.64 CC24.2 160.23,90.17 v2(160.23,89.36) ; PD1.1 v2(281.89,41.93) ; v2(164.32,99.06) 165.26,99.06 CH102.2 ; PU2501.2 v2(108.13,16.91) ; v2(286.21,42.26) PR5.2 ; v2(154.16,101.86) 153.69,101.86 PCZ187.2 ; v2(183.47,111.66) 182.82,112.3 PCH2.2 ; CU57.1 v2(12.24,52.71) ; v2(35.15,3.22) 35.13,3.21 C409.2 34.42,3.22 C5249.2 C410.2 ; PCB29.2 243.02,10.53 v2(242.51,10.53) ; C5258.2 87.35,6.88 v2(87,6.53) ; v2(215.04,10.13) 215.19,9.98 CH79.1 ; RH24.2 214.27,17.29 v2(214,17.01) ; C367.2 v2(37.51,2.06) ; RD11.1 129.58,91.19 129.05,91.72 v2(128.91,91.72) ; C5256.2 v2(84.86,6.55) ; v2(151.76,100.61) 152.17,100.61 152.41,100.37 PCZ188.2 ; DA8.1 v2(297.18,37.86) ; v2(284.48,42.26) 284.43,42.21 PC6.2 ; CWL1.2 v2(311.65,22.76) ; CL1.1 v2(45.9,32.54) ; RA37.2 288.14,15.34 v2(286.9,15.34) 286.9,14.94 QA3.3 ; CC39.2 162.26,103.57 v2(161.77,103.57) ; v2(131.6,10.18) 132.08,10.18 CK8.2 ; PC1003.2 234.57,24.07 v2(235.03,23.61) ; v2(154.63,52.65) 153.87,52.65 CD18.2 ; RC393.2 181.67,11.79 v2(182.11,11.35) ; CD13.1 124.24,51.2 v2(124.52,51.49) ; CLRP3.1 217,20.37 219.06,18.31 v2(219.28,18.31) ; PD3.2 v2(287.31,38.76) ; PCZ190.2 147.45,100.61 v2(146.88,100.61) ; C390.2 198.33,8.95 v2(198.58,9.21) ; RH50.1 192.16,21.67 v2(192.88,21.67) ; CH22.2 206.86,32.69 v2(207.09,32.92) ; v2(255.31,43.06) 255.22,43.15 CC393.2 CC392.2 ; DA9.1 v2(297.2,41.96) ; v2(208.84,22.95) 208.5,23.29 CH63.2 ; v2(174.17,42.42) 173.84,42.09 CD8.2 CD7.2 ; CC29.2 164.24,86.82 164.66,87.23 v2(165,87.23) ; PCZ185.2 143.92,101.88 v2(144.48,101.88) ; CH15.2 192,34.29 193.19,33.1 v2(193.19,32.85) ; C389.1 184.59,11.48 v2(184.03,11.48) ; CH81.2 211.06,30.15 v2(211.54,30.15) ; CD81.1 141.32,28.08 v2(141.86,28.08) ; PCB05.2 235.94,16.51 v2(236.11,16.35) ; v2(125.96,40.77) 125.96,40.77 126.61,41.43 CD16.2 ; v2(16.96,118.12) CV52.1 15.1,118.12 CV45.2 14.01,118.15 v2(13.87,118.29) ; PCZ297.2 155.39,90.64 CC32.2 ; v2(149.18,100.61) 148.65,100.61 PCZ181.2 ; v2(164.93,51.6) 164.93,51.6 165.25,51.6 165.61,51.24 CD17.2 ; C5257.2 85.79,6.97 85.47,6.65 v2(85.47,6.35) ; CD93.2 104.74,40.5 v2(104.74,40.73) ; RH14.1 214.54,29.18 v2(214.87,29.18) ; v2(103.04,24.24) 103.04,23.08 103.97,22.15 Q32.3 ; CU59.2 12.05,51.87 CU60.1 v2(12.7,51.84) ; v2(118.45,95.65) 118.88,96.09 PCG6.2 ; CD25.2 131.65,42.15 v2(130.57,43.24) ; RH156.1 196.78,11.23 v2(196.94,11.06) ; CH13.2 202.43,34.72 v2(202.46,34.7) ; v2(201,9.2) C391.2 ; v2(201.35,27.21) 201.41,27.28 CH62.2 ; PCZ180.2 147.45,101.88 v2(146.88,101.88) ; v2(198.46,27.77) 198.46,27.18 CH33.2 ; RK4.1 154.52,26.55 PCB32.2 154.56,26.93 153.52,27.98 v2(152.95,27.98) ; C5259.2 88.27,6.94 v2(87.58,6.25) ; CV1.1 v2(73.08,37.11) ; CH27.2 v2(178.74,15.64) ; CU68.2 54.5,45.96 v2(53.92,45.96) ; v2(154.16,100.61) 153.73,100.61 PCZ176.2 ; DM5.2 84.97,10.49 v2(84.67,10.79) ; PCB30.2 v2(244.94,8.88) ; v2(45.67,25.37) 45.67,25.84 46.27,26.44 CL4.2 ; PQ1.3 274.88,13.81 v2(274.3,14.39) ; RV50.2 v2(78.71,40.54) ; RK34.1 148,26.43 CK15.2 ; PC2501.1 103.41,17.57 v2(102.39,18.59) ; v2(19.98,65.67) 19.98,65.22 20.37,64.82 RV22.1 ; RTT12.2 118.06,15.7 v2(117.53,15.7) ; RK30.1 v2(131.5,18.97) ; PRB30.2 v2(236.89,4.84) ; v2(111.02,20.72) R124.2 ; CE5.2 v2(274.87,42.5)
  GND1 w0.203: H16.1 4.67,124.73
  GND2 w0.203: H16.1 4.67,124.73
  BOTTOM w0.127: v3(228.13,71.72) v2(228.87,71.72) ; v2(266.18,45.76) v3(266.18,46.42) ; v2(217.76,75.34) 217.33,75.77 UG1.D2 ; 212.83,31.79 212.9,31.73 213.28,31.73 213.45,31.55 213.87,31.55 v2(214.13,31.81) ; UH1.D8 210.91,39.09 210.7,39.31 210.7,40.07 210.79,40.16 UH1.A8 ; v2(232.91,15.14) v3(232.91,15.73) ; v3(236.35,31.16) 236.75,31.56 v2(237.24,31.56) ; v2(123.6,6.78) v3(122.82,6.78) ; UC1.F29 164.34,103.69 164.34,104.37 164.66,104.69 UC1.F31 ; v2(213.58,102.74) v2(213.58,101.94) v2(214.41,101.94) ; v2(295.43,28.73) v3(294.78,28.73) ; v3(181.66,116.07) v2(181.17,115.58)
  BOTTOM w0.15: v2(217.78,96.94) 217.78,96.09 UG1.C25 ; v2(217.78,91.12) 217.78,91.74 217.58,91.94 217.18,91.94 216.98,92.14 v2(216.98,92.77) ; v2(218.58,83.62) 218.58,84.29 218.43,84.44 v2(217.78,84.44)
  BOTTOM w0.152: UH1.A28 200.82,40.49 v2(201.89,41.56) ; UH1.AD49 190.88,28.9 v2(190.88,27.8) 190.88,27.62 UH1.AG49 ; v2(215.54,27.98) 215.54,27.52 215.44,27.42 214.79,27.42 UH1.AG1 ; v2(197.06,16.29) 196.43,16.92 UH1.BG37 ; UH1.AM1 214.43,25.11 v2(214.82,25.11) ; UH1.M49 190.88,35 192.05,35 192.44,34.61 UH1.P46 ; v2(190.81,36.45) 191.03,36.22 UH1.J48 191.55,36.38 UH1.J47 192.33,36.38 UH1.J46 ; v2(202.37,17.28) 202.37,17.66 UH1.BG25 ; v2(200.82,17.29) UH1.BG28 ; UH1.AA49 190.81,30.66 191.95,30.66 192.44,30.17 UH1.AC46 ; UH1.AT1 214.38,23 214.68,23 v2(214.81,22.87) ; UH1.A33 198.63,40.49 v2(199.29,41.16) ; v2(196.73,40.81) 196.43,40.51 UH1.A37 ; v2(198.63,17) UH1.BG33 ; v2(215.73,90.69) UG1.G19 ; v2(214.87,29.18) 214.79,29.1 UH1.AD1 UH1.AD2 ; UH1.BG17 v2(206.72,17.44) ; UH1.BG22 v2(204.18,17.28) ; v2(220.18,82.77) 219.76,83.19 UG1.B10
  BOTTOM w0.178: UG1.E22 v2(215.73,93.19) UG1.G22
  BOTTOM w0.2: v2(220.18,93.62) v2(219.38,93.62)
  BOTTOM w0.203: UH1.G3 213.82,38.2 UH1.F3 ; UC1.BE3 UC1.BE2 UC1.BE1 134.67,82.01 134.19,81.54 v2(134.19,81.38) ; UC1.BE3 UC1.BE4 UC1.BE5 134.99,85.44 v2(135.06,85.44) ; UC1.BE3 v2(134.17,83.5) ; UC1.AG8 UC1.AG7 148.79,85.89 UC1.AG6 ; UC1.BH3 132.19,83.78 132.19,83.2 UC1.BH2 131.9,82.91 UC1.BH1 131.9,82.08 v2(131.81,82) ; UC1.BH3 131.75,83.48 v2(131.72,83.48) ; UC1.BH3 132.21,83.88 132.21,84.41 UC1.BH4 UC1.BH5 132.03,85.12 v2(131.71,85.44) ; UC1.BA9 UC1.BA8 ; UC1.BA9 v2(138.28,88.12) ; UC1.BA9 UC1.BA10 v2(138.28,88.75) UC1.BA11 v2(138.28,89.39) ; UC1.BA8 v2(138.28,87.48) ; UC1.BA8 UC1.BA7 137.82,86.41 UC1.BB6 ; UC1.W3 v2(154.34,83.52) ; UC1.W3 154.82,83.78 154.82,83.2 UC1.W2 UC1.W1 154.78,82.03 154.5,81.75 v2(154.34,81.59) ; UC1.W3 UC1.W4 UC1.W5 154.97,85.12 UC1.V6 155.69,85.7 156.4,85.7 UC1.U6 156.46,85.86 UC1.T7 UC1.T8 UC1.T9 ; UC1.AL9 146.44,88.12 v2(146.51,88.12) v2(146.51,87.48) 146.1,87.08 UC1.AL8 UC1.AL7 ; UC1.BM12 129.56,89.43 v2(129.56,89.36) UC1.BM11 130.17,88.69 130.17,88.54 129.89,88.26 UC1.BM9 129.65,87.94 129.65,87.63 UC1.BM8 129.56,87.06 129.56,87.01 ; UC1.M6 UC1.N6 ; UC1.N6 159.71,85.77 v2(159.39,85.45) 159.65,85.19 159.72,85.12 UC1.N5 UC1.N4 159.85,84.43 159.85,83.85 UC1.N3 UC1.N2 UC1.N1 ; UC1.N6 159.81,86.38 UC1.N7 159.82,86.48 159.82,87.02 UC1.N8 160.24,87.56 160.24,88 v2(160.21,88.03) 160.07,88.03 UC1.N9 159.75,87.75 159.75,88.36 UC1.N10 ; v2(151.09,87.4) 151.48,87.07 UC1.AD8 ; UC1.BN2 129.32,83.33 129.7,83.53 UC1.BM2 UC1.BM3 129.89,84.34 129.89,84.44 v2(130.05,84.6) 129.86,84.8 129.86,84.89 129.78,85.04 UC1.BM5 ; v2(141.85,80.86) 141.47,81.24 141.47,81.61 142.21,82.35 UC1.AR1 UC1.AR2 UC1.AR3 UC1.AR4 v2(141.77,84.75) 142.03,84.97 UC1.AR5 ; UC1.A18 168.38,95.18 v2(168.38,95.19) ; 129.56,87.01 v2(129.55,87.01) ; 129.56,87.01 129.56,86.96 129.89,86.63 UC1.BM7 UC1.BL6 ; UC1.Y8 154.66,87.45 v2(154.74,87.45) ; UC1.Y8 UC1.Y9 UC1.Y10 ; UC1.Y8 UC1.Y7 154.2,86.34 154.2,86.21 154.13,86.15 153.75,86.15 153.63,86.02 153.5,86.02 153.24,85.77 UC1.AB6 UC1.AC6 UC1.AC5 UC1.AC4 152.12,84.47 151.95,84.29 v2(151.82,84.17) 152.18,83.82 UC1.AC3 UC1.AC2 UC1.AC1 152.17,82.41 152.17,78.24 152.16,78.24 v2(152.16,77.31) ; UC1.AD8 UC1.AD7 ; UC1.AD8 151.57,87.11 151.57,87.7 UC1.AD9 ; v2(152,88.1) 151.91,88.1 UC1.AD9 ; v2(160.23,89.36) 160.54,89.68 UC1.M12 UC1.M13 UC1.M14 ; v2(160.23,89.36) 159.89,89.03 UC1.N11 ; v2(160.23,89.36) 159.91,89.68 UC1.N12 ; UC1.AU11 UC1.AU10 UC1.AU9 UC1.AU8 140.75,87.08 v2(141,86.82) 140.61,86.43 UC1.AU7 140.99,86 141.22,85.77 UC1.AT6 ; UC1.AU11 141,88.77 141.01,88.73 v2(141.03,88.72) ; UC1.AU11 UC1.AU12 ; 154.71,90.65 154.75,90.61 154.75,90.15 155.2,89.71 UC1.W12 ; 154.71,90.65 154.38,90.33 UC1.Y13 ; 154.71,90.65 154.61,90.65 UC1.Y14 ; v2(168.49,88.41) UC1.A10 ; v2(168.49,97.86) UC1.A22 ; v2(135.53,89.96) 135.59,89.96 135.87,89.68 UC1.BC12 UC1.BC13 UC1.BC14 ; v2(143.77,87.48) 143.36,87.08 UC1.AP8 143.74,86.64 143.74,85.91 UC1.AN6 143.84,85.72 UC1.AN5 ; v2(143.77,87.48) 143.55,87.48 UC1.AP9 ; v2(143.77,87.48) v2(143.77,88.12) ; UC1.T3 UC1.T4 UC1.T5 ; UC1.T3 157.17,83.82 v2(156.86,83.51) ; UC1.T3 157.3,83.71 157.31,83.7 157.31,83.32 157.3,83.3 UC1.T2 UC1.T1 157.26,82.52 v2(156.91,82.17) ; UC1.AG6 UC1.AH6 UC1.AJ6 UC1.AJ5 UC1.AJ4 ; UC1.AG6 v2(149.28,86.13) ; v2(149.76,81.97) UC1.AF1 UC1.AF2 149.73,83.16 149.35,83.42 v2(149.34,83.49) 149.68,83.68 149.72,83.7 UC1.AF3 UC1.AF4 ; v2(126.52,85.51) 126.52,85.49 126.68,85.33 UC1.BT5 ; UC1.BE6 UC1.BF6 UC1.BG6 UC1.BH6 ; UC1.BE6 135.08,86.18 UC1.BD7 UC1.BD8 v2(135.54,87.48) UC1.BD9 v2(135.54,88.12) UC1.BD10 v2(135.54,88.75) UC1.BD11 135.55,89.4 135.55,89.38 ; UC1.BE6 v2(135.06,85.44) ; UC1.BH6 UC1.BH7 ; UC1.BH6 131.83,85.44 v2(131.71,85.44) ; UH1.BB41 194.66,20.14 194.66,20.01 194.65,20 194.65,19.59 v2(194.78,19.46) ; v2(159.35,86.12) 159,85.77 UC1.P6 ; UC1.T12 156.86,89.85 156.28,89.85 UC1.V12 ; UC1.T12 UC1.T13 UC1.T14 ; UC1.T12 157.19,89.68 v2(157.48,89.39) 157.65,89.39 UC1.R12 158.2,89.94 158.59,89.94 UC1.P12 159.07,89.9 159.55,89.9 UC1.N12 ; UC1.T12 UC1.T11 UC1.T10 ; UC1.BM5 129.68,85.14 UC1.BM6 129.77,85.77 UC1.BL6 ; UC1.BM5 129.7,85.04 UC1.BN4 129.14,84.48 128.81,84.48 128.78,84.45 128.44,84.45 128.28,84.29 127.8,84.29 127.55,84.53 UC1.BT4 ; UC1.BL6 UC1.BK6 131.38,85.77 v2(131.71,85.44) ; v2(139.25,82.84) 139.58,82.52 UC1.AW1 139.72,82.54 139.72,83.14 UC1.AW2 139.73,83.2 139.73,83.78 UC1.AW3 UC1.AW4 v2(139.24,84.72) UC1.AW5 139.88,85.12 UC1.AU6 ; v2(135.06,85.44) UC1.BD6 UC1.BC6 v2(136.76,85.44) ; PUM1.14 90.63,27.35 v2(91.03,26.95) ; v2(143.77,88.12) 143.57,88.12 143.34,88.35 UC1.AP10 ; v2(143.77,88.12) 143.77,88.75 v2(143.77,88.75) ; UC1.N12 UC1.N11 ; UC1.BH7 UC1.BH8 ; UC1.BH7 v2(132.79,86.75) ; v2(136.76,85.44) 136.8,85.4 136.8,85.4 136.8,84.96 136.86,84.9 136.86,84.69 136.8,84.62 136.8,84.31 137.02,84.09 137.15,84.09 137.18,84.05 UC1.BB3 137.2,83.79 137.2,83.19 UC1.BB2 137.2,83.15 137.2,82.53 UC1.BB1 ; v2(136.76,85.44) 136.86,85.44 UC1.BB6 ; UC1.AD6 151.1,85.43 v2(151.01,85.43) 150.93,85.43 UC1.AE6 ; UH1.BC45 v2(193.41,19.85) ; v2(193.41,19.85) UH1.BD43 193.51,19.01 193.45,18.86 UH1.BE44 ; v2(193.41,19.85) UH1.BB43 ; UH1.E40 195.19,38.8 194.65,38.8 UH1.E42 194.27,38.46 UH1.F43 ; UC1.AD11 UC1.AD10 ; UC1.AD11 151.9,89.39 v2(151.99,89.39) 152,89.02 v2(152,88.75) 151.91,88.75 UC1.AD10 ; UC1.AD11 UC1.AD11 ; UC1.AD10 UC1.AD9 ; UC1.BB6 UC1.BA6 ; UC1.BB6 137.36,85.59 137.36,85.3 UC1.BB5 137.24,85.06 137.24,84.53 UC1.BB4 ; v2(141.94,90.65) 142.26,90.98 UC1.AR14 142.42,90.95 142.42,90.36 UC1.AR13 ; v2(160.23,88.71) 159.89,88.38 UC1.N10 ; UC1.AJ4 UC1.AK4 146.22,84.33 145.75,84.33 UC1.AL4 ; UC1.AJ4 UC1.AJ3 147.12,83.82 v2(146.8,83.49) 146.89,83.49 147.21,83.17 UC1.AJ2 147.28,83.13 147.28,82.56 UC1.AJ1 146.9,82.85 v2(146.81,82.85) ; UC1.N10 UC1.N11 ; v2(214.88,33.74) 214.58,33.74 214.47,33.85 214.05,33.85 213.94,33.74 213.19,33.74 UH1.R3 ; UC1.F31 164.21,105.4 163.89,105.4 UC1.H32 ; v2(143.77,88.75) 143.58,88.75 UC1.AP11 143.67,89.39 v2(143.77,89.39) 143.77,89.39 v2(143.77,88.75) ; UC1.B3 167.34,83.77 UC1.A3 UC1.A4 ; UC1.BH8 UC1.BH9 132.5,87.89 132.5,88.21 UC1.BH10 v2(132.8,88.75) UC1.BH11 ; UC1.BH8 v2(132.79,87.4) ; UC1.AG10 149.17,88.75 v2(149.26,88.75) ; v2(168.49,91.56) UC1.A14 ; v2(168.49,93.13) UC1.A16 ; v2(190.63,17.47) 190.65,17.46 UH1.BG48 UH1.BF48 UH1.BF49 ; UH1.P46 192.75,33.76 192.75,33.29 v2(193.19,32.85) ; UC1.BN7 129.24,86.68 129.1,86.82 129.1,86.82 v2(128.91,87.01) 128.91,86.93 UC1.BP7 128.56,86.63 127.96,86.63 UC1.BR7 ; v2(167.53,99.04) 167.53,99.05 UC1.A24 ; UH1.AL12 208.78,25.98 v2(208.78,26.61) ; UC1.AG11 149.11,89.35 v2(149.22,89.35) ; UC1.A9 UC1.B9 ; v2(126.69,96.84) UC1.BT21 UC1.BR21 ; v2(93.89,28.02) 93.62,27.75 PUM1.1 ; v2(144.87,81.9) 144.73,82.04 UC1.AM1 UC1.AM2 UC1.AM3 144.76,83.85 144.76,84.43 UC1.AM4 UC1.AM5 ; v2(168.49,96.28) UC1.A20 ; UC1.Y10 154.66,88.75 v2(154.74,88.75) 154.47,89.03 UC1.Y11 UC1.Y10 ; UH1.C12 208.8,38.99 UH1.D12 ; UH1.AW46 192.55,21.93 192.72,22.1 192.72,22.66 192.64,22.74 UH1.AT45 192.64,23.54 v2(192.65,23.55) 192.44,23.76 UH1.AP46 ; PUM1.3 v2(94.1,26.95) ; v2(168.49,89.98) UC1.A12
  BOTTOM w0.229: UH1.AT21 204.32,23.39 203.2,23.39 UH1.AT24 ; v2(201.43,19.51) 201.46,19.54 UH1.BC26
  BOTTOM w0.25: v2(216.88,104.34) 216.88,104.33 216.43,103.88 216.42,103.88 v2(216.08,103.54) ; v2(196.01,99.52) 195.99,99.5 195.24,99.5 v2(195.18,99.44) ; v2(220.94,101.77) 220.93,101.76 220.93,101.71 220.23,101.01 v2(220.23,100.94)
  BOTTOM w0.254: v2(147.53,110.61) 147.53,110.87 147.73,111.07 147.73,111.91 148.01,112.19 RC13.2 ; UH1.D12 208.5,38.69 UH1.E13 208.69,38.26 209.5,38.26 209.51,38.25 v2(210.13,38.25) 210.49,38.25 UH1.E8 ; v2(145.85,38.67) 146.03,38.5 JDIMM2.167 ; v2(126.4,83.62) 126.59,83.81 UC1.BT3 ; PUZ4.6 137.49,132.49 v2(137.5,132.48) ; UC1.BJ18 131.79,94.47 v2(131.51,94.14) 131.24,94.47 UC1.BK18 131.14,94.47 v2(130.86,94.14) 130.59,94.47 UC1.BL18 130.49,94.47 v2(130.21,94.14) 129.94,94.47 UC1.BM18 129.84,94.47 v2(129.56,94.14) 129.29,94.47 UC1.BN18 129.19,94.47 v2(128.91,94.14) 128.64,94.47 UC1.BP18 128.54,94.47 v2(128.26,94.14) 127.99,94.47 UC1.BR18 127.89,94.47 v2(127.61,94.14) 127.33,94.47 UC1.BT18 ; UC1.K38 v2(162.55,109.47) ; JDIMM1.27 110.53,48.97 110.52,48.28 110.52,47.73 v2(109.38,46.58) ; v2(164.32,99.06) UC1.F23 v2(164.97,98.27) ; v2(164.32,99.06) UC1.G23 ; v2(164.32,99.06) UC1.G24 v2(163.62,99.84) UC1.H25 UC1.J25 ; v2(301.39,7.09) 301.9,7.6 JWLAN1.61 ; v2(128.91,99.6) UC1.BP24 UC1.BR24 v2(127.61,99.6) ; v2(128.91,99.6) UC1.BP25 UC1.BR25 v2(127.61,99.6) ; v2(128.91,99.6) UC1.BN24 v2(129.56,98.81) ; v2(208.47,30.34) 208.47,30.04 UH1.AC12 ; UH1.F41 194.4,37.87 v2(194.11,37.58) ; UH1.BG2 213.96,17.04 v2(214,17.01) ; UH1.BG2 UH1.BF2 UH1.BF1 ; UH1.BG2 UH1.BG3 213.53,17.55 213.4,17.29 v2(213.37,17.23) 213.22,17.28 UH1.BG4 UH1.BF3 ; v2(192.29,25.87) 192.44,26.02 UH1.AK46 ; v2(135,104.22) UC1.BE30 v2(134.21,104.22) ; UH1.AW4 212.69,21.83 212.75,21.44 v2(212.73,21.42) 212.77,21.29 212.57,20.96 UH1.BA5 211.84,20.9 UH1.BA6 ; JEDP1.6 63.55,31.3 v2(63.72,31.47) ; v2(168.98,47.17) 168.8,47.17 167.52,48.45 JDIMM1.247 ; UG1.T7 v2(207.72,80.25) ; UH1.E10 209.83,38.81 v2(210.23,38.81) UH1.D8 ; v2(163.35,106.88) 163.42,106.88 UC1.H35 ; v2(153.11,106.87) UC1.AB34 v2(153.11,106.22) UC1.AB33 ; v2(130.21,98.81) UC1.BM24 v2(129.56,98.81) ; v2(145.12,132.48) 145.11,132.49 PUZ3.6 ; UH1.AM18 UH1.AL17 206.63,26.41 v2(206.53,26.52) UH1.AH17 ; UH1.BB9 UH1.BC8 v2(210.17,19.42) UH1.BC10 ; UC1.F11 164.64,89.19 v2(164.36,88.82) 164.01,88.44 UC1.G10 164.37,87.98 ; v2(165,87.23) UC1.F9 164.37,87.98 ; v2(165,87.23) UC1.E9 ; v2(165,87.23) UC1.F8 UC1.G8 UC1.J7 ; v2(137.36,104.22) UC1.BB30 v2(136.57,104.22) ; v2(138.93,106.87) UC1.AY34 v2(138.93,106.22) UC1.AY33 ; UH1.N35 198.08,35.04 UH1.M34 ; UH1.N35 197.25,34.21 v2(197.25,33.85) ; UH1.N35 UH1.N34 UH1.R34 ; UC1.AU33 v2(141.29,106.22) UC1.AU34 v2(141.29,106.87) ; 164.37,87.98 UC1.G9 ; UC1.C31 v2(166.3,105.33) UC1.D33 165.77,105.96 UC1.E34 165.26,106.52 v2(164.9,106.88) ; v2(199.93,33.82) 200.06,33.82 200.37,33.51 UH1.R29 ; UH1.AN12 208.94,24.58 209.23,24.29 209.23,24.29 v2(209.23,24.28) ; UC1.BP14 v2(128.91,91.72) UC1.BN14 UC1.BM14 ; UH1.M16 UH1.N16 UH1.R16 ; UH1.M16 207.03,35.04 207.66,35.67 v2(207.81,35.67) ; UH1.M16 206.76,35.04 v2(206.31,35.02) UH1.M18 v2(205.04,35.45) 204.6,35 UH1.M21 ; UC1.BJ30 131.35,103.57 UC1.BK29 v2(130.98,102.79) ; UH1.D17 206.4,38.88 206.3,38.71 206.3,38.71 UH1.E17 206.3,38.43 v2(205.98,38.12) 205.82,38.12 UH1.E19 ; UH1.G44 193.76,37.3 194.04,37.58 v2(194.11,37.58) ; UC1.BT14 v2(127.61,91.72) UC1.BR14 ; v2(212.5,39.92) UH1.C4 ; UC1.J4 v2(163.58,84.13) UC1.G4 ; UC1.J4 UC1.K5 ; UC1.J4 v2(162.74,84.13) ; JDIMM2.192 152.28,28.32 v2(151.94,27.99) ; JWLAN1.55 303.75,9.1 304.12,9.47 v2(304.12,9.8) 304.12,10.11 303.63,10.6 JWLAN1.49 ; UC1.AU7 140.38,86.43 v2(140.07,86.73) ; v2(214.13,31.81) 214.43,32.12 215.87,32.12 216.12,31.86 218.28,31.86 v2(218.47,31.67) 218.8,31.34 220.69,31.34 221.25,31.9 v2(221.25,33.23) 221.25,34.62 221.09,34.78 v2(220.71,34.78) 220.25,35.24 219.1,35.24 218.78,35.56 216.46,35.56 v2(215.88,34.98) 215.88,34.75 v2(214.88,33.74) ; UC1.G4 UC1.G5 ; UC1.G4 UC1.F4 ; UH1.AK27 UH1.AL26 UH1.AK25 ; UH1.AK27 v2(201.34,26.39) ; UH1.AK27 v2(202.11,26.39) ; UC1.T10 v2(157.49,88.75) UC1.T11 ; UC1.T10 v2(156.53,88.05) UC1.T9 ; UC1.T10 v2(157.49,88.12) ; v2(205.21,26.39) 205.25,26.43 UH1.AJ19 205.5,26.88 205.25,27.12 205.21,27.16 205.07,27.02 UH1.AJ20 ; v2(205.21,26.39) UH1.AK20 ; v2(205.21,26.39) 205.25,26.35 UH1.AK19 ; v2(205.21,26.39) UH1.AJ20 ; v2(199.86,75.75) 199.73,75.88 199.73,76.44 UG1.AE2 ; UC1.AY12 139.07,89.35 139.32,89.35 UC1.AW12 139.8,89.68 v2(140.09,89.98) ; v2(138.93,104.22) UC1.AW30 v2(139.72,104.22) ; v2(211.87,38.89) UH1.C5 ; v2(201.34,26.39) UH1.AJ27 ; v2(201.34,26.39) UH1.AJ28 ; v2(201.34,26.39) UH1.AK28 ; UH1.AA20 v2(204.44,31.04) v2(203.66,31.04) v2(202.89,31.04) ; UH1.AA20 205.21,30.26 v2(205.21,30.26) ; UH1.AA20 204.82,30.65 v2(204.44,30.26) ; UG1.F28 215.73,98.24 v2(215.31,98.67) UG1.G28 v2(214.48,97.84) ; v2(202.13,27.18) UH1.AJ27 ; v2(202.13,27.18) 202.1,27.18 UH1.AG27 ; v2(202.13,27.18) 202.13,27.15 UH1.AJ25 v2(202.11,26.39) ; v2(202.13,27.18) UH1.AG25 202.89,27.94 ; UH1.AJ27 v2(202.11,26.39) ; UH1.AJ27 201.73,26.84 v2(201.35,27.21) ; 211.84,29.14 211.91,29.14 212.56,29.68 UH1.AC4 ; 211.84,29.14 212.56,28.52 UH1.AE4 ; 211.84,29.14 v2(211.46,29.24) ; v2(202.11,26.39) UH1.AK25 ; UH1.AK25 202.99,25.51 UH1.AL24 ; v2(202.11,30.26) UH1.AB25 202.88,29.5 v2(202.88,29.42) 202.83,29.42 UH1.AD25 v2(202.89,28.71) 202.51,28.34 UH1.AF25 202.89,27.94 ; 192.76,32.2 192.59,32.2 191.97,32.82 190.84,32.82 UH1.T49 ; 192.76,32.2 UH1.V46 ; 192.76,32.2 v2(193.18,32.2) ; v2(152.74,132.48) 152.73,132.49 PUZ2.6 ; v2(126.53,107.01) UC1.BT35 ; JIO1.15 305.76,38.75 v2(305.59,38.58) ; UG4.F5 v2(217.42,125.8) UG4.G5 v2(216.6,125.8) UG4.F5 ; UG4.F5 v2(217.42,125) ; 202.89,27.94 UH1.AG23 ; UC1.BM13 UC1.BL13 130.83,90.9 ; UH1.D16 206.97,38.37 v2(207.08,38.26) UH1.E15 207.68,38.46 207.68,38.08 206.98,37.38 v2(206.98,37.13) ; UC1.C25 166.49,100.23 165.95,100.89 UC1.D26 v2(166.27,101.42) UC1.C27 ; v2(305.56,40.38) 306,40.38 306.13,40.25 JIO1.12 ; v2(129.55,105.86) 129.85,105.5 UC1.BM33 ; UC1.BL38 v2(130.4,109.6) UC1.BM38 ; v2(194.11,37.58) 193.91,37.78 UH1.F43 ; v2(129.56,98.81) UC1.BM23 ; UH1.AH33 198.47,26.55 198.5,26.51 v2(198.5,26.42) 198.48,26.28 198.48,26.26 198.42,26.22 198.37,25.89 UH1.AL33 v2(197.87,25.26) 198.15,24.97 UH1.AN34 UH1.AR34 UH1.AT34 198.24,23.06 198.74,23.06 199.12,23.06 UH1.AT32 ; UC1.AE33 v2(150.74,106.22) UC1.AE34 v2(150.74,106.87) ; v2(132.8,90.66) UC1.BG14 ; v2(132.8,90.66) UC1.BH14 ; v2(132.8,90.66) UC1.BG13 ; UG1.AP2 192.49,76.43 v2(192.49,75.9) ; v2(198.78,35.48) UH1.M32 v2(199.93,34.53) UH1.P29 ; v2(127.61,99.6) UC1.BT24 ; UH1.J40 195.24,36.26 UH1.K39 195.42,35.75 v2(196.04,35.14) 196.04,34.56 UH1.N38 ; UC1.AD7 151.77,86.43 151.96,86.24 v2(151.96,86.17) 151.96,86.15 152.27,85.84 UC1.AC6 ; v2(209.68,31.66) UH1.Y10 ; v2(209.68,31.66) 209.87,31.85 210.49,31.85 v2(210.52,31.81) 210.52,31.41 UH1.Y9 ; v2(209.68,31.66) 208.98,32.36 UH1.U12 v2(208.92,32.88) UH1.R12 ; UC1.BK25 v2(131.51,100.38) UC1.BJ25 ; UC1.D12 UC1.C11 v2(166.92,88.82) ; v2(198.38,30.34) 198.38,29.75 UH1.AC33 ; JHDD1.9 247.15,13.23 v2(246.83,12.91) ; v2(201.19,38.81) 201.34,38.66 UH1.E26 202.5,39.24 UH1.C25 ; JDIMM2.18 v2(106.78,28.06) ; UH1.AC38 196.17,31.04 UH1.Y38 195.52,31.7 195.26,31.7 v2(194.88,32.08) ; UH1.AK20 v2(204.44,26.39) UH1.AJ20 ; UH1.AK20 UH1.AL21 ; v2(126.55,105.44) UC1.BT32 ; v2(152.75,44.14) 152.65,44.14 151.77,43.26 JDIMM1.184 ; UC1.K10 v2(162.03,88.06) UC1.K9 ; UC1.BG12 133.08,89.68 v2(132.79,89.39) 132.63,89.39 132.34,89.68 UC1.BH12 ; UC1.C2 166.68,83.98 v2(166.64,84.02) ; UH1.AJ20 UH1.AG22 204.44,27.94 204.39,27.98 UH1.AF22 204.44,28.71 UH1.AD22 ; UC1.F2 UC1.F3 UC1.F4 ; UC1.BM21 v2(130.21,96.45) ; UC1.BM21 v2(129.56,96.45) UC1.BN21 v2(128.91,96.45) UC1.BP21 ; UC1.BM21 UC1.BM22 ; v2(130.21,96.45) UC1.BL21 UC1.BL22 ; v2(130.21,96.45) UC1.BL20 UC1.BL19 ; v2(166.94,87.23) UC1.C9 166.32,87.98 ; v2(166.94,87.23) UC1.C8 UC1.D6 ; v2(166.94,87.23) UC1.B9 ; UH1.J26 v2(202.42,36.45) ; RC16.2 159.31,112.32 159.03,112.04 159.03,111 159.41,110.63 v2(159.51,110.63) ; v2(146.52,88.78) 146.51,88.77 ; 146.51,88.77 v2(146.51,88.12) ; 146.51,88.77 146.44,88.77 UC1.AL10 ; v2(211.54,30.15) 212.09,30.7 UH1.AA5 ; UC1.BN20 v2(129.56,95.66) UC1.BN19 ; v2(205.21,30.26) 205.6,30.65 UH1.AA19 ; v2(205.21,30.26) 205.52,29.96 205.6,29.87 UH1.AB19 ; v2(209.02,30.29) 209.02,30.99 UH1.Y12 ; UC1.BK13 130.83,90.9 ; 130.83,90.9 UC1.BK14 v2(130.86,91.72) ; UC1.BC12 136.07,89.68 136.19,89.8 136.79,89.8 UC1.BB12 137.03,89.8 137.7,89.8 UC1.BA12 ; v2(214.42,79.35) UG1.G5 v2(215.26,78.51) ; UC1.AJ38 v2(146.81,109.47) ; UC1.E35 165.24,107.19 v2(164.9,107.53) 164.59,107.84 UC1.F36 ; UH1.R12 208.94,33.81 v2(209.18,34.05) UH1.N12 v2(208.81,35.06) 209.08,35.47 v2(209.03,36.02) UH1.K11 UH1.J10 UH1.J9 ; UH1.R12 209.42,33.37 209.84,33.37 209.84,33.38 209.98,33.38 210.2,33.6 210.6,33.6 210.71,33.49 v2(211.14,33.49) UH1.T7 211.26,32.82 v2(211.77,32.82) UH1.T5 UH1.T4 ; UH1.T32 199,32.87 198.86,32.92 198.5,32.74 UH1.U33 198.21,32.15 198.22,32.09 v2(198.29,31.65) 198.29,31.3 UH1.Y33 ; JDIMM2.39 112.03,38.56 v2(112.22,38.76) ; UC1.AP12 142.97,89.34 142.92,89.34 v2(142.86,89.28) ; UC1.C27 v2(166.27,102.21) UC1.D28 ; UC1.C27 v2(166.92,101.42) ; UC1.BR38 v2(127.51,109.57) ; UC1.Y13 153.85,89.9 153.58,89.9 UC1.AA12 153.21,89.83 152.61,89.83 UC1.AC12 152.28,89.68 v2(151.99,89.39) 151.71,89.68 UC1.AD12 ; UC1.F17 v2(164.97,93.55) ; UH1.AT18 205.9,23.33 v2(206.41,23.32) 206.55,23.17 UH1.AT16 UH1.AR16 UH1.AN16 ; JHDD1.12 245.65,15.21 245.43,14.99 v2(244.68,14.99) ; PCV7.2 220.49,44.62 217.25,47.86 210.74,47.86 210.26,48.34 201.61,48.34 200.92,49.03 195.99,49.03 194.32,50.69 194.32,55.87 v2(194.91,56.46) ; UC1.P37 v2(159.4,108.82) UC1.P38 ; v2(130.98,102.79) UC1.BL29 v2(130.23,102.74) ; v2(130.98,102.79) 131.54,102.79 UC1.BJ29 ; v2(160.42,130.33) 160.35,130.39 PUA1.6 ; UH1.AH12 208.78,26.96 v2(208.78,26.61) ; v2(16.08,52.15) 16.07,52.13 DU2.8 ; UH1.BC15 v2(207.94,19.41) UH1.BC13 ; UC1.AC37 v2(152.32,108.82) UC1.AC38 v2(152.32,109.47) ; UC1.D24 UC1.C23 v2(166.92,98.27) ; v2(192.88,21.67) 193.37,20.9 UH1.BA44 ; UC1.BM35 130.01,106.96 130.43,106.96 UC1.BL35 ; v2(212.64,36.71) 212.56,36.63 UH1.J4 ; v2(130.23,102.74) UC1.BM28 UC1.BM27 ; v2(130.23,102.74) UC1.BM29 UC1.BN29 UC1.BP29 UC1.BR29 UC1.BT29 126.64,103.14 v2(126.55,103.05) ; v2(127.53,28.06) 127.53,28.19 127.78,28.43 JDIMM2.102 ; v2(166.92,93.55) UC1.C17 166.27,94.33 166.24,94.37 UC1.D18 ; v2(61.61,31.43) 61.55,31.38 JEDP1.2 ; v2(153.43,40.69) 153.77,41.03 JDIMM1.192 ; JIO1.24 v2(305.91,34.25) ; UC1.AL33 v2(146.02,106.22) UC1.AL34 v2(146.02,106.87) ; UC1.AJ37 v2(147.59,108.17) UC1.AH36 v2(148.38,107.52) UC1.AH35 v2(148.38,106.87) UC1.AH34 v2(148.38,106.22) UC1.AH33 ; UC1.BG37 v2(133.42,108.82) UC1.BG38 v2(133.42,109.47) ; v2(311.63,20.02) 311.31,20.35 JWLAN1.18 ; v2(212.12,31.21) 212.25,31.33 212.25,31.56 UH1.V4 ; UH1.BC31 199.68,19.45 v2(199.28,19.32) ; UH1.AR38 v2(196.06,24.15) UH1.AN38 ; UG1.F7 v2(216.16,80.27) ; UC1.U37 v2(157.04,108.82) UC1.U38 v2(157.04,109.47) ; v2(192.32,28) 192.44,28.12 UH1.AE46 UH1.AC46 ; v2(227.06,60.94) 226.51,60.94 PCV18.2 ; UC1.BJ34 v2(131.85,106.22) UC1.BJ33 UC1.BL33 ; UC1.F4 UC1.E4 UC1.D3 166.5,83.82 v2(166.64,84.02) ; UC1.F4 UC1.F5 UC1.G6 UC1.J7 ; UG1.AJ7 196.43,80.67 v2(196.02,80.26) 195.59,80.69 UG1.AK7 ; UH1.F3 213.69,38.69 v2(213.61,38.86) ; UG1.AN25 UG1.AM25 ; v2(126.48,108.06) 126.7,107.83 UC1.BT36 UC1.BR36 ; UC1.J33 v2(163.38,105.57) UC1.J32 v2(163.38,104.88) UC1.H32 ; v2(199.98,24.01) 200.39,23.6 200.49,23.5 UH1.AT29 ; v2(162.74,84.13) UC1.K3 162.39,83.76 162.39,83.23 UC1.K2 v2(162.74,82.82) UC1.K1 ; v2(162.74,84.13) UC1.K4 ; UC1.BJ32 131.21,105.04 v2(131.06,104.92) UC1.BJ31 ; UC1.N33 v2(160.19,106.22) UC1.N34 v2(160.19,106.87) ; UH1.N37 196.82,34.94 v2(196.59,35.16) ; UC1.D22 166.27,97.48 UC1.C21 v2(166.92,96.7) ; v2(128.26,88.57) 128.26,88.5 UC1.BR9 ; UH1.AL37 UH1.AL38 v2(196.08,25.26) ; UH1.M24 202.85,34.7 v2(202.46,34.7) ; v2(201.35,27.21) 201.39,27.21 UH1.AG27 ; v2(201.35,27.21) 201.29,27.21 UH1.AG28 ; v2(201.35,27.21) 200.95,26.82 ; 215.26,76.14 215.26,75.33 v2(215.46,75.12) ; UC1.J18 162.73,94.64 163.24,94.64 UC1.H18 163.38,94.64 163.94,94.64 UC1.G18 v2(164.32,95.12) UC1.F19 v2(164.32,95.91) UC1.G20 ; UH1.T4 UH1.R3 ; UH1.T4 UH1.R4 UH1.P4 v2(212.64,34.62) 212.56,34.75 UH1.M5 ; UC1.V12 v2(155.67,89.37) UC1.W12 ; UG1.T2 207.42,76.45 v2(207.42,75.82) ; v2(204,34.44) 204,34.44 204,33.59 203.1,32.69 UH1.U24 ; v2(196.95,76.94) 197.33,76.56 UG1.AH2 ; JEDP1.12 66.55,31.25 66.86,31.56 v2(66.86,31.6) 67.05,31.41 JEDP1.13 ; v2(202.45,34.1) 202.45,34.05 201.92,33.52 UH1.R26 ; UC1.J7 163.27,86.43 UC1.K7 162.54,86.61 162.54,86.97 UC1.K8 ; UC1.BP26 UC1.BR26 UC1.BT26 126.82,100.78 v2(126.6,100.56) ; v2(192.48,83.09) 192.49,83.11 192.49,83.11 192.58,83.19 UG1.AN10 ; v2(216.98,80.27) 216.58,80.67 UG1.E7 ; UH1.AG27 201.33,27.94 ; JDIMM2.44 113.28,30.18 113.87,30.78 v2(113.87,31.01) ; v2(130.86,91.72) UC1.BL14 ; v2(130.86,91.72) UC1.BK15 ; v2(166.64,84.02) 166.84,83.86 UC1.B3 ; UH1.AT21 204.58,23.27 v2(204.98,23.27) ; UC1.C5 v2(166.96,85.66) ; UC1.BM25 v2(130.21,100.38) UC1.BM26 ; UC1.G16 v2(164.32,92.76) ; UG4.A3 215.4,121.39 v2(215.8,121) ; UC1.K11 v2(162.84,88.73) ; v2(162.84,88.73) UC1.H11 ; v2(162.84,88.73) UC1.J10 ; JIO1.9 v2(305.82,41.75) ; UC1.T33 v2(157.83,106.22) UC1.T34 v2(157.83,106.87) ; v2(131.06,107.52) UC1.BJ36 ; v2(131.06,107.52) UC1.BL35 ; v2(131.06,107.52) UC1.BJ35 ; JDIMM2.86 123.78,30.42 v2(124.11,30.76) ; JWLAN1.37 304.54,13.6 v2(304.98,14.04) ; UC1.A6 168.58,86.06 v2(168.71,86.19) ; UG7.N12 238.64,101.69 v2(238.24,102.09) ; US2.14 22.05,80.44 22.41,80.08 v2(22.99,80.08) ; UC1.BD37 v2(135.78,108.82) UC1.BD38 v2(135.78,109.47) ; v2(196.17,27.8) UH1.AE38 ; v2(166.92,90.4) UC1.C13 166.27,91.18 UC1.D14 ; UC1.J22 162.76,97.76 163.22,97.76 UC1.H22 163.38,97.79 163.94,97.79 UC1.G22 v2(164.32,97.48) UC1.F21 v2(164.97,96.7) ; v2(207.27,21.01) UH1.BA14 ; UH1.E24 v2(203.61,38.73) 204.09,38.45 UH1.E22 ; UG1.M18 212.32,89.94 v2(212.42,90.03) ; 210.33,36.68 210.84,37.03 UH1.H8 211.32,37 UH1.G6 ; UH1.AJ28 200.95,26.82 ; UH1.AJ28 200.6,26.42 v2(200.6,26.34) 200.18,26.77 UH1.AJ30 200.24,26.78 v2(200.64,27.17) ; JDIMM1.168 147.77,43.59 147.5,43.86 v2(146.77,43.86) ; v2(212.75,76.96) UG1.K2 ; UC1.L33 v2(161.77,106.22) UC1.L34 ; 201.33,27.94 UH1.AF28 ; 201.33,27.94 200.95,27.56 UH1.AG28 ; PUZ5.6 130.12,132.49 v2(130.13,132.48) ; UH1.AT26 202.16,23.27 v2(202.52,23.63) ; v2(154.68,109.47) UC1.Y38 v2(154.68,108.82) UC1.Y37 ; UH1.AG28 200.95,27.48 v2(200.64,27.17) ; UC1.D20 165.97,96.28 UC1.C19 v2(166.27,95.12) ; UC1.H12 UC1.G12 UC1.F13 v2(164.32,91.18) UC1.G14 v2(164.32,91.97) UC1.F15 v2(164.97,91.97) ; QG17.4 v2(235.19,39.6) 234.94,39.84 CG197.1 ; UC1.D30 v2(166.27,103.78) UC1.C29 ; v2(126.78,89.97) 126.99,89.75 UC1.BT12 UC1.BR12 UC1.BP12 UC1.BN12 ; UH1.AP4 v2(212.08,24.21) ; v2(143.66,104.22) UC1.AN30 v2(144.44,104.22) ; UG1.AB7 202.31,80.64 202.13,80.83 v2(201.89,81.06) ; PUH1.18 v2(184.61,105.33) ; UC1.W33 v2(155.47,106.22) UC1.W34 v2(155.47,106.87) ; UC1.G28 UC1.F27 v2(164.97,101.42) ; v2(199.72,26.41) 199.65,26.35 199.65,26.29 199.4,26.03 UH1.AK31 199.26,25.5 UH1.AM32 ; v2(199.72,26.41) 199.72,26.46 UH1.AJ31 v2(199.11,26.39) ; v2(199.72,26.41) 199.97,26.15 200.02,26.15 UH1.AK30 200.39,25.68 UH1.AL29 ; v2(61.11,31.69) 61.05,31.63 JEDP1.1 ; UH1.BC40 195.07,19.5 v2(194.78,19.46) ; UG6.K14 v2(242.64,68.47) ; UC1.BP33 UC1.BN31 v2(128.92,104.32) UC1.BN30 ; v2(143.77,89.39) 144.05,89.68 UC1.AN12 144.34,89.8 145.02,89.8 UC1.AM12 UC1.AL12 ; v2(304.35,11.78) 303.99,11.78 303.68,12.1 JWLAN1.43 ; UH1.BA12 v2(209.41,20.77) ; v2(202.42,75.87) 202.33,75.97 UG1.AB2 ; UC1.AF12 v2(150.17,89.89) UC1.AF13 ; UC1.A26 v2(167.58,101.41) ; UC1.BN34 128.96,105.96 v2(128.91,105.9) UC1.BP34 UC1.BR34 ; v2(213.49,41.16) 213.96,40.69 UH1.A2 UH1.A3 UH1.A4 UH1.A5 ; v2(207.09,32.92) 207.39,32.61 UH1.U15 UH1.U17 206.63,32.46 UH1.T17 UH1.T18 UH1.V20 v2(204.44,31.81) 204.37,31.88 UH1.V22 204.51,32.66 UH1.U21 ; v2(131.06,106.87) UC1.BL35 ; v2(196.77,87.91) 197,87.91 UG1.AH16 ; UH1.AE12 v2(208.83,29.03) ; UH1.BC35 197.37,19.38 v2(196.99,19.38) ; v2(196.1,26.35) UH1.AH38 ; UG5.A1 v2(197.15,133.8) ; 200.95,26.82 200.64,27.13 v2(200.64,27.17) ; UH1.BF49 190.55,18.05 190.51,17.84 190.48,17.7 v2(190.63,17.47) ; 166.32,87.98 UC1.D9 ; 166.32,87.98 UC1.D10 ; UG1.G7 214.88,80.73 v2(215.2,81.05) ; UH1.AW10 UH1.AV11 v2(208.84,22.95) 208.8,22.99 208.8,23.51 UH1.AR12 ; UH1.BC19 205.28,19.77 205.59,20.09 v2(205.59,20.32) ; v2(163.7,101.4) UC1.G26 ; v2(194.9,21.96) 195.06,22.12 UH1.AV39 UH1.AW40 ; UC1.AJ13 v2(147.41,90) ; UH1.AG30 200.26,27.55 v2(200.64,27.17) ; PU1001.18 235.47,27.14 v2(235.43,27.1) ; UC1.F25 v2(164.97,99.84) ; v2(140.51,109.47) UC1.AV38 v2(140.51,108.82) UC1.AV37 ; v2(145.23,109.47) UC1.AM38 v2(145.23,108.82) UC1.AM37 ; JHDD1.6 248.65,15.41 247.75,14.51 v2(247.75,12.94) ; UG1.N2 209.43,76.94 v2(209.32,76.94) ; v2(304.91,23.31) 304.69,23.1 JWLAN1.7 ; v2(135.55,89.34) 135.55,89.38 135.38,89.38 UC1.BD12 134.96,89.8 134.28,89.8 UC1.BF12 ; v2(195.76,33.93) 196.06,33.63 UH1.R38 196.06,32.89 v2(196.08,32.87) UH1.U38 ; v2(305.96,37.36) 306.07,37.25 JIO1.18 ; UC1.L29 v2(161.77,103.57) UC1.L30 ; UC1.AF14 UC1.AG13 v2(148.33,90) UC1.AH12 ; JDIMM1.243 166.52,48.87 165.93,48.28 v2(165.87,48.28) ; UC1.BJ14 v2(131.51,91.74) UC1.BJ15 ; UC1.A28 v2(168.35,102.82) 168.56,103.02 168.56,103.72 UC1.A30 ; UC1.J36 v2(163.34,108.17) ; UC1.BJ12 v2(131.91,89.37) ; v2(136.57,106.87) UC1.BC34 v2(136.57,106.22) UC1.BC33 ; v2(198.46,27.77) UH1.AE33 ; UH1.BC24 203.11,19.5 203.52,19.47 v2(203.68,19.46) ; UC1.BJ22 v2(131.53,98.02) UC1.BK22 ; UC1.D16 166.27,92.76 UC1.C15 v2(166.92,91.97) ; v2(138.26,90.02) 138.26,90.14 138.27,90.14 138.27,90.51 UC1.AY14 ; v2(212.12,26.1) 212.12,26.1 212.12,26.1 212.54,26.33 UH1.AK4 ; JIO1.21 306.19,35.75 306.05,35.61 v2(305.62,35.61) ; v2(19.77,83.34) 19.91,83.48 CS109.2 ; v2(217.33,102.99) 217.33,103.49 217.34,103.5 217.34,103.88 217.33,103.89 217.33,103.89 v2(216.88,104.34) ; UH1.D33 198.69,38.47 UH1.E33 198.94,38.45 v2(199.24,38.44) UH1.E31 199.96,38.68 UH1.D30 UH1.C30 ; UC1.BF33 v2(134.21,106.22) UC1.BF34 v2(134.21,106.87) ; UG1.AN19 UG1.AM19 ; UH1.E35 v2(197.09,38.73) ; UH1.AM49 v2(190.12,25.23) ; UC1.BA37 v2(138.14,108.82) UC1.BA38 v2(138.14,109.47) ; v2(145.58,91.3) UC1.AL14 ; DU2.3 13.23,52.13 v2(12.86,52.5)
  BOTTOM w0.3: v2(211.91,103.54) 212.39,103.06 212.39,102.54 212.33,102.49 UG1.K33
  BOTTOM w0.305: v2(200.56,31.04) UH1.W28 v2(201.34,31.04) ; v2(200.56,31.04) 200.39,31.21 UH1.W30 ; v2(200.56,31.04) UH1.AA28 v2(201.34,31.04) ; v2(200.56,31.04) 200.39,30.86 UH1.AA30 200.06,30.53 v2(199.79,30.26) ; v2(115.16,40.66) 115.14,40.66 114.77,41.03 JDIMM1.44 ; JDIMM1.251 168.52,48.77 v2(168.96,48.34) ; JDIMM2.69 119.53,38.47 119.22,38.77 v2(119.22,38.77) ; JDIMM1.235 164.52,51.26 164.86,51.6 v2(164.93,51.6) 164.93,51.6 165.25,51.6 165.52,51.33 JDIMM1.239 ; v2(113.09,51.99) 112.53,51.43 JDIMM1.35 ; JDIMM2.51 115.03,38.64 v2(115.16,38.78) ; v2(35.54,10.39) 35.35,10.2 JSSD1.3 ; v2(117.36,30.61) 117.28,30.53 JDIMM2.60 ; JDIMM1.172 148.77,43.24 149.81,44.28 v2(149.94,44.28) ; v2(129.62,47.39) 129.55,47.39 128.53,48.42 JDIMM1.99 ; v2(153.43,40.69) 154.39,40.69 154.77,41.08 JDIMM1.196 ; JDIMM1.22 109.27,40.79 v2(109.42,40.65) ; JDIMM1.180 150.77,43.92 v2(151.91,45.05) ; JSSD1.9 v2(33.85,8.2) ; v2(123.53,35.2) 123.27,35.2 122.53,35.95 JDIMM2.81 ; v2(246.64,92.29) UG7.C1 v2(247.04,93.29) ; v2(125.96,40.77) 125.58,40.77 125.27,41.08 JDIMM1.86 ; JSSD1.57 v2(21.85,8.2) ; JDIMM1.72 121.77,43.56 121.35,43.99 v2(121.09,43.99) ; JDIMM2.222 159.78,30.44 v2(159.47,30.75) ; JDIMM2.27 109.03,38.44 v2(109.42,38.83) ; v2(219.38,93.62) 218.98,93.21 UG1.B22 ; v2(195.18,83.57) 195.2,83.57 UG1.AK10 ; v2(156.81,52.11) 157.42,52.11 158.02,51.5 JDIMM1.209 ; UG7.H2 v2(242.24,93.29) 242.64,92.89 UG7.H1 242.64,92.39 v2(242.54,92.29) v2(242.54,91.69) ; JDIMM2.209 156.53,36.47 v2(156.95,36.05) ; v2(128.56,27.98) 128.78,28.19 JDIMM2.106 ; v2(165.09,30.66) 165.28,30.47 JDIMM2.244 ; v2(113.87,36.09) 114.03,36.24 JDIMM2.47 ; JDIMM2.239 164.03,39.02 v2(163.58,39.47) 163.03,38.91 JDIMM2.235 ; JDIMM1.227 162.52,49.42 163.38,48.56 v2(163.68,48.56) ; v2(202.11,31.04) UH1.W27 v2(201.34,31.04) ; v2(202.11,31.04) UH1.AA27 ; v2(202.11,31.04) UH1.AA25 ; v2(202.11,31.04) UH1.W25 v2(202.89,31.04) UH1.AA25 ; v2(151.08,34.57) 150.91,34.57 149.53,35.95 JDIMM2.181 ; JDIMM2.5 103.53,36.51 103.16,36.15 103.16,35.59 102.71,35.14 v2(101.94,35.14) ; v2(221.4,125) UG4.F10 221,125.4 v2(221.4,125.8) UG4.G10 ; UG7.H14 v2(242.64,103.89) v2(242.64,104.49) ; v2(113.09,53.16) 113.28,53.16 114.53,51.91 JDIMM1.43 ; v2(125.96,46.76) 126.3,46.76 127.02,47.49 JDIMM1.93 ; v2(248.24,103.89) v2(248.24,104.49) ; v2(248.24,103.89) UG7.A14 ; v2(248.24,103.89) v2(249.04,103.89) ; v2(125.97,48.16) 126.02,48.21 JDIMM1.89 ; JDIMM2.82 122.78,30.14 122.64,30.27 122.64,31.08 123.08,31.52 v2(123.12,31.52) ; JDIMM2.99 127.03,36.55 126.69,36.22 v2(126.32,36.22) ; v2(104.66,43.64) 105.27,43.02 JDIMM1.6 ; v2(125.96,38.89) 125.94,38.89 125.53,38.47 JDIMM2.93 ; v2(148.03,35.96) JDIMM2.175 ; UG7.L5 240.24,96.09 239.91,96.42 v2(239.84,96.49) UG7.M5 239.44,96.09 v2(239.04,96.49) ; v2(149.84,39.6) 149.32,40.12 149.32,40.76 149.77,41.22 JDIMM1.176 ; JDIMM2.227 161.03,36.47 162.09,35.41 v2(162.38,35.41) ; JDIMM2.22 107.78,30.36 107.22,30.91 v2(107.09,30.91) ; UH1.AA27 v2(201.34,31.04) ; UH1.AA27 v2(202.11,30.26) UH1.AA25 ; v2(216.6,130.6) UG4.M5 v2(217.4,129.8) UG4.L5 ; JDIMM1.201 156.02,51.23 156.34,51.55 v2(156.81,51.55) 157.02,51.34 JDIMM1.205 157.02,48.56 158.09,47.49 v2(158.18,47.49) ; JDIMM2.43 113.03,36.43 111.92,35.33 v2(111.84,35.33) ; v2(104.74,40.73) 104.27,41.19 JDIMM1.2 ; v2(119.22,47.65) 119.01,47.65 118.02,48.63 JDIMM1.57 ; v2(155.06,27.98) 154.93,27.98 154.78,28.14 JDIMM2.202 ; JDIMM1.77 123.02,51.26 123.25,51.49 v2(124.52,51.49) ; v2(151.97,36.01) 151.92,36.01 151.53,36.41 JDIMM2.189 ; v2(126.32,35.58) 126.94,35.58 128.03,36.67 JDIMM2.103 ; v2(247.04,94.09) 247.04,94.09 UG7.C3 v2(246.24,94.89) 246.24,94.89 UG7.C4 v2(247.04,95.69) 247.04,95.69 UG7.B5 ; UG7.N1 238.64,92.88 v2(238.64,92.29) v2(238.64,91.69) ; v2(126.81,87.08) 127.21,87.08 UC1.BT8 ; UG4.K14 v2(224.8,128.6) v2(225.4,128.6) ; UG5.L10 190.35,126.2 v2(189.95,125.8) UG5.M10 190.35,125.4 v2(189.95,125) ; JDIMM1.98 128.27,43.21 128.37,43.3 v2(128.37,43.35) ; v2(149.94,48.41) 149.52,48.83 JDIMM1.175 ; v2(163.68,45.44) 163.66,45.41 162.95,45.41 161.28,43.74 JDIMM1.222 ; JDIMM2.30 109.78,30.57 v2(109.92,30.71) ; v2(104.53,36.27) 104.53,36.27 JDIMM2.9 ; UG4.H14 224.19,127 v2(223.8,126.6) 223.4,126.99 UG4.H13 v2(223,127.4) ; JDIMM2.206 155.78,30.46 156.11,30.8 v2(156.11,30.89) ; v2(192.62,78.44) 192.87,78.19 UG1.AN4 ; UG1.N5 209.83,79.42 v2(210.03,79.63) ; JDIMM2.68 119.28,30.43 119.26,30.45 119.26,30.87 119.26,30.87 119.26,30.88 119.65,31.26 v2(119.75,31.26) ; v2(195.22,76.93) UG1.AL2 ; JDIMM1.234 164.28,41.22 163.75,40.69 v2(163.58,40.69) 163.28,41 JDIMM1.230 ; v2(167.98,31.52) 167.28,30.82 JDIMM2.252 ; JDIMM1.107 130.53,51.39 131.43,52.3 v2(131.45,52.3) ; UG1.K7 212.72,80.25 v2(212.72,79.34) ; v2(215,127.4) UG4.H2 v2(214.2,126.6) UG4.H1 213.29,127 v2(213.2,126.9) ; JDIMM1.102 129.27,44.89 ; v2(301.72,5.21) 301.72,5.72 302.09,6.1 JWLAN1.67 ; v2(152.95,27.98) 153.28,28.31 JDIMM2.196 ; JDIMM1.56 117.77,43.03 117.48,43.32 v2(117.48,43.36) ; v2(125.97,44.27) 125.53,44.27 124.27,43.01 JDIMM1.82 ; v2(192.49,75.9) 192.68,75.72 193.16,75.72 UG1.AN1 ; UG1.T17 207.58,88.92 v2(208.05,88.45) ; JWLAN1.25 303.93,16.6 v2(304.3,16.96) ; UG5.H14 186.57,128.6 v2(186.57,128.6) ; v2(108.04,38.77) 108.03,38.76 JDIMM2.23 ; JDIMM1.64 119.77,44.19 119.37,44.6 v2(119.21,44.6) ; v2(27.89,8.22) 27.85,8.26 JSSD1.33 ; JDIMM2.184 150.28,28.28 150.06,28.07 v2(148.87,28.07) ; v2(163.97,30.66) 163.78,30.46 JDIMM2.238 ; JDIMM1.60 118.77,41.1 v2(119.22,40.66) 119.23,40.66 119.49,40.41 120.45,40.41 120.77,40.73 JDIMM1.68 ; JDIMM2.218 v2(158.78,27.99) ; v2(30.93,8.18) 30.85,8.26 JSSD1.21 ; JDIMM1.39 113.53,49 112.79,48.26 v2(112.22,48.26) ; UG4.L10 v2(220.6,129.8) 220.99,130.2 UG4.M10 v2(221.4,130.6) ; JDIMM2.14 v2(105.78,28.07) ; v2(199.79,30.26) 199.52,30.53 UH1.AA31 ; v2(199.79,30.26) UH1.AB31 ; v2(248.64,94.89) UG7.A3 v2(247.84,94.09) ; JDIMM2.73 120.53,38.5 120.48,38.55 120.48,39.01 v2(120.99,39.52) 121.53,38.98 JDIMM2.77 ; UG7.L10 240.24,100.09 v2(239.84,100.49) UG7.M10 v2(239.04,100.49) ; v2(130.57,43.24) 130.44,43.24 130.27,43.07 JDIMM1.106 ; v2(115.16,44.81) 115.04,44.81 114.08,43.85 114.08,43.25 113.77,42.95 JDIMM1.40 ; JDIMM2.52 115.28,31.14 v2(115.91,31.77) ; v2(112.16,43.74) 111.64,43.74 111.27,43.38 JDIMM1.30 ; v2(158.13,40.86) 158.28,41 JDIMM1.210 ; JDIMM1.252 168.77,41.22 168.31,40.75 v2(168.01,40.75) 167.77,40.99 JDIMM1.248 ; v2(112.16,39.47) 111.03,38.34 JDIMM2.35 ; v2(163.73,51.43) 163.52,51.22 JDIMM1.231 ; JDIMM1.103 129.53,49.27 129.62,49.17 v2(129.62,48.66) ; JDIMM2.226 v2(160.78,30.66) ; UG7.B5 v2(247.84,95.69) ; UG7.B5 v2(247.84,96.49) ; JDIMM2.72 120.28,32.2 121.12,33.04 v2(121.39,33.04) ; v2(24.9,8.22) 24.85,8.27 JSSD1.45 ; JDIMM2.214 157.78,28.39 158.12,28.04 v2(158.12,27.99) ; JWLAN1.31 301.92,15.1 301.48,14.65 v2(301.48,14.37) ; v2(236.64,96.49) 236.24,96.09 UG7.T5 236.24,96.09 v2(235.82,96.51) ; JDIMM1.223 161.52,49.26 162.21,48.58 162.21,47.88 162.74,47.34 v2(163.68,47.34) ; JSSD1.39 26.35,8.34 v2(26.2,8.19) ; UG5.H13 v2(188.35,128.2) ; JDIMM2.1 102.53,36.66 102.22,36.36 v2(101.94,36.36) ; JDIMM1.73 122.02,47.78 121.72,47.48 v2(121.09,47.48) ; JDIMM2.188 151.28,28.2 151.49,27.99 151.94,27.99 v2(151.94,27.99) ; UG5.K14 187.15,127 v2(187.55,126.6) 187.95,127 UG5.K13 v2(188.35,127.4) ; JSSD1.51 23.35,8.32 v2(23.26,8.23) ; v2(112.22,47.01) 112.08,47.01 111.53,47.57 JDIMM1.31 ; JDIMM1.85 125.02,51.24 125.09,51.31 125.09,52.33 124.67,52.76 v2(124.52,52.76) ; JDIMM1.52 116.77,40.78 117.33,40.23 v2(117.48,40.23) ; RH153.1 199.42,13.59 v2(199.47,13.54) ; JDIMM1.26 110.27,43.6 109.68,44.19 v2(109.38,44.19) ; JDIMM1.214 159.28,40.7 v2(159.83,40.14) 159.83,40.75 160.28,41.2 JDIMM1.218 ; v2(192.65,80.48) 192.86,80.69 UG1.AN7 ; JDIMM2.98 126.78,30.21 126.08,30.91 v2(125.69,30.91) 125.78,30.82 JDIMM2.94 ; v2(159.19,39.28) 159.25,39.28 160.03,38.51 JDIMM2.223 ; v2(240.94,92.29) 241.04,92.39 UG7.K1 241.04,92.89 v2(240.64,93.29) UG7.K2 v2(241.44,94.09) ; v2(105.67,45.16) 106.15,45.16 106.78,44.54 106.78,43.4 106.27,42.89 JDIMM1.10 ; v2(223,128.2) 223.39,128.6 UG4.K13 ; JDIMM2.193 152.53,38.33 152.16,38.7 v2(152.16,38.87) ; JDIMM2.19 107.03,38.44 108.05,39.46 v2(108.07,39.46) ; JDIMM1.23 109.53,51.49 108.93,52.09 v2(107.9,52.09) ; v2(217.42,124.2) 217.59,124.2 218.04,123.75 218.04,122.89 217.34,122.19 UG4.B5 ; JDIMM2.6 103.78,32.11 104.07,32.41 v2(104.61,32.41) ; JDIMM2.185 150.53,38.4 150.22,38.7 v2(149.85,38.7) ; JDIMM1.9 106.02,48.94 v2(105.62,48.54) ; JDIMM1.238 165.28,43.75 v2(165.87,44.35) ; JDIMM2.56 116.28,30.87 117.38,31.98 v2(117.67,31.98) ; v2(162.62,31.29) 162.78,31.14 JDIMM2.234 ; v2(119.21,46.07) 119.26,46.12 119.41,46.12 120.15,46.86 120.15,49.18 120.02,49.3 JDIMM1.65 ; RH200.2 195.13,13.99 v2(194.89,13.75) 194.51,14.13 RH11.2 ; JDIMM1.185 152.02,51.08 v2(152.5,51.56) 152.55,51.56 153.02,51.09 JDIMM1.189 ; JDIMM1.69 121.02,48.89 v2(121.09,48.83) ; v2(105.62,38.76) 105.72,38.76 106.03,38.45 JDIMM2.15 ; JWLAN1.1 303.75,24.6 v2(303.97,24.38) ; v2(119.22,48.83) 119.22,48.84 119.02,49.03 JDIMM1.61 ; JDIMM2.201 154.53,39.2 153.94,39.79 v2(153.43,39.79) 153.28,39.79 152.92,39.43 152.92,38.94 153.53,38.34 JDIMM2.197 ; v2(124.7,30.73) 124.7,30.73 124.78,30.65 JDIMM2.90 ; JDIMM1.206 157.28,40.92 v2(157.73,40.46) ; JDIMM2.210 156.78,30.23 v2(157.34,30.79) ; UH1.AC17 v2(206.54,30.32) 206.54,31.1 UH1.Y17 ; JDIMM2.205 155.53,38.62 155.92,39.01 v2(156.87,39.01) 157.22,39.01 157.53,38.71 JDIMM2.213 ; UG1.AH5 196.88,79.39 196.88,80.24 UG1.AH7 v2(196.86,81.07) 196.81,81.07 UG1.AJ7 ; v2(189.95,123.4) 189.55,123 UG5.R11 189.55,122.99 v2(189.15,122.6) ; v2(124.32,44.45) 124.05,44.45 123.27,43.67 JDIMM1.78 ; UG7.C11 v2(247.04,100.49) UG7.B10 v2(247.84,99.69) ; JDIMM2.180 149.28,30.47 v2(149.43,30.63) ; v2(112.32,30.55) 112.28,30.51 JDIMM2.40 ; v2(148.04,30.88) 148.28,30.64 JDIMM2.176 ; v2(189.95,130.6) 189.95,130.6 UG5.F10 v2(190.75,129.8) UG5.G10 ; JSSD1.27 29.35,8.27 29.27,8.2 v2(29.26,8.2) ; UG1.AB5 202.42,78.94 v2(202.8,78.56) ; v2(146.76,48.92) 147.15,48.92 147.52,49.3 JDIMM1.167 ; UG1.AE7 199.83,80.18 v2(199.96,80.05) ; v2(149.94,47.14) 149.79,47.14 148.52,48.4 JDIMM1.171 ; UG7.U3 v2(235.04,94.09) ; v2(117.48,44.55) 117.25,44.55 115.77,43.07 JDIMM1.48 ; JDIMM1.94 127.27,40.78 126.48,39.98 v2(125.96,39.98) ; v2(118.32,30.61) 118.28,30.56 JDIMM2.64 ; v2(235.84,93.29) UG7.U1 235.44,92.88 v2(235.44,92.29) ; JDIMM2.248 166.28,30.61 v2(166.2,30.68) ; JDIMM1.181 151.02,51.08 152.06,52.12 v2(152.5,52.12) ; UH1.AD19 v2(205.95,29.46) ; UG4.K2 UG4.K1 213.3,128.6 v2(213.2,128.7) v2(212.6,128.7) ; JDIMM2.247 166.03,38.59 v2(166.29,38.85) ; v2(248.24,92.29) UG7.A1 ; v2(248.24,92.29) v2(248.24,91.69) ; v2(248.24,92.29) v2(249.04,92.29) ; v2(124.32,47.93) 124.02,48.17 JDIMM1.81 ; v2(103.04,48.12) 103.9,48.12 105.02,49.25 JDIMM1.5 ; v2(108.11,40.66) 107.78,40.66 107.27,41.17 JDIMM1.14 ; JDIMM1.202 156.28,43.07 v2(156.79,43.58) ; JDIMM1.19 108.53,48.55 108.13,48.16 v2(107.9,48.16) ; UG7.N3 238.64,94.49 v2(239.04,94.09) ; v2(236.64,101.29) 237.04,100.89 UG7.R11 237.04,100.89 v2(237.44,100.49) ; v2(243.84,100.49) UG7.G10 v2(243.84,99.69) UG7.F10 v2(244.64,100.49) ; v2(212.42,89.4) 212.42,89.35 212.01,88.94 UG1.M17 ; v2(119.22,39.42) 118.95,39.42 118.53,38.99 JDIMM2.65 ; JDIMM2.36 111.28,30.16 111.39,30.28 111.39,32.28 v2(110.34,33.33) ; JDIMM2.231 162.03,38.61 161.02,39.61 v2(159.64,39.61) ; v2(167.88,43.93) 167.69,43.93 166.77,43.02 JDIMM1.244 ; v2(147.1,36.24) 147.03,36.31 JDIMM2.171 ; JSSD1.15 v2(32.35,8.2) ; v2(104.7,30.92) 104.78,30.84 JDIMM2.10 ; PRZ24.2 175.1,129.5 v2(175.37,129.23) ; JDIMM2.85 123.53,38.79 123.83,39.09 v2(124.51,39.09) 124.53,39.08 JDIMM2.89 ; JDIMM1.51 116.53,48.3 117.45,47.37 v2(117.48,47.37) ; UG1.AH13 196.96,85.37 v2(196.56,85.37) ; v2(152.16,40.8) 152.47,40.8 152.77,41.11 JDIMM1.188 ; v2(115.16,48.07) 115.27,48.07 115.67,48.47 115.67,49.16 115.53,49.31 JDIMM1.47 ; JDIMM2.251 167.03,39.14 166.72,39.45 v2(166.29,39.45) 165.79,39.45 165.03,38.68 JDIMM2.243 ; UC1.D38 165.82,109.54 v2(165.38,109.99) 165.02,109.63 UC1.E38 ; JDIMM2.107 129.03,38.56 129.96,39.5 v2(131.76,39.5) ; v2(107.88,51.48) 107.83,51.48 107.53,51.18 JDIMM1.15 ; UG7.K14 v2(240.64,102.89) UG7.K13 v2(241.44,102.09) ; v2(245.44,93.29) UG7.E1 245.04,92.89 v2(245.04,92.29) ; JDIMM2.57 116.53,38.51 116.83,38.81 v2(117.48,38.81) 117.48,38.79 117.51,38.76 117.51,38.59 117.53,38.57 JDIMM2.61 ; JPWR1.7 8.87,127.21 v2(8.87,127.22) ; JDIMM1.226 162.28,43.08 163.39,44.19 v2(163.68,44.19) ; JDIMM2.31 110.03,36.39 109.01,35.37 v2(108.65,35.37) ; UH1.J9 210.33,36.68 v2(210.73,36.28) ; JSSD1.1 35.85,10.01 v2(36.17,10.34) ; JDIMM1.1 104.02,49.68 103.72,49.38 v2(103.04,49.38) ; v2(202.46,34.7) 202.27,34.7 201.92,34.35 UH1.P26 ; JDIMM1.36 112.77,41.09 112.45,40.76 112.25,40.76 v2(112.2,40.71) ; JDIMM1.213 159.02,49.34 159.92,48.45 v2(160.39,48.45) 160.39,48.88 160.02,49.24 JDIMM1.217 ; UH1.J29 199.97,36.52 v2(199.6,36.89) ; v2(108.78,30.7) JDIMM2.26 ; JDIMM2.2 v2(102.78,30.53) ; v2(146.13,30.63) 146.28,30.49 JDIMM2.168 ; UG7.H13 v2(242.24,102.09) ; v2(128.36,43.97) 127.22,43.97 126.27,43.03 JDIMM1.90 ; JDIMM2.217 158.53,38.42 158.84,38.73 v2(159.06,38.73) ; JDIMM1.18 108.27,43.47 107.9,43.84 v2(107.9,44.22) ; v2(218.9,26.57) 218.64,26.31 RC391.2 ; UG1.K5 v2(212.73,78.54) ; JPWR1.8 13.14,127.44 ; JDIMM2.172 147.28,30.43 v2(147.16,30.55) ; UG7.E14 v2(244.64,102.89) ; v2(121.78,30.61) JDIMM2.78 ; v2(194.4,78.66) UG1.AL5
  BOTTOM w0.33: v2(114.7,28.01) 114.28,28.44 JDIMM2.48 ; v2(194.75,130.6) UG5.F5 194.35,130.2 v2(193.95,129.8) UG5.G5 ; v2(196.35,127.4) UG5.K2 v2(197.15,126.6) 197.55,127 UG5.K1 198.05,127 v2(198.15,126.9) v2(198.75,126.9) ; v2(198.75,128.58) v2(198.15,128.58) 197.57,128.58 UG5.H1 197.55,128.6 v2(197.15,128.2) UG5.H2 ; v2(193.95,125) 194.35,125.4 UG5.M5 v2(193.95,125.8) 194.35,126.2 UG5.L5
  BOTTOM w0.356: v2(209.14,87.33) UG1.R16 ; UG1.AM13 194.33,86.04 194.36,86.07 v2(194.36,86.17) 194.39,86.17 194.43,86.21 194.5,86.22 UG1.AL14 UG1.AL15 ; UG1.AM13 193.98,85.65 194.38,85.25 v2(194.38,85.2) 194.43,85.2 194.78,84.85 UG1.AL12 ; UG1.AM13 UG1.AN13 ; PCW14.2 PCW13.2 243.67,49.34 PCW12.2 243.66,49.04 243.43,48.8 242.65,48.8 v2(242.54,48.92) ; CR17.2 v2(40.21,21.84) ; v2(210.22,80.19) 210.22,80.25 UG1.N7 ; v2(196.86,92.65) 196.86,92.77 UG1.AH22 ; UG7.G5 v2(243.84,96.49) UG7.F5 244.64,95.69 v2(244.64,95.69) ; v2(216.98,96.12) UG1.E25 v2(216.06,95.87) ; UG1.V23 v2(206.08,94.44) UG1.U23 ; v2(241.44,70.27) UG6.H13 v2(240.64,69.47) 241.04,69.08 UG6.H14 ; v2(120.99,108.38) 120.55,108.38 CC406.2 ; CL11.2 v2(52.67,22.03) ; v2(195.16,96.16) UG1.AL26 ; v2(221.4,123.4) 221.8,123 UG4.C11 v2(222.2,122.6) ; v2(27.28,49.31) 27.18,49.21 RT858.2 27.18,48.55 RT857.2 RT818.2 RT817.2 ; UG1.AL21 UG1.AL20 v2(194.38,91.16) UG1.AM19 ; UG1.W17 204.08,89.44 UG1.W18 ; 243.78,72.73 243.78,72.62 UG6.L10 ; 243.78,72.73 UG6.M10 244.24,72.27 v2(244.64,71.87) ; 243.78,72.73 v2(243.78,72.76) ; v2(199.96,80.05) 199.68,79.77 199.69,79.08 UG1.AE5 ; v2(192.78,100.27) 192.74,100.31 192.03,100.31 v2(191.98,100.27) ; v2(201.02,87.39) UG1.AC15 ; UG6.K2 v2(243.04,79.07) UG6.K1 v2(242.64,80.07) ; UG1.AN16 UG1.AM16 193.98,88.26 v2(194.37,88.65) UG1.AL17 UG1.AL18 ; CL13.2 55.75,16.03 v2(56.27,16.03) ; UG1.AB23 v2(202.06,94.52) UG1.AA22 ; UG1.T20 v2(208.07,92.66) UG1.R21 ; UG1.W22 v2(204.08,94.44) UG1.Y23 ; v2(249.04,80.07) v2(248.24,80.07) ; v2(248.24,80.07) v2(248.24,80.67) ; v2(248.24,80.07) UG6.U1 ; UG1.AH10 197.09,83.38 v2(196.87,83.6) ; v2(59.52,21.71) CL9.2 ; UG1.N16 v2(210.98,87.54) ; UG1.AH19 v2(196.88,91.09) ; v2(234.84,80.07) 234.84,80.08 v2(234.84,80.67) ; CL26.2 55.07,24.12 54.83,24.36 v2(54.65,24.36) ; UG1.AN22 UG1.AM22 v2(194.34,93.6) 194.35,93.61 UG1.AL23 194.63,94.19 194.63,94.69 UG1.AL24 194.78,94.89 UG1.AM25 ; v2(189.67,13.69) 191.62,13.69 192.05,14.12 CH16.2 ; v2(197.72,83.6) 197.52,83.8 UG1.AH11 ; UG1.M15 v2(212.13,87.25) ; v2(196.84,95.34) 197.16,94.98 UG1.AH24 ; RT846.2 RT845.2 v2(25.72,47.74) ; CL16.2 v2(53.89,17) ; UG1.AC18 200.84,89.75 v2(201.12,89.54) 200.84,89.22 UG1.AC17 ; UG1.AC22 200.68,93.84 v2(201.05,93.48) UG1.AB21 ; UG1.N23 210.54,94.89 v2(210,94.31) 209.82,94.15 UG1.P22 ; UG1.W20 v2(204.08,92.44) UG1.Y21 ; UG1.G25 v2(214.52,95.28) ; CL12.2 v2(59.59,23.56) ; UG1.T5 v2(207.8,78.55)
  BOTTOM w0.381: v2(237.24,31.56) 237.43,31.37 PC1012.2 ; v2(254.03,31.3) 253.75,31.57 PR313.2 252.85,31.57 252.82,31.61 PC328.2 ; v2(242.64,80.67) 242.64,81.03 242.89,81.28 CG103.2 ; YH1.2 219.51,34.58 v2(219.63,34.7) ; v2(228.87,71.72) 229.54,71.05 CG193.2 ; v2(231.26,89.09) 231.26,89.62 CG36.2 ; v2(195.55,121) 195.95,121.39 UG5.U3 ; UG10.3 236.97,46.41 236.97,46.41 v2(236.97,46.75) ; v2(198.75,126.9) 199.57,126.9 CG168.2 ; v2(185.95,123) 184.94,123 CG146.2 ; v2(221.81,54.92) 222.14,55.24 PCV17.2 ; RG66.2 CG123.2 243.18,67.66 v2(242.97,67.88) 242.97,68.15 v2(242.64,68.47) ; CG190.2 220.92,115.94 v2(221.33,116.35) ; CG105.2 245.11,91.61 v2(245.04,91.69) ; v2(184.02,130.82) 184.02,131.56 QG3.3 ; CH65.1 v2(184.79,23.09) ; v2(62.25,23.93) 61.83,23.51 CU72.2 ; v2(235.44,68.47) 235.44,67.61 235.49,67.56 CG102.2 235.49,66.24 CG92.2 ; RG122.1 219.92,68.45 219.92,69.59 RG135.1 ; UG1.P20 v2(209.04,91.4) UG1.R19 ; v2(253.6,27) 253.23,26.63 PC310.2 ; CG340.2 237.77,64.39 v2(238.23,63.93) ; UG1.V19 205.58,90.89 205.97,90.5 v2(206.25,90.5) 206.58,90.84 UG1.U19 ; CG196.1 238.19,45.13 v2(238.19,45.69) ; v2(246.64,67.87) 246.74,67.78 CG107.2 ; v2(229.17,64.45) 229.17,64.32 228.7,63.85 RG133.1 ; CL3.2 34.73,42.75 34.73,42.23 v2(34.36,41.86) ; UG28.3 236.27,62.05 v2(236.59,62.37) ; D506.1 v2(66.31,28.08) ; PC1001.2 241.69,25.66 PR1005.2 241.69,24.59 v2(241.3,24.2) ; RG42.2 187.13,81.8 v2(186.76,81.8) ; UG8.3 184.12,79.13 184.36,79.36 v2(184.36,79.84) 183.76,79.84 183.28,79.36 CG46.2 ; CG167.2 v2(227.07,135.67) ; v2(229.23,93.54) 229.36,93.42 CG223.2 ; v2(212.6,123) 211.67,123 CG58.2 ; CG163.2 226.3,129.4 v2(225.4,129.4) v2(225.4,128.6) 225.98,128.6 226.09,128.7 CG89.2 RG52.2 ; v2(238.08,54.29) 238.35,54.01 PCW5.2 ; QG4.3 242,61.91 v2(241.59,61.49) ; UG5.B10 v2(190.75,133.8) ; R5216.1 v2(35.64,11.05) ; v2(190.63,17.47) 189.85,16.69 189.85,15.43 189.67,15.25 CH25.2 ; v2(59.52,21.71) 60.28,21.71 CL20.2 ; v2(16.95,115.09) DV1.3 v2(14.28,115.09) ; UG1.U21 v2(206.08,92.44) UG1.V21 ; CV18.2 72.06,25.36 v2(72.4,25.01) ; UC3.5 178.73,128.69 v2(178.85,128.8) ; v2(212.6,134.2) 212.13,134.66 CG147.2 ; CG337.2 244.61,38.99 245.01,38.6 v2(245.38,38.6) 245.38,39.08 CG269.2 ; CG67.2 211.56,128.7 v2(212.6,128.7) ; v2(235.44,80.67) 235.46,80.69 235.46,81.1 235.31,81.25 CG110.2 ; UG1.T17 207.8,89.16 208.08,89.44 UG1.T18 ; v2(240.94,91.69) 240.94,90.69 CG188.2 ; CG84.2 223.14,116.84 v2(223.08,116.79) ; UG1.W17 UG1.V16 206.07,88.43 v2(206.19,88.43) 206.19,88.33 UG1.U16 206.58,87.89 206.96,87.51 v2(207.01,87.51) 207.58,86.94 UG1.T15 v2(208.08,86.44) UG1.R14 ; v2(96.43,25.54) 95.83,25.54 PRM9.2 ; v2(56,13.49) 56.31,13.8 UL2.2 ; CG184.2 236.22,106.23 v2(236.78,106.79) ; UG1.AB14 201.1,85.46 v2(201.1,85.43) 200.61,84.94 UG1.AC13 ; CG143.2 193.64,113.4 194.33,112.72 v2(194.51,112.72) ; v2(238.64,67.87) 238.64,66.95 CG99.2 ; CH20.2 CH101.2 217.74,37.85 v2(217.58,37.69) ; RG381.1 188.24,79.19 v2(188.78,79.19) ; CG164.2 226.31,131 v2(225.4,131) v2(224.8,131) ; UG1.AA17 v2(201.9,89.49) UG1.AA18 ; CG160.2 211.88,131 v2(212.6,131) ; RL11.1 v2(49.92,22.38) ; v2(248.24,68.47) v2(248.24,67.87) ; v2(225.4,134.2) 225.82,134.2 225.99,134.37 CG74.2 ; CG200.2 v2(237.95,61.12) ; UG1.N12 v2(210.08,84.44) UG1.P13 ; UG11.3 184.14,76.16 v2(184.66,76.68) ; v2(215.75,39.71) 216.56,39.71 217.18,40.33 CH21.2 ; RV56.2 70.38,23.42 70.08,23.71 v2(70.08,24.5) ; v2(239.03,59.53) 239.34,59.84 UG29.3 ; v2(237.04,67.87) 237.04,66.95 CG175.2 ; v2(201.71,129.64) 201.01,130.35 CG139.2 ; UG1.M13 v2(211.98,84.54) ; v2(224.8,124.6) v2(225.4,124.6) 225.42,124.58 CG56.2 ; v2(55.38,13.61) 55.75,13.97 CL14.2 CL15.2 ; 129.27,44.89 v2(130.64,46.25) ; v2(188.5,72.62) 190.38,72.62 RG406.1 ; v2(189.35,116.99) 188.81,116.99 CG191.2 ; v2(15.6,89.37) 15.94,89.03 DS6.3 ; UG1.M22 v2(211.05,93.53) UG1.N21 ; v2(240.31,21.09) 240.31,21.84 PR1002.2 ; PCH14.2 180.76,106.36 v2(180.76,106.86) ; RG75.2 241.27,81 v2(240.94,80.67) 240.94,80.71 240.47,81.18 CG121.2 ; v2(53.07,23.7) 52.93,23.56 CL5.2 ; UG1.AA15 v2(203.08,87.44) UG1.Y16 ; CH105.2 218.14,40.1 v2(218.7,39.55) ; v2(238.64,91.69) 238.64,90.68 CG186.2 ; v2(239.06,106.77) 238.95,106.77 CG183.2 ; v2(185.95,129.4) 184.98,129.4 CG65.2 ; CG71.2 210.27,114.64 v2(209.47,114.64) ; CA31.1 295.55,23.2 v2(295.02,23.2) ; CG122.2 242.24,104.89 v2(242.64,104.49) 242.98,104.82 CG91.2 ; CH107.2 64.13,21.67 v2(64.6,21.67) ; v2(225.4,123) 226.3,123 CG165.2 ; UG1.A33 220.15,102.71 v2(220.25,102.71) ; v2(245.04,68.47) v2(245.04,67.87) 245.12,67.79 CG93.2 ; UG1.N19 v2(211.15,91.55) UG1.M20 ; UG1.R23 v2(208.08,94.44) UG1.T22 ; v2(184.02,129.3) 183.88,129.15 RG56.2 ; UG1.Y14 v2(204.08,86.44) UG1.W15 ; UG1.W28 204.81,98.24 v2(204.39,97.82) ; v2(245.04,104.49) 245.04,105.62 CG119.2 ; UG1.U14 206.25,86.27 v2(206.04,86.27) 205.91,86.27 UG1.V14 ; v2(242.54,91.69) 242.54,91.11 CG106.2 ; QG56.3 v2(238.01,62.89) ; v2(206.09,83.29) 206.09,83.45 UG1.U12 206.58,84.08 v2(206.08,84.59) 205.58,84.09 UG1.V12 ; v2(225.4,126.76) 225.44,126.72 225.66,126.72 225.91,126.47 CG60.2 ; v2(246.64,80.67) 246.46,80.86 CG120.2 ; UG1.AB12 v2(202.08,84.44) UG1.AA13 ; v2(16.72,107.92) 16.51,107.72 DV3.3 14.66,107.72 v2(14.53,107.59) ; v2(238.64,80.67) 238.52,80.79 CG185.2 238.52,82.21 CG159.2 ; UG1.AB16 201.57,87.94 v2(201.02,87.39) ; UG1.G16 v2(215.31,88.62) ; v2(231.1,40.25) 231.01,40.16 QG7.4 ; CH4.2 v2(216.58,34.97) ; CG179.2 241.5,67.28 241.65,67.42 v2(241.65,67.85) ; UG1.P17 v2(208.99,89.42) UG1.P18 ; v2(187.55,131.4) UG5.E14 186.55,131 v2(186.55,131) v2(185.95,131) 185.16,131 CG69.2 ; UG1.W13 v2(204.08,84.44) UG1.Y12 v2(203.19,83.55) ; v2(248.24,91.69) 248.24,90.88 CG104.2 ; D507.1 v2(70.23,25.07) ; RA22.1 302.38,32.34 v2(302.06,32.66) ; UG1.AE30 199.81,99.94 v2(199.41,100.34) ; v2(37.88,8.64) 37.78,8.55 JSSD1.68 ; PR1806.2 v2(268.06,21.36) ; v2(213.2,126.9) v2(212.53,126.9) 212.3,127.12 RG59.2 ; CG189.2 235.02,94.11 v2(235.04,94.09) ; v2(235.04,101.29) 234.37,100.61 234.37,100.42 RG71.2 ; PQW3.3 236.23,53.31 235.97,53.05 v2(235.97,52.62) ; v2(198.75,123) 199.03,123 199.22,123.19 200.27,123.19 CG80.2 ; UG1.T13 v2(208.08,84.44) 208.1,84.42 208.1,84.41 208.11,84.41 UG1.R12 ; PRV21.2 226.09,51.24 v2(226.28,51.05) ; UG5.N3 v2(196.35,124.2) ; CG149.2 249.04,66.64 v2(249.04,67.87) ; CG72.2 199.1,131 v2(198.75,131) ; CV17.2 71.79,23.25 v2(71.79,22.43) 71.88,22.33 RV5.2 ; v2(190.21,70.55) 190.21,70.75 190.54,71.08 RG405.1 ; v2(229.29,41.09) 229.1,41.27 229.1,42.01 QG7.1 ; CG192.2 231.08,101.82 v2(231.46,102.19) ; v2(219.38,80.27) 219.38,80.29 UG1.B7 218.58,80.29 ; JTP1.5 88.2,12.88 88.06,12.74 v2(88.06,12.22) ; UG2.3 233.64,53.14 234.13,53.63 v2(234.25,53.63) ; JIO1.38 309.18,27.62 v2(309.48,27.92) ; v2(15.32,79.78) 15.32,79.78 RS41.1 ; v2(193.95,121.8) 194.35,122.19 UG5.T5 v2(193.95,122.6) ; v2(235.44,91.69) 235.44,90.72 CG95.2 ; CG154.2 v2(248.58,107.07) ; CH17.2 217.51,38.37 v2(217.09,37.96) ; v2(197.72,83.6) 198.08,83.95 UG1.AG11 ; CG145.2 185.17,134.2 v2(185.95,134.2) ; CG563.2 v2(241.41,63.09) ; PCM15.2 v2(96.46,26.57) ; CL19.2 v2(49.87,23.22) ; CL27.2 v2(49.89,21.49) ; v2(194.5,113.28) 194.5,113.53 CG144.2 ; CG68.2 212.03,124.8 212.23,124.6 v2(212.6,124.6) v2(213.2,124.6) ; v2(220.21,31.81) 220.51,32.11 YH1.4 ; RA23.1 297.77,21.36 297.64,21.23 v2(296.98,21.23) ; RV7.2 74.91,23.96 v2(74.4,24.46) 73.95,24.92 RV3.2 ; UG1.AB19 v2(201.04,91.48) UG1.AC20 ; v2(16.72,111.22) 16.51,111.02 DV2.3 14.61,111.02 v2(14.5,111.14) ; CR12.2 38.56,20.62 39.05,20.13 v2(39.05,20.06) ; v2(249.04,80.67) 249.04,82.03 CG150.2 ; CG66.2 199.71,124.6 v2(198.75,124.6) v2(198.15,124.6) UG5.N1 ; CL10.2 53.73,14.68 v2(53.68,14.73) ; v2(33.36,60.26) 33.62,60 RV18.2 ; v2(242.54,48.92) 242.51,48.95 PCW3.2 ; PRW11.2 244,58.74 v2(244.06,58.79) ; UG1.Y19 v2(203.08,91.44) UG1.AA20 ; v2(293.05,21.23) 292.54,21.74 CA30.1 ; v2(211.08,85.44) UG1.N14 ; CG176.2 244.71,81.01 v2(245.04,80.67) ; UG1.G3 214.86,77.34 v2(215.26,76.94) 214.86,76.54 UG1.G2 ; v2(238.42,60.19) 237.88,60.19 RG16.2 ; PRW3.2 v2(244.57,55.49) ; CG172.2 216.14,115.01 v2(216.63,114.51) ; CH5.2 v2(216.68,32.42) ; CG173.2 199.81,128.27 CG78.2 199.06,128.27 v2(198.75,128.58) ; v2(196.35,122.6) UG5.R3 195.95,122.99 v2(195.55,122.6) UG5.R4 ; RG43.2 186.94,83.73 v2(186.85,83.64) ; PCM6.2 95.98,28.47 v2(96.03,28.52) ; RG11.2 v2(221.13,68.96) ; PRW12.2 236.46,51.08 236.88,51.51 v2(236.88,51.67) ; UG1.P15 v2(209.14,87.33) ; v2(15.32,80.54) RS42.1
  BOTTOM w0.4: 218.58,95.29 v2(218.58,95.27) ; 218.58,95.29 UG1.C25 ; 218.58,95.29 UG1.B25 ; UG1.AH30 v2(197.76,99.52) ; v2(196.88,98.64) UG1.AH28 ; v2(196.91,102.74) 196.93,102.74 197.08,102.59 UG1.AH33 v2(196.93,101.94) UG1.AH32 ; v2(249.04,80.67) v2(249.04,80.07) ; v2(245.04,92.29) v2(245.04,91.69) ; 214.43,101.94 v2(214.41,101.94) ; 214.43,101.94 UG1.G33 ; 214.43,101.94 UG1.G32 ; 194.43,101.94 v2(194.41,101.94) ; 194.43,101.94 UG1.AL32 ; 194.43,101.94 UG1.AL33 194.43,102.74 v2(194.41,102.74) ; v2(216.98,92.77) 216.98,92.79 UG1.E22 ; v2(192.78,101.94) UG1.AP33 192,101.96 v2(191.97,101.96) ; UG1.K32 212.76,101.12 v2(212.76,101.1) ; v2(213.2,131) v2(212.6,131) ; 218.58,82.79 v2(218.58,82.77) ; 218.58,82.79 UG1.B10 218.81,83.36 218.58,83.59 v2(218.58,83.62) 218.18,83.22 UG1.C10 218.58,82.79 ; v2(218.58,80.27) 218.58,80.29 UG1.C7 ; v2(209.41,101.94) 209.43,101.94 UG1.N33 ; v2(201.91,97.84) 201.93,97.84 UG1.AB28 ; v2(235.44,80.67) v2(234.84,80.67) ; UG1.E5 v2(216.98,78.54) ; UG1.K28 212.73,97.84 v2(212.76,97.84) ; v2(220.78,76.14) 220.94,75.98 220.94,75.72 220.55,75.34 v2(220.18,75.34) ; UG1.B34 v2(218.58,102.74) ; v2(234.84,68.47) v2(235.44,68.47) ; v2(202.76,101.14) 202.73,101.14 UG1.AB32 ; v2(198.75,123) v2(198.15,123) ; v2(215.31,86.12) UG1.G13 ; v2(192.78,99.44) UG1.AN30 192.78,100.24 v2(192.78,100.27) ; v2(245.04,103.89) UG7.E14 ; v2(200.26,97.84) 200.23,97.84 UG1.AE28 v2(200.26,98.67) ; UG1.C16 217.8,88.57 v2(217.8,88.62) ; v2(209.41,97.84) 209.43,97.84 UG1.N28 ; UG1.G2 215.23,76.14 215.26,76.14 ; UG1.T32 207.73,101.14 v2(207.76,101.14) ; v2(249.04,67.87) v2(249.04,68.47) v2(248.24,68.47) ; v2(213.2,134.2) v2(212.6,134.2) ; v2(235.44,104.49) v2(235.44,103.89) v2(234.84,103.89) ; v2(215.31,83.62) UG1.G10 ; v2(204.41,101.94) 204.43,101.94 UG1.W32 ; v2(195.18,99.44) UG1.AL30 ; 200.23,101.94 UG1.AE33 199.43,102.74 v2(199.41,102.74) ; 200.23,101.94 UG1.AE32 ; 200.23,101.94 v2(200.26,101.94) ; v2(249.04,92.29) v2(249.04,91.69) ; v2(186.55,135) v2(186.55,134.2) ; v2(220.18,83.62) v2(220.18,82.77) ; UG1.G19 v2(214.48,90.29) ; v2(235.44,91.69) v2(234.84,91.69) v2(234.84,92.29) v2(235.44,92.29) 235.44,92.28 v2(235.44,91.69)
  BOTTOM w0.406: v2(235.04,71.07) 235.44,70.68 UG6.A12 ; UG5.B10 190.35,133.4 v2(189.95,133) UG5.C11 ; v2(212.6,132.6) v2(213.2,132.6) UG4.R1 v2(214.2,133) ; v2(215,133.8) UG4.U3 v2(215.8,134.6) ; v2(237.44,70.27) 237.04,70.67 UG6.C12 236.68,71.04 236.68,71.04 v2(236.64,71.07) UG6.C11 237.4,71.83 v2(237.44,71.87) 237.84,72.27 UG6.D10 ; UG6.F5 v2(239.04,75.87) ; UG6.F5 v2(239.84,76.67) UG6.G5 v2(239.84,75.87) 239.44,76.27 UG6.F5 ; UG5.C3 195.55,132.2 v2(195.55,132.2) 195.55,132.2 UG5.C4 194.75,132.2 v2(194.75,132.2) ; v2(235.44,68.47) 235.44,68.48 UG6.A14 ; UG5.N12 v2(188.35,125) ; v2(215.73,85.69) v2(215.31,86.12) ; UG4.R4 216.6,133 UG4.T5 ; UG4.R4 v2(215.8,132.2) UG4.R3 ; UG4.R4 v2(216.6,132.2) ; v2(244.64,79.07) UG6.N1 v2(245.04,80.07) ; UG4.E1 v2(213.2,124.6) ; v2(220.18,75.34) v2(219.38,76.14) ; v2(219.38,76.14) UG1.A2 ; v2(219.38,76.14) UG1.B1 ; v2(224.8,131) 224.2,131 UG4.N14 v2(223.8,130.6) ; v2(196.35,131.4) 195.95,131 UG5.E3 195.95,131 v2(195.55,130.6) ; v2(189.95,123.4) 190.35,123.8 UG5.P10 ; UG6.N3 v2(245.44,77.47) ; v2(215,131.4) UG4.N3 ; UG4.N3 v2(215.8,131.4) ; UG4.N3 v2(215,130.6) ; UG6.L5 v2(243.84,75.87) UG6.M5 v2(244.64,76.67) ; v2(223,123.4) 223,123.39 UG4.C12 222.59,122.99 v2(222.2,122.6) ; v2(238.24,78.27) 238.64,77.88 UG6.E3 ; v2(224.8,134.2) v2(224.8,135) ; v2(224.8,134.2) UG4.U14 ; v2(224.8,134.2) v2(225.4,134.2) ; UG6.R11 246.64,71.47 v2(246.24,71.87) 246.24,71.87 UG6.P10 ; UG5.A12 188.75,134.2 v2(188.35,133.8) ; UG1.C13 v2(217.78,86.09) ; 200.21,103.54 v2(199.41,102.74) ; 200.21,103.54 v2(200.26,103.54) ; 200.21,103.54 200.04,103.71 200.03,103.71 199.72,104.02 199.72,104.02 199.51,104.24 v2(199.41,104.24) ; v2(217.78,91.12) 218.18,90.72 UG1.C19 ; UG5.U12 v2(189.15,121) ; v2(185.95,134.2) v2(186.55,134.2) UG5.A14 ; UG6.N14 v2(245.04,68.47) ; v2(223.8,132.2) UG4.R14 v2(224.8,132.6) v2(225.4,132.6) ; v2(245.44,102.09) UG7.E12 ; v2(187.55,122.6) 187.15,122.99 UG5.R14 186.55,122.99 v2(186.55,123) v2(185.95,123) ; UG1.D33 v2(217.33,102.99) ; UG1.AL28 194.78,98.22 v2(194.38,98.62) ; v2(237.04,68.47) 237.04,68.48 UG6.C14 237.04,69.08 v2(236.64,69.47) ; v2(215,124.2) 215,124.2 UG4.E3 v2(215,125) ; v2(190.75,132.2) UG5.D10 189.95,131.4 v2(189.95,131.4) ; v2(219.4,77.76) 218.98,78.18 UG1.B4 ; UG4.A12 222.56,121.35 v2(222.56,120.54) ; UG7.U12 235.44,101.69 v2(235.04,101.29) ; UG1.E10 v2(216.16,82.77) v2(215.73,83.19) v2(215.31,83.62) ; v2(237.44,94.89) UG7.R3 237.04,94.49 v2(236.64,94.89) UG7.R4 ; v2(212.33,99.09) 211.93,99.49 v2(211.93,99.54) UG1.K30 ; UG4.E12 v2(223,124.2) ; v2(195.55,133.8) 195.95,134.2 UG5.A3 196.35,134.6 v2(196.35,134.6) ; v2(194.34,100.28) 194.78,99.85 UG1.AL30 ; UG4.P10 v2(220.6,131.4) ; UG4.P10 v2(220.6,132.2) ; UG4.P10 221.4,132.2 v2(221.4,132.2) UG4.R11 ; v2(222.2,131.4) UG4.N12 222.6,131 v2(223,131.4) ; v2(213.2,131) UG4.N1 v2(214.2,131.4) ; v2(247.84,78.27) UG6.U3 ; v2(198.15,123) 197.55,123 UG5.R1 v2(197.15,123.4) ; UG6.R1 v2(246.64,80.07) ; UG6.U14 v2(248.24,68.47) ; UG6.R4 v2(246.24,77.47) UG6.R3 v2(247.04,78.27) ; v2(238.64,104.49) v2(238.64,103.89) 238.64,103.29 UG7.N14 v2(238.24,102.89) ; v2(245.44,100.49) UG7.D10 v2(246.24,99.69) ; v2(192.78,103.54) v2(192.78,104.24) ; v2(192.78,103.54) UG1.AN34 ; v2(192.78,103.54) 192.05,103.54 v2(191.95,103.63) ; v2(245.04,104.49) v2(245.04,103.89) ; v2(217.78,93.62) 218.18,93.22 UG1.C22 ; v2(209.41,101.94) 209.81,101.54 UG1.N32 210.23,101.14 v2(210.26,101.14) ; v2(246.24,69.47) 246.64,69.07 UG6.R14 v2(246.64,68.47) v2(246.64,67.87) ; v2(242.64,80.07) v2(242.64,80.67) ; v2(246.24,102.89) UG7.C14 v2(246.64,103.89) v2(246.64,104.49) ; v2(240.94,80.67) v2(240.94,80.07) 240.94,79.57 UG6.H1 241.04,79.47 v2(240.64,79.07) 240.64,79.07 UG6.H2 v2(241.44,78.27) ; v2(220.23,100.94) 220.18,100.89 219.6,100.89 v2(219.38,101.12) 218.98,100.71 UG1.B31 ; v2(197.76,99.52) UG1.AH29 197.24,99 v2(196.88,98.64) ; v2(238.24,69.47) 238.64,69.08 UG6.E14 238.64,68.48 v2(238.64,68.47) ; v2(237.44,100.49) 237.84,100.09 UG7.P10 ; v2(237.04,80.67) v2(237.04,80.07) 237.04,80.07 UG6.C1 237.04,79.47 v2(236.64,79.07) ; UG7.C12 v2(247.04,102.09) ; v2(238.64,80.07) 238.64,80.07 UG6.E1 239.04,79.07 v2(239.04,79.07) ; UG6.A1 235.44,80.07 v2(235.44,80.07) v2(235.44,80.67) ; UG7.U14 235.44,103.89 v2(235.44,103.89) ; UG4.C1 213.2,122.99 v2(213.2,123) v2(212.6,123) ; v2(235.84,71.87) 236.24,72.27 UG6.B10 ; UG1.N30 v2(210.26,99.52) v2(209.83,99.09) ; UG7.E3 v2(245.44,94.89) ; UG1.AB30 v2(201.91,99.52) ; UG6.P10 v2(246.24,72.67) ; UG6.P10 245.44,72.67 v2(245.44,72.67) ; v2(216.6,133.8) UG4.T5 ; UG4.T5 v2(217.4,133.8) ; v2(213.2,134.2) UG4.U1 v2(214.2,134.6) ; v2(224.8,124.6) 224.2,124.6 UG4.E14 223.8,124.2 v2(223.8,124.2) ; v2(244.64,70.27) UG6.N12 245.44,70.27 v2(245.44,70.27) ; UG6.A3 235.44,77.87 v2(235.04,77.47) ; v2(237.04,104.49) v2(237.04,103.89) 237.04,103.29 UG7.R14 v2(236.64,102.89) ; v2(187.55,124.2) 187.15,124.6 UG5.N14 186.55,124.6 v2(186.55,124.6) v2(185.95,124.6) ; UG7.A1 v2(248.64,93.29) ; v2(239.04,71.87) UG6.F10 239.44,72.27 v2(239.84,71.87) UG6.G10 ; v2(217.78,98.62) 218.18,98.22 UG1.C28 ; UG5.R12 v2(189.15,122.6) ; UG6.U12 v2(247.84,70.27) ; UG6.K13 242.64,69.87 v2(242.24,70.27) ; UG1.G30 214.86,99.94 v2(215.26,100.34) ; v2(215.26,102.74) 214.86,102.34 UG1.G33 ; v2(223,133.8) 222.6,134.2 UG4.U12 ; UG7.T10 236.24,100.09 v2(235.84,100.49) ; v2(187.55,133) UG5.C14 v2(186.55,132.6) v2(185.95,132.6) ; v2(237.04,91.69) v2(237.04,92.29) 237.04,92.88 UG7.R1 v2(237.44,93.29) ; v2(225.4,123) v2(224.8,123) 224.2,123 UG4.C14 224.19,122.99 v2(223.8,122.6) ; v2(236.64,75.87) 236.24,76.27 UG6.B5 ; UG4.B10 v2(221.4,121.8) ; v2(188.35,131.4) UG5.E12 v2(189.15,130.6) ; v2(223,133) 222.6,132.6 UG4.R12 ; UG1.B28 218.98,98.21 v2(219.38,98.62) ; UG6.T10 v2(247.84,72.67) ; UG7.R12 237.04,101.69 v2(236.64,101.29) ; UG4.T10 v2(220.6,133.8) ; v2(188.35,132.2) 188.75,132.6 UG5.C12 ; v2(197.15,132.2) 197.55,132.6 UG5.C1 v2(198.15,132.6) ; v2(186.55,121.4) 186.55,121.39 UG5.U14 ; UG1.D31 v2(217.78,101.14) ; v2(236.64,77.47) 237.04,77.08 UG6.C4 237.44,77.47 v2(237.44,77.47) 237.04,77.87 UG6.C3 ; v2(197.15,130.6) 197.55,131 UG5.E1 v2(198.15,131) v2(198.75,131) ; UG5.T10 190.35,122.19 v2(189.95,121.8) ; UG6.T5 v2(247.84,75.87) ; v2(246.64,92.29) v2(246.64,91.69) ; v2(193.95,133.8) 194.35,133.4 UG5.B5 ; UG7.A12 v2(247.84,102.09) ; UG6.E12 v2(238.24,70.27) ; UG6.R12 v2(247.04,70.27) ; UG1.T28 v2(206.91,98.67) ; UG4.D10 v2(221.4,123.4) ; 216.2,123 UG4.C4 216.19,122.99 v2(215.8,122.6) UG4.C3 215.8,123.39 v2(215.8,123.4) 216.2,123
  BOTTOM w0.457: v2(238.64,68.47) v2(238.64,67.87) ; v2(246.64,80.07) v2(246.64,80.67) ; v2(245.04,80.07) v2(245.04,80.67) ; PCM17.2 92.6,23.73 v2(92.25,24.07) ; v2(237.04,68.47) v2(237.04,67.87) ; v2(75.48,11.06) 75.92,11.5 PC329.2
  BOTTOM w0.508: RH168.2 RH25.2 v2(219.28,18.31) ; RG136.1 230.88,64.5 v2(230.88,65.06) ; v2(304.26,43.14) 303.37,42.25 JSPK1.7 ; CH68.1 CH67.1 219.59,13.25 v2(220.02,13.68) ; v2(252.17,20.34) 251.32,20.34 PC311.2 ; v2(271.21,48.32) 271.76,48.32 271.99,48.1 JFAN1.4 ; v2(101.43,60.6) 101.43,60.32 JDIMM1.261 ; PR6.2 282.25,29.89 282.25,30.4 v2(282.55,30.71) ; CR6.2 CR3.2 v2(46.92,18.82) ; RC392.2 122.64,103.43 CC157.1 v2(122.05,104.29) ; v2(89.91,25.29) 89.67,25.05 PCM16.2 ; v2(281.98,27.47) 281.76,27.25 PR2.2 ; v2(176.14,83.84) 176.18,83.8 CC156.1 ; PC1804.2 261.24,17.78 v2(261.86,17.78) ; v2(302.32,36.78) 301.8,37.29 301.8,37.92 ; PCZ53.2 147.32,135.2 147.86,135.74 v2(147.86,136.17) ; v2(229.25,50.84) 229.25,50.99 228.83,51.41 PCV28.2 ; CH34.2 187.89,14.64 CH11.1 v2(186.38,15.53) ; UG13.3 233.74,60.27 v2(233.74,60.85) RG15.2 ; UC2.3 121.25,88.78 120.89,89.15 v2(120.77,89.15) ; CG11.2 v2(190.92,93.5) ; PC1803.2 261.09,21.28 v2(261.58,21.28) ; RC36.2 RC34.2 v2(122.67,95.58) ; RG70.2 244.15,64.64 v2(243.79,64.29) ; CG2.2 223.23,67.31 v2(222.79,66.87) 222.7,66.87 CG1.2 ; v2(116.03,95.02) 115.3,95.76 PHZ5.2 ; v2(97.15,9.4) 97.15,9.82 96.52,10.45 JTP1.9 ; v2(219.31,14.57) 219.24,14.5 CH66.1 ; DM12.2 51.89,26.81 v2(51.54,26.46) ; CH7.2 187.05,18.54 v2(187.28,18.77) ; v2(304.02,26.64) 303.6,26.22 JWLAN1.68 ; CH3.2 181.41,49.72 v2(181.19,49.93) ; RG58.2 v2(229.12,126.96) ; PRW6.2 239.58,57.25 v2(239.86,56.97) PCW1.2 ; PCM5.2 93.18,31.15 92.54,30.5 v2(92.54,30.12) ; JKBL1.5 219.1,8.25 v2(218.37,8.98) ; RG137.1 232.55,64.9 v2(232.4,65.06) ; JDIMM2.261 101.15,20.45 v2(99.83,20.45) ; CH6.2 v2(187.3,21.26) ; CG570.2 v2(190.9,94.99) ; CG88.2 184.87,128.6 v2(185.97,128.6) v2(186.57,128.6) ; v2(240.94,92.29) v2(240.94,91.69) ; v2(192.35,48.54) 192.35,49.01 UH2.4 ; v2(210.61,7.55) 211,7.55 JKBL1.6 ; CC41.1 120.55,84.23 v2(120.41,84.08) ; QG55.3 v2(233.75,63.19) ; JFAN2.4 32.68,45.81 v2(32.77,45.72) ; v2(219.31,69.16) 219.31,69.62 219.46,69.77 RG135.1 ; CH2.2 v2(180.68,53.36) ; PCM7.1 v2(88.47,28.45) ; v2(121.75,99.59) 123.38,99.59 RC32.2 ; RC13.2 RC11.2 ; v2(93.56,21.9) 93.54,21.92 PCM18.2 ; PHZ4.2 v2(155.2,131.21) ; PCZ39.2 154.89,135.2 155.53,135.84 v2(155.53,136.17) ; PCZ31.1 v2(161.88,126.64) ; v2(285.8,25.94) 285.45,26.29 PD2.1 ; PCZ30.2 PRZ77.2 162.06,124.28 v2(161.88,124.1) ; QG17.1 237.91,38 v2(237.94,38.03) ; CV274.2 v2(181.31,119.68) ; CR7.2 CR2.2 CR10.2 v2(36.28,17.3) ; RC390.2 124.49,100.33 v2(124.82,100.66) ; JSPK1.6 v2(296.8,44.65) ; PC329.2 75.89,11.74 PR308.2 ; PCV19.2 193.81,56.22 194.18,56.58 v2(194.18,57.06) ; v2(271.68,43.04) 271.22,43.5 JFAN1.5 ; RG73.2 233.83,71.07 v2(235.04,71.07) ; v2(242.86,46.48) 242.86,46.05 242.68,45.86 CG336.2 ; PRZ63.2 162.01,129.82 v2(161.88,129.69) ; JFAN2.5 36.55,46.14 v2(36.66,46.26) ; v2(174.83,57.85) 174.53,58.15 JDIMM1.262 ; v2(252.15,19.69) 252,19.53 PC308.2 ; v2(58.32,27.41) 58.32,27.74 57.64,28.41 UU5.4 ; RG57.2 v2(229.12,126.17) ; PC301.2 245.52,29.02 v2(245.03,29.02) ; RC31.2 123.38,98 RC19.2 v2(122.66,98) ; PRZ57.2 PCZ32.2 161.96,132.23 PRZ78.2 v2(161.75,131.34) ; CR9.2 v2(36.28,18.18) ; v2(174.18,8.68) 173.52,8.68 JKB1.33 ; v2(225.06,65.94) 225.28,65.72 RG134.1 225.48,64.98 RG138.1 ; JFAN1.6 v2(276.29,42.2) ; CH69.1 218.99,17 v2(219.14,17.15) ; PCZ60.2 132.42,135.2 132.92,135.71 v2(132.92,136.24) ; RH204.2 RH193.2 186.49,26.17 v2(186.31,26.35) ; v2(294.37,41.96) 294.66,42.25 JSPK1.8 ; QG16.3 233.41,38.67 v2(232.94,39.14) ; PRZ65.2 162.01,130.58 v2(161.88,130.45) ; CG335.2 244.48,45.85 v2(243.98,46.36) ; PRF6.2 174.41,105.1 v2(174.41,105.12) ; PDM3.2 v2(84.29,27.72) ; JHDD1.13 254.05,13.3 v2(254.61,13.86) ; v2(88.09,29.23) 88.31,29.45 88.31,30.38 ; v2(37.86,51.66) 37.1,50.9 JFAN2.6 ; PUF1.2 v2(176.84,100.54) ; RH176.2 180.77,51.71 v2(180.58,51.52) ; v2(28.74,66.79) 28.32,67.21 CV32.2 ; JKB1.34 208.75,8.14 v2(208.23,7.62) ; RG118.1 230.04,64.53 v2(230.04,65.06) ; v2(161.55,135.56) 161.37,135.74 PCA6.2 ; v2(17.03,48.46) 16.85,48.28 DU14.1 ; PCH7.2 v2(181.17,115.58) ; JTP1.10 82.8,10.45 v2(84.59,12.24) ; v2(231.72,65.06) 231.72,64.55 RG123.1 ; PCW6.2 v2(262.03,57.8) ; v2(18.48,117.65) 18.57,117.56 RV29.2 ; v2(238.09,57.54) 238.58,58.04 PRW4.1 ; PR1007.2 v2(239.55,22.25) ; PC1805.2 261.77,23.39 PR1805.2 v2(260.57,22.49) ; 46.99,41.04 46.97,41.02 CE6.2 ; CC155.2 v2(122,108.48) CH80.2 ; RR10.2 v2(36.89,13.06) ; v2(51.57,32.84) 51.89,33.16 DM13.2 ; RC33.2 123,96.45 122.57,96.88 v2(122.57,97.15) 122.63,97.21 RC35.2 ; CL25.1 v2(50.25,17.68) ; PCZ67.2 139.73,135.2 140.24,135.71 v2(140.24,136.12) ; v2(60.89,14.8) 61.25,14.8 62.03,14.01 CL28.2 ; v2(189.67,13.69) CH25.2 ; DL1.1 38.17,38.55 38.77,37.96 v2(39.07,37.96) ; CL24.1 v2(50.2,20.34) ; v2(238.64,80.07) v2(238.64,80.67)
  vias: v2(0.43,123.18) v2(0.44,12.27) v2(0.44,9.73) v2(0.44,7.19) v2(0.44,4.65) v2(0.44,2.11) v2(0.5,120.67) v2(0.89,46.84) v2(0.89,44.3) v2(0.92,0.44) v2(1,119.83) v2(1.24,100.86) v2(1.24,98.32) v2(1.73,125.9) v2(1.73,96.19) v2(1.78,57.48) v2(2.24,101.5) v2(2.34,47.39) v2(2.62,127.43) v2(2.62,124.37) v2(2.68,98.15) v2(2.88,12.83) v2(2.98,80.9) v2(3.36,99.55) v2(3.46,0.44) v2(4.07,96.19) v2(4.2,119.83) v2(4.18,101.03) v2(4.34,98.18) v2(4.38,127.43) v2(4.38,124.37) v2(4.39,42.81) v2(4.88,47.39) v2(5.27,125.9) v2(5.31,57.48) v2(5.31,55.85) v2(5.31,48.82) v2(5.42,103.4) v2(5.38,99.55) v2(5.61,5.05) v2(5.69,3.19) v2(6,0.44) v2(6.41,101.55) v2(6.36,98.18) v2(6.76,119.84) v2(7.06,6.31) v2(7.09,4.14) v2(7.11,1.89) v2(7.28,100.25) v2(7.51,8.25) v2(7.69,103.42) v2(7.7,10.58) v2(8.11,99.08) v2(8.21,101.62) v2(8.29,9.39) v2(8.37,7.23) v2(8.53,96.19) v2(8.5,81.56) v2(8.54,0.44) v2(8.92,42.8) v2(9,98.04) v2(9.3,119.84) v2(9.29,100.32) v2(9.31,8.26) v2(9.5,10.6) v2(9.75,125.23) v2(9.96,126.97) v2(10.11,101.64) v2(10.13,99.15) v2(10.09,9.4) v2(10.19,117.35) v2(10.24,105.84) v2(10.23,103.42) v2(10.23,4) v2(10.44,125.19) v2(10.5,12.82) v2(10.87,128.47) v2(10.87,119.35) v2(11.04,81.56) v2(11,8.26) v2(11.07,96.18) v2(11.12,5.53) v2(11.12,2.47) v2(11.24,98.1) v2(11.19,10.6) v2(11.31,100.33) v2(11.46,42.8) v2(11.78,9.4) v2(12.3,101.66) v2(12.39,99.15) v2(12.67,8.28) v2(12.86,10.61) v2(12.88,5.53) v2(12.88,2.47) v2(13.04,12.82) v2(13.43,50.12) v2(13.45,9.42) v2(13.6,97.9) v2(13.77,4) v2(14.04,109.2) v2(14.08,44.78) v2(14.05,42.8) v2(14.17,58.89) v2(14.61,128.18) v2(15.06,60.42) v2(15.06,57.36) v2(15.58,12.82) v2(15.65,126) v2(16.16,0.44) v2(16.46,124.32) v2(16.57,44.8) v2(16.82,60.42) v2(16.82,57.36) v2(17.2,8.18) v2(17.41,122.33) v2(17.71,58.89) v2(17.87,8.21) v2(18.12,12.82) v2(18.31,120.44) v2(18.44,8.2) v2(18.7,0.44) v2(19.11,44.8) v2(19.37,118.21) v2(19.51,116.23) v2(19.51,115.59) v2(19.47,113.02) v2(19.54,109.51) v2(19.7,111.22) v2(19.69,85.25) v2(19.82,107.69) v2(19.78,80.19) v2(20.31,105.99) v2(20.66,12.82) v2(20.76,110.92) v2(20.91,74.87) v2(20.92,74.31) v2(20.9,50.59) v2(21.17,108.03) v2(21.24,0.44) v2(21.52,105.51) v2(21.53,49.09) v2(21.65,44.8) v2(21.75,86.76) v2(21.8,54.81) v2(21.9,102.84) v2(22.11,117.35) v2(22.09,54.33) v2(22.23,115.28) v2(22.56,113.21) v2(22.6,90.81) v2(22.88,88.94) v2(23.12,116.81) v2(23.12,113.75) v2(23.2,12.82) v2(23.25,93.26) v2(23.28,70.29) v2(23.25,54.74) v2(23.48,84.74) v2(23.48,74.87) v2(23.5,74.31) v2(23.59,83.91) v2(23.59,83.35) v2(23.63,68.18) v2(23.67,90.3) v2(23.84,63.3) v2(23.84,61.95) v2(23.84,60.6) v2(23.84,59.26) v2(23.78,0.44) v2(23.86,54.78) v2(24,87.94) v2(23.96,71.39) v2(24.19,44.8) v2(24.33,101.52) v2(24.37,96.08) v2(24.38,85.22) v2(24.35,78.23) v2(24.53,74.92) v2(24.52,73.01) v2(24.8,82.28) v2(24.88,116.81) v2(24.88,113.75) v2(24.95,67.94) v2(25.07,69.9) v2(25.19,63.3) v2(25.19,61.95) v2(25.19,60.6) v2(25.19,59.26) v2(25.31,79.02) v2(25.37,100.25) v2(25.37,97.71) v2(25.77,115.28) v2(26,76.04) v2(26.32,0.44) v2(26.54,63.3) v2(26.54,61.95) v2(26.54,60.6) v2(26.54,59.26) v2(26.75,73.63) v2(27.88,63.3) v2(27.88,61.95) v2(27.88,60.6) v2(27.88,59.26) v2(28.2,70.04) v2(28.33,42.8) v2(28.28,12.82) v2(28.35,44.77) v2(28.63,7.06) v2(28.86,0.44) v2(29.54,67.41) v2(29.6,44.38) v2(30.18,44.38) v2(30.44,51.68) v2(30.44,50.28) v2(30.76,44.38) v2(30.82,12.82) v2(30.87,42.8) v2(31.18,64.73) v2(31.4,0.44) v2(31.49,6.09) v2(31.55,53.1) v2(31.55,51.68) v2(31.55,50.28) v2(31.55,48.86) v2(32.22,58.45) v2(32.21,6.1) v2(32.67,51.68) v2(32.67,50.28) v2(32.95,62.25) v2(33.33,18.21) v2(33.33,15.67) v2(33.3,12.82) v2(33.36,42.8) v2(33.45,11.02) v2(33.43,10.46) v2(33.94,0.44) v2(35.18,59.71) v2(35.51,47.61) v2(36.5,34.95) v2(36.48,0.44) v2(36.68,31.92) v2(36.72,25.88) v2(36.76,28.9) v2(37.32,57.6) v2(38.52,49.96) v2(38.96,50.92) v2(39.02,0.44) v2(39.5,8.05) v2(39.61,55.67) v2(39.99,37.26) v2(40.49,17.97) v2(40.62,49.77) v2(40.57,37.26) v2(40.95,42.42) v2(40.99,9.55) v2(41,0.43) v2(41.13,37.26) v2(41.61,17.97) v2(41.61,16.86) v2(41.61,15.74) v2(41.58,2.64) v2(42.09,48.5) v2(42.37,53.71) v2(42.55,10.31) v2(42.61,45.86) v2(42.62,45.3) v2(42.72,17.97) v2(42.72,16.86) v2(42.72,15.74) v2(42.78,46.41) v2(42.96,3.83) v2(43.35,46.49) v2(43.94,12.29) v2(44.48,48.71) v2(45.32,51.97) v2(45.5,3.83) v2(45.81,12.22) v2(46.52,44.72) v2(46.52,43.46) v2(46.52,42.19) v2(47.08,49.15) v2(47.28,5.9) v2(47.5,48.77) v2(47.99,45.98) v2(47.99,44.72) v2(47.99,43.46) v2(47.99,42.19) v2(47.99,40.93) v2(48.22,50.59) v2(48.17,7.43) v2(48.17,4.37) v2(49.47,44.72) v2(49.47,43.46) v2(49.47,42.19) v2(49.93,7.43) v2(49.93,4.37) v2(50.33,12.89) v2(50.51,49.69) v2(50.82,5.9) v2(50.88,12.89) v2(51.16,33.27) v2(51.41,27.23) v2(52.77,3.83) v2(52.91,25.17) v2(53.09,48.87) v2(53.75,25.93) v2(54.59,21.06) v2(54.59,19.94) v2(54.59,18.83) v2(55.61,48.26) v2(55.71,21.06) v2(55.71,19.94) v2(55.66,3.83) v2(56.36,23.03) v2(56.83,21.06) v2(56.83,19.94) v2(56.83,18.83) v2(57.48,23) v2(58.2,3.83) v2(58.29,47.8) v2(58.83,22.32) v2(59.02,34.31) v2(59.61,34.31) v2(60.13,6.88) v2(60.06,6.24) v2(60.19,34.31) v2(60.34,5.56) v2(60.49,47.57) v2(60.74,9.37) v2(60.69,6.22) v2(60.74,3.83) v2(60.77,8.12) v2(60.77,6.9) v2(60.97,5.58) v2(61.33,9.37) v2(61.3,6.22) v2(61.35,8.12) v2(61.35,6.9) v2(61.55,5.58) v2(61.91,6.19) v2(62.98,46.85) v2(63.28,3.83) v2(65.82,3.83) v2(65.91,46.92) v2(66.17,34.63) v2(66.17,34.06) v2(66.17,33.44) v2(66.73,34.67) v2(66.65,32.66) v2(68.36,3.83) v2(68.94,21.6) v2(69.17,47.86) v2(70.65,20.91) v2(70.9,3.83) v2(71.38,31.42) v2(71.71,33.11) v2(71.73,32.55) v2(71.93,48.36) v2(72.27,33.12) v2(72.29,32.57) v2(72.69,31.75) v2(72.69,26.57) v2(73.16,31.44) v2(73.44,3.83) v2(73.82,8.81) v2(74.21,26.55) v2(74.61,49.05) v2(75.08,8.34) v2(75.73,26.44) v2(75.98,3.83) v2(77.08,8.34) v2(77.18,49.91) v2(77.66,26.41) v2(78.14,31.5) v2(78.37,43.99) v2(78.39,7.84) v2(78.52,3.83) v2(78.6,34.64) v2(78.74,31.52) v2(78.79,8.3) v2(78.94,43.99) v2(79.06,8.82) v2(79.13,7.86) v2(79.23,34.66) v2(79.24,6.53) v2(79.41,8.35) v2(79.52,50.88) v2(79.55,44) v2(79.54,26.53) v2(79.66,8.86) v2(79.7,7.83) v2(80.05,8.35) v2(80.04,7.34) v2(80.3,8.86) v2(80.3,7.84) v2(80.63,7.35) v2(80.68,8.35) v2(80.93,7.84) v2(81.06,3.83) v2(81.28,26.41) v2(81.6,51.89) v2(82.45,33.82) v2(82.46,34.44) v2(83.6,3.83) v2(83.81,53.14) v2(85.9,54.5) v2(85.95,41.94) v2(85.95,41.35) v2(85.95,40.77) v2(86.14,3.83) v2(86.83,23.17) v2(87.05,21.73) v2(87.35,32.54) v2(87.35,31.78) v2(87.57,44.25) v2(88.16,56.22) v2(88.15,44.25) v2(88.18,20.59) v2(88.74,44.25) v2(88.68,3.83) v2(88.98,35.84) v2(88.98,35.2) v2(88.98,34.57) v2(89.32,44.25) v2(89.49,35.46) v2(89.49,34.82) v2(89.49,34.19) v2(89.62,39.14) v2(89.62,38.5) v2(89.62,37.87) v2(89.62,37.23) v2(89.62,36.6) v2(90.12,38.25) v2(90.12,37.62) v2(90.12,36.85) v2(90.44,58.23) v2(91.23,52.9) v2(91.22,3.83) v2(91.65,27.57) v2(91.65,26.32) v2(92.12,54.43) v2(92.12,51.37) v2(92.35,60.19) v2(92.27,26.95) v2(93.12,9.5) v2(93.76,3.83) v2(93.88,54.43) v2(93.88,51.37) v2(94.16,62.33) v2(94.77,52.9) v2(96.23,65.13) v2(96.3,3.83) v2(97.5,67.33) v2(98.18,42.6) v2(98.72,41.99) v2(98.71,41.43) v2(98.71,40.8) v2(98.84,3.83) v2(98.87,70.01) v2(99.98,72.67) v2(100.76,10.5) v2(100.87,75.32) v2(101.38,3.83) v2(101.5,77.71) v2(101.91,93.09) v2(101.99,80.29) v2(102.2,91.03) v2(102.41,88.65) v2(102.69,10.47) v2(102.85,82.47) v2(103.18,107.75) v2(103.49,105.54) v2(103.5,94.46) v2(103.89,102.72) v2(103.92,3.83) v2(104.19,100.55) v2(104.53,98.15) v2(104.6,44.96) v2(104.65,33.65) v2(104.62,10.47) v2(104.8,96.24) v2(105.02,108.45) v2(105.52,82.47) v2(105.58,87.34) v2(105.62,46.38) v2(105.96,11.22) v2(106.51,35.33) v2(106.51,34.06) v2(106.51,32.79) v2(106.46,3.83) v2(107.56,108.47) v2(107.9,47.14) v2(107.9,45.87) v2(107.89,11.22) v2(108.04,86.22) v2(108.15,83.75) v2(108.16,95.15) v2(108.16,94.51) v2(108.16,93.88) v2(108.59,34.15) v2(108.67,95.4) v2(108.67,94.77) v2(108.67,94.13) v2(108.67,93.5) v2(108.72,32.05) v2(109,3.83) v2(109.17,95.15) v2(109.17,94.51) v2(109.17,93.88) v2(109.38,45.39) v2(109.52,9.02) v2(110,95.3) v2(110,94.29) v2(110,93.29) v2(110.23,13.95) v2(110.34,108.99) v2(110.79,13.95) v2(111.31,95.3) v2(111.31,94.29) v2(111.31,93.29) v2(111.35,13.95) v2(111.4,9.02) v2(111.54,3.83) v2(111.84,34.69) v2(111.84,33.42) v2(112.12,9.97) v2(112.22,45.77) v2(112.32,109.83) v2(112.63,95.3) v2(112.63,94.29) v2(112.63,93.29) v2(113.94,94.22) v2(113.94,93.29) v2(113.87,34.82) v2(113.87,33.55) v2(113.87,32.28) v2(114,9.97) v2(114.08,3.83) v2(114.16,111.08) v2(115.1,9.08) v2(115.16,46.86) v2(115.16,45.65) v2(115.46,112.34) v2(115.91,34.31) v2(115.91,32.41) v2(116.65,73.6) v2(116.62,3.83) v2(116.68,114.02) v2(116.98,9.16) v2(117.54,115.78) v2(117.68,73.31) v2(117.83,34.67) v2(117.82,33.35) v2(117.94,87.44) v2(117.98,130.96) v2(117.98,128.42) v2(117.98,125.88) v2(117.98,123.34) v2(117.98,120.8) v2(117.98,118.26) v2(118.08,9.07) v2(118.26,87.92) v2(118.51,94.65) v2(118.56,87.43) v2(118.75,88.29) v2(119.13,88.8) v2(119.11,87.64) v2(119.16,3.83) v2(119.33,88.24) v2(119.56,89.23) v2(119.8,132.4) v2(119.78,34.01) v2(119.75,32.77) v2(119.96,9.07) v2(120.35,109.75) v2(120.86,110.26) v2(120.98,134.96) v2(121.37,110.77) v2(121.64,137.39) v2(121.7,18.49) v2(121.7,15.34) v2(121.7,3.83) v2(121.84,9.07) v2(121.87,111.28) v2(122.84,81.63) v2(122.89,33.55) v2(123.27,16.91) v2(123.78,82.34) v2(123.9,88.17) v2(124.18,137.39) v2(124.24,3.83) v2(124.29,126.9) v2(124.29,126.26) v2(124.29,125.63) v2(124.29,124.99) v2(124.25,85.12) v2(124.3,46.61) v2(124.85,18.49) v2(124.85,15.34) v2(125.07,83.82) v2(125.3,33.93) v2(125.41,89) v2(125.48,6.79) v2(126.09,79.58) v2(126.23,88.02) v2(126.72,137.39) v2(126.78,3.83) v2(126.95,55.4) v2(126.95,54.76) v2(127.41,80.85) v2(127.52,128.97) v2(127.52,128.03) v2(127.72,33.81) v2(127.76,77.95) v2(128.22,32.54) v2(128.22,31.27) v2(128.84,128.97) v2(128.84,127.96) v2(128.84,126.95) v2(129.07,79.26) v2(129.26,137.39) v2(129.32,3.83) v2(129.88,134.39) v2(130.15,128.97) v2(130.15,127.96) v2(130.15,126.95) v2(130.55,80.66) v2(130.64,47.52) v2(131.47,128.97) v2(131.47,127.96) v2(131.47,126.95) v2(131.51,96.45) v2(131.51,95.66) v2(131.8,137.39) v2(131.81,33.81) v2(131.78,32.54) v2(131.86,3.83) v2(132.03,129.56) v2(132.03,128.93) v2(132.03,127.91) v2(132.03,126.9) v2(132.35,133.5) v2(132.35,128.42) v2(132.35,127.4) v2(132.35,126.32) v2(132.35,125.75) v2(132.35,125.18) v2(132.35,124.61) v2(132.35,124.04) v2(132.35,123.47) v2(132.35,122.9) v2(132.35,122.32) v2(132.35,121.75) v2(132.67,128.93) v2(132.67,127.91) v2(132.67,126.9) v2(132.92,133.5) v2(132.92,126.32) v2(132.92,125.75) v2(132.92,125.18) v2(132.92,124.61) v2(132.92,124.04) v2(132.92,123.47) v2(132.92,122.9) v2(132.92,122.32) v2(132.92,121.75) v2(132.99,128.42) v2(132.99,127.4) v2(133.3,128.93) v2(133.3,127.91) v2(133.3,126.9) v2(133.33,68.3) v2(133.49,133.5) v2(133.49,126.32) v2(133.49,125.75) v2(133.49,125.18) v2(133.49,124.61) v2(133.49,124.04) v2(133.49,123.47) v2(133.49,122.9) v2(133.49,122.32) v2(133.49,121.75) v2(133.62,128.42) v2(133.62,127.4) v2(133.94,128.93) v2(133.94,127.91) v2(133.94,126.9) v2(133.91,101.22) v2(133.91,100.45) v2(133.91,99.82) v2(133.91,99.24) v2(133.91,98.63) v2(133.91,98.04) v2(133.91,93.65) v2(133.91,92.2) v2(134.07,133.5) v2(134.07,126.32) v2(134.07,125.75) v2(134.07,125.18) v2(134.07,124.61) v2(134.07,124.04) v2(134.07,123.47) v2(134.07,122.9) v2(134.07,122.32) v2(134.07,121.75) v2(134.19,79.6) v2(134.19,78.41) v2(134.34,137.39) v2(134.32,129.37) v2(134.26,128.42) v2(134.26,127.4) v2(134.45,33.53) v2(134.4,3.83) v2(134.47,32.26) v2(134.68,46.42) v2(134.8,102.13) v2(134.89,128.97) v2(134.89,128.03) v2(135.62,97.99) v2(136.2,128.97) v2(136.2,127.96) v2(136.2,126.95) v2(136.24,81.5) v2(136.23,79.68) v2(136.25,97.99) v2(136.33,96.01) v2(136.27,78.51) v2(136.35,101.17) v2(136.35,99.85) v2(136.35,93.37) v2(136.39,92.17) v2(136.82,44.8) v2(136.88,137.39) v2(136.89,97.99) v2(136.94,96.01) v2(136.94,3.83) v2(137.14,35.61) v2(137.13,33.85) v2(137.24,134.39) v2(137.52,128.97) v2(137.52,127.96) v2(137.52,126.95) v2(137.57,97.99) v2(137.57,95.96) v2(137.73,48.02) v2(137.73,46.85) v2(138.13,95.96) v2(138.21,97.99) v2(138.69,101.93) v2(138.71,101.24) v2(138.69,100.48) v2(138.71,99.9) v2(138.83,128.97) v2(138.83,127.96) v2(138.83,126.95) v2(138.83,81.38) v2(138.84,80.22) v2(138.89,97.97) v2(138.88,79.02) v2(138.89,77.62) v2(139.42,137.39) v2(139.4,34.06) v2(139.4,32.79) v2(139.46,128.99) v2(139.53,126.45) v2(139.45,97.97) v2(139.51,71.55) v2(139.48,3.83) v2(139.65,129.63) v2(139.72,123.72) v2(139.72,123.15) v2(139.72,122.58) v2(139.72,122.01) v2(139.69,46.03) v2(139.84,133.5) v2(140.06,97.99) v2(140.16,126.45) v2(140.16,125.88) v2(140.29,123.72) v2(140.29,123.15) v2(140.29,122.58) v2(140.29,122.01) v2(140.31,94.16) v2(140.34,93.52) v2(140.42,133.5) v2(140.8,126.45) v2(140.8,125.88) v2(140.86,123.72) v2(140.86,123.15) v2(140.86,122.58) v2(140.86,122.01) v2(140.99,133.5) v2(141.03,99.16) v2(141,96.04) v2(140.97,94.16) v2(140.97,93.52) v2(141.05,98.32) v2(141.05,97.18) v2(141.18,101.39) v2(141.23,100.12) v2(141.43,123.72) v2(141.43,123.15) v2(141.43,122.58) v2(141.43,122.01) v2(141.56,133.5) v2(141.84,79.1) v2(141.88,129.69) v2(141.88,129.12) v2(141.88,128.55) v2(141.88,127.98) v2(141.91,77.92) v2(141.91,76.71) v2(141.96,137.39) v2(142,123.72) v2(142,123.15) v2(142,122.58) v2(142,122.01) v2(141.98,74.77) v2(142.02,3.83) v2(142.08,104.92) v2(142.08,104.22) v2(142.16,32.08) v2(142.45,33.14) v2(142.51,128.97) v2(142.51,128.03) v2(142.64,46.03) v2(142.64,44.58) v2(142.87,109.47) v2(142.87,108.82) v2(142.87,108.17) v2(142.87,107.52) v2(142.87,106.87) v2(142.87,106.22) v2(142.87,105.57) v2(143.66,106.22) v2(143.82,128.97) v2(143.82,127.96) v2(143.82,126.95) v2(144.35,99.21) v2(144.35,98.32) v2(144.35,97.31) v2(144.35,96.42) v2(144.35,95.4) v2(144.35,94.51) v2(144.35,93.5) v2(144.35,46.12) v2(144.5,137.39) v2(144.56,3.83) v2(144.86,134.39) v2(145.14,128.97) v2(145.14,127.96) v2(145.14,126.95) v2(145.06,33.43) v2(146.02,104.22) v2(145.98,71.04) v2(145.98,69.11) v2(145.96,67.35) v2(146.45,128.97) v2(146.45,127.96) v2(146.45,126.95) v2(146.56,34.19) v2(146.81,104.22) v2(146.8,81.02) v2(146.8,79.18) v2(146.77,47.65) v2(146.77,46.38) v2(146.77,45.11) v2(147.04,137.39) v2(147.02,128.99) v2(147.02,127.98) v2(147.02,126.96) v2(147.15,129.63) v2(147.1,3.83) v2(147.34,128.48) v2(147.34,127.47) v2(147.59,133.5) v2(147.59,124.36) v2(147.59,123.78) v2(147.59,123.21) v2(147.59,122.64) v2(147.59,122.07) v2(147.66,128.99) v2(147.66,127.98) v2(147.78,121.5) v2(147.97,128.48) v2(147.97,127.47) v2(148.04,33.42) v2(148.04,32.15) v2(148.1,124.1) v2(148.1,123.53) v2(148.1,122.96) v2(148.1,122.39) v2(148.06,34.69) v2(148.16,133.5) v2(148.29,128.99) v2(148.29,127.98) v2(148.29,126.96) v2(148.35,121.5) v2(148.38,104.22) v2(148.42,53.01) v2(148.61,128.48) v2(148.61,127.47) v2(148.61,122.07) v2(148.73,133.5) v2(148.75,98.3) v2(148.75,96.34) v2(148.7,93.5) v2(148.8,97.31) v2(148.77,95.4) v2(148.77,94.51) v2(148.93,128.99) v2(148.93,127.98) v2(148.93,126.96) v2(148.93,121.5) v2(149.24,128.48) v2(149.24,127.47) v2(149.18,122.07) v2(149.17,104.22) v2(149.31,133.5) v2(149.5,126.9) v2(149.5,121.5) v2(149.58,137.39) v2(149.56,129.56) v2(149.56,128.99) v2(149.56,127.98) v2(149.64,3.83) v2(149.75,122.07) v2(149.92,45.44) v2(150.13,128.97) v2(150.13,128.03) v2(150.74,104.22) v2(150.97,79.28) v2(151.08,32.28) v2(151.44,128.97) v2(151.44,127.96) v2(151.44,126.95) v2(151.53,104.22) v2(151.91,47.6) v2(151.87,31.63) v2(151.97,34.82) v2(152.12,137.39) v2(152.18,3.83) v2(152.48,134.39) v2(152.75,46.42) v2(152.76,128.97) v2(152.76,127.96) v2(152.76,126.95) v2(152.76,47.84) v2(152.75,45.31) v2(153.11,104.22) v2(153.24,99.21) v2(153.24,98.32) v2(153.24,97.31) v2(153.24,95.4) v2(153.24,94.51) v2(153.24,93.5) v2(153.27,96.42) v2(153.39,76.05) v2(153.66,71.65) v2(153.7,69.82) v2(153.89,104.22) v2(154.07,128.97) v2(154.07,127.96) v2(154.07,126.95) v2(154.45,133.5) v2(154.64,128.99) v2(154.64,127.98) v2(154.64,126.96) v2(154.63,47.49) v2(154.63,46.32) v2(154.64,45.13) v2(154.59,33.53) v2(154.61,32.33) v2(154.66,137.39) v2(154.72,3.83) v2(155.02,133.5) v2(154.96,128.48) v2(154.96,127.47) v2(154.96,126.45) v2(154.96,125.88) v2(154.96,125.31) v2(154.96,124.74) v2(154.96,122.13) v2(154.96,121.56) v2(155.28,128.99) v2(155.28,127.98) v2(155.28,126.96) v2(155.28,32.91) v2(155.53,126.45) v2(155.53,125.88) v2(155.53,125.31) v2(155.53,124.74) v2(155.53,122.13) v2(155.53,121.56) v2(155.47,104.22) v2(155.59,133.5) v2(155.59,128.48) v2(155.59,127.47) v2(155.91,128.99) v2(155.91,127.98) v2(155.91,126.96) v2(155.94,78.7) v2(156.1,122.13) v2(156.1,121.56) v2(156.16,133.5) v2(156.23,128.48) v2(156.23,127.47) v2(156.21,73.89) v2(156.25,104.22) v2(156.33,72.09) v2(156.55,128.99) v2(156.55,127.98) v2(156.47,6.69) v2(156.57,101.88) v2(156.57,100.61) v2(156.78,77.85) v2(156.79,46.17) v2(156.78,31.95) v2(157.2,137.39) v2(157.54,33.48) v2(157.69,99.27) v2(157.69,95.4) v2(157.69,94.77) v2(157.69,94.13) v2(157.69,93.5) v2(157.83,104.22) v2(158.05,76.6) v2(158.09,9.23) v2(158.25,46.25) v2(158.25,44.98) v2(158.44,32.04) v2(158.53,33.26) v2(158.62,104.22) v2(158.68,80.74) v2(159.03,101.98) v2(159.03,101.34) v2(159.03,100.71) v2(159.03,100.07) v2(159.09,94.26) v2(159.09,93.62) v2(159.34,99.44) v2(159.34,98.8) v2(159.34,98.19) v2(159.34,97.56) v2(159.34,96.92) v2(159.34,96.29) v2(159.34,95.65) v2(159.34,95.02) v2(159.56,79.9) v2(159.74,137.39) v2(159.85,34.06) v2(159.85,32.79) v2(159.99,81.27) v2(160.05,27.99) v2(160.1,132.23) v2(160.1,128.74) v2(160.1,128.17) v2(160.1,127.59) v2(160.1,126.96) v2(160.4,47.28) v2(160.39,45.8) v2(160.63,9.23) v2(160.67,128.74) v2(160.67,128.17) v2(160.67,127.59) v2(160.67,126.96) v2(160.67,126.39) v2(160.67,125.82) v2(160.67,125.25) v2(160.78,71.47) v2(160.77,70.22) v2(161.24,129.06) v2(161.24,128.42) v2(161.24,127.85) v2(161.24,127.28) v2(161.24,126.71) v2(161.24,126.13) v2(161.24,125.56) v2(161.24,124.99) v2(161.24,124.36) v2(161.28,80.06) v2(161.47,96.77) v2(162.28,137.39) v2(162.38,32.33) v2(162.59,34.24) v2(163.17,9.23) v2(163.66,81.32) v2(163.88,33.83) v2(164.82,137.39) v2(165.33,7.33) v2(165.33,4.79) v2(165.87,47.01) v2(165.87,45.62) v2(166.11,131.56) v2(166.11,129.44) v2(166.11,127.32) v2(166.32,32.04) v2(166.95,21.12) v2(167.36,137.39) v2(167.52,21.12) v2(167.88,3.83) v2(168.01,77.98) v2(168,45.77) v2(168.23,131.56) v2(168.23,129.44) v2(168.23,127.32) v2(168.2,109.14) v2(168.15,33.4) v2(168.44,77.55) v2(168.48,108.61) v2(168.76,109.4) v2(168.83,77.16) v2(168.95,45.93) v2(168.99,108.86) v2(169.09,44.63) v2(169.23,101.38) v2(169.82,106.19) v2(169.8,105.6) v2(169.9,137.39) v2(170.35,131.56) v2(170.35,129.44) v2(170.35,127.32) v2(170.38,103.98) v2(170.42,3.83) v2(170.77,86.81) v2(171.61,85.75) v2(172.02,31.8) v2(172.44,137.39) v2(172.39,84.86) v2(172.42,32.19) v2(172.8,32.61) v2(172.88,106.45) v2(172.96,3.83) v2(173.23,84.02) v2(173.44,106.42) v2(174.09,111.45) v2(174.33,110.94) v2(174.91,110.64) v2(174.98,137.39) v2(175.12,111.16) v2(175.5,3.83) v2(175.97,100.6) v2(176.35,100.17) v2(176.4,100.96) v2(176.57,27.53) v2(177,27.95) v2(177.23,133.9) v2(177.52,137.39) v2(178.04,3.83) v2(178.12,135.43) v2(178.12,132.37) v2(178.16,40.51) v2(178.83,107.71) v2(179.02,99.59) v2(179.27,108.07) v2(179.36,103.49) v2(179.44,99.99) v2(179.63,108.51) v2(179.88,135.43) v2(179.88,132.37) v2(179.94,103.5) v2(179.91,102.94) v2(179.96,101.93) v2(180.06,137.39) v2(180.58,3.83) v2(180.77,133.9) v2(181.19,100.08) v2(181.76,100.07) v2(182.6,137.39) v2(183.12,3.83) v2(184.05,100.63) v2(184.05,100.07) v2(184.05,99.51) v2(184.05,98.93) v2(184.61,105.92) v2(184.61,102.96) v2(184.64,100.63) v2(185.14,137.39) v2(185.66,3.83) v2(187.68,137.39) v2(188.2,3.83) v2(188.35,100.69) v2(188.4,99.57) v2(188.79,101.04) v2(189.62,98.8) v2(189.67,37.3) v2(189.67,36.66) v2(189.91,39.91) v2(189.98,45.18) v2(190.22,137.39) v2(190.25,98.79) v2(190.32,40.35) v2(190.56,115.58) v2(190.73,40.76) v2(190.74,3.83) v2(191.16,41.16) v2(191.52,46.05) v2(191.98,101.12) v2(192.76,137.39) v2(193.28,3.83) v2(193.58,98.62) v2(193.58,60.98) v2(193.76,58.8) v2(193.76,58.24) v2(194.14,60.98) v2(194.34,58.24) v2(194.32,57.64) v2(194.41,104.24) v2(194.47,69.88) v2(194.47,69.32) v2(194.91,58.47) v2(194.91,57.46) v2(195.3,137.39) v2(195.82,3.83) v2(195.89,45.46) v2(196.04,79.37) v2(196.08,102.74) v2(196.08,101.94) v2(196.08,101.14) v2(196.06,78.6) v2(196.22,58.47) v2(196.22,57.46) v2(196.22,56.46) v2(196.68,43.01) v2(196.7,41.96) v2(196.91,104.97) v2(196.91,101.14) v2(196.91,100.34) v2(196.93,96.09) v2(196.9,78.54) v2(197.16,107.41) v2(197.22,44.61) v2(197.53,58.47) v2(197.53,57.46) v2(197.53,56.46) v2(197.84,137.39) v2(198.15,121.4) v2(198.15,120.8) v2(198.36,3.83) v2(198.64,112.35) v2(198.58,81.85) v2(198.74,105.26) v2(198.79,121.42) v2(198.75,120.81) v2(198.85,57.39) v2(198.85,56.46) v2(198.98,83.31) v2(198.98,82.72) v2(199.21,113.98) v2(199.32,43.84) v2(199.32,42.5) v2(199.48,57.37) v2(199.48,56.82) v2(199.88,72.82) v2(199.88,72.24) v2(199.88,71.66) v2(199.88,71.07) v2(199.88,70.49) v2(200.11,62.33) v2(200.11,61.75) v2(200.11,61.16) v2(200.38,110.45) v2(200.74,62.33) v2(200.74,61.75) v2(200.74,61.16) v2(200.88,42.59) v2(200.9,3.83) v2(200.99,113.75) v2(201,58.57) v2(201.08,100.34) v2(201.08,79.46) v2(201.12,57.94) v2(201.13,43.89) v2(201.25,46.81) v2(201.38,62.33) v2(201.38,61.75) v2(201.38,61.16) v2(201.45,60.47) v2(201.45,59.84) v2(201.45,59.2) v2(201.63,58.57) v2(201.68,57.94) v2(201.89,42.15) v2(202.01,62.33) v2(202.01,61.75) v2(202.01,61.16) v2(202.02,60.48) v2(202.02,59.84) v2(202.02,59.21) v2(202.27,80.11) v2(202.25,58.61) v2(202.27,57.94) v2(202.31,56.67) v2(202.39,82.91) v2(202.79,108.59) v2(202.8,63.84) v2(202.87,58.52) v2(202.87,57.51) v2(202.87,56.5) v2(203.13,46.81) v2(203.44,3.83) v2(203.61,113.53) v2(204.04,63.78) v2(204.19,58.52) v2(204.19,57.51) v2(204.19,56.5) v2(204.41,104.24) v2(205.01,46.81) v2(205.46,137.39) v2(205.5,58.52) v2(205.5,57.51) v2(205.5,56.5) v2(205.57,73.35) v2(205.59,72.78) v2(205.59,72.18) v2(205.62,71.59) v2(205.62,71.02) v2(205.98,3.83) v2(206.44,40.9) v2(206.81,57.44) v2(206.81,56.5) v2(206.89,46.81) v2(206.95,96.24) v2(207.43,57.26) v2(207.43,56.7) v2(207.54,96.24) v2(207.82,82.1) v2(208,137.39) v2(207.98,61.49) v2(208.28,58.7) v2(208.52,3.83) v2(208.58,99.52) v2(208.74,61.49) v2(208.66,42.31) v2(208.77,46.81) v2(208.89,58.7) v2(208.92,58.09) v2(209.16,42.87) v2(209.42,113.44) v2(209.41,104.14) v2(209.47,115.25) v2(209.5,61.49) v2(209.5,58.7) v2(209.5,58.06) v2(209.71,41.04) v2(210.14,58.7) v2(210.14,58.06) v2(210.23,104.17) v2(210.2,56.7) v2(210.26,103.54) v2(210.54,137.39) v2(210.8,58.51) v2(210.8,57.51) v2(210.8,56.5) v2(211.03,42.98) v2(211.06,3.83) v2(211.21,71.71) v2(211.2,71.14) v2(211.69,64.82) v2(211.79,71.23) v2(211.91,106.14) v2(211.91,104.74) v2(212.12,58.51) v2(212.12,57.51) v2(212.12,56.5) v2(212.17,15.36) v2(212.26,112.95) v2(212.27,64.82) v2(212.6,120.76) v2(213.08,137.39) v2(213.2,121.4) v2(213.43,58.51) v2(213.43,57.51) v2(213.43,56.5) v2(213.44,15.34) v2(213.56,107.77) v2(213.56,105.85) v2(213.6,3.83) v2(214.48,86.12) v2(214.59,112.54) v2(214.75,57.43) v2(214.75,56.5) v2(214.71,42.95) v2(214.73,16.03) v2(215.09,38.22) v2(215.12,31.47) v2(215.31,57.25) v2(215.31,56.69) v2(215.33,16.02) v2(215.44,42.98) v2(215.47,61.49) v2(215.62,137.39) v2(215.58,30.4) v2(215.93,58.26) v2(215.93,57.7) v2(215.92,16.02) v2(216.06,61.49) v2(216.14,3.83) v2(216.2,113.5) v2(216.62,61.47) v2(216.57,58.26) v2(216.57,57.7) v2(216.98,99.44) v2(217.2,58.26) v2(217.2,57.7) v2(217.78,81.94) v2(218.16,137.39) v2(218.58,99.44) v2(218.68,3.83) v2(218.81,58.58) v2(219.38,74.54) v2(219.73,58.75) v2(220.18,99.44) v2(220.21,98.62) v2(220.18,96.95) v2(220.18,95.27) v2(220.7,137.39) v2(220.65,58.74) v2(220.78,92.77) v2(220.78,77.77) v2(221.22,3.83) v2(221.38,95.27) v2(221.38,93.62) v2(221.58,96.27) v2(221.61,80.27) v2(221.93,82.77) v2(223.24,137.39) v2(223.76,3.83) v2(224.61,45.38) v2(224.8,121.4) v2(224.8,120.8) v2(225.04,44.99) v2(225.4,121.4) v2(225.4,120.8) v2(225.47,44.57) v2(225.57,92.19) v2(225.78,137.39) v2(225.93,83.4) v2(226.14,57.03) v2(226.14,55.05) v2(226.32,86.62) v2(226.3,3.83) v2(227.07,83.14) v2(227.13,56.04) v2(227.42,92.6) v2(227.41,84.18) v2(227.52,86.62) v2(227.73,7.9) v2(228.12,57.03) v2(228.12,55.05) v2(228.32,137.39) v2(228.62,9.43) v2(228.62,6.37) v2(228.74,86.62) v2(228.84,3.83) v2(229.18,73.14) v2(230.38,9.43) v2(230.38,6.37) v2(230.81,92.08) v2(230.86,137.39) v2(231.27,7.9) v2(231.38,3.83) v2(231.71,46.38) v2(232.26,46.18) v2(232.25,45.63) v2(232.26,45.07) v2(233.05,6.06) v2(233.05,5.5) v2(233.4,137.39) v2(233.36,102.07) v2(233.92,3.83) v2(234.02,135.41) v2(235.15,132.46) v2(236.46,3.83) v2(237.02,130.84) v2(237.02,128.3) v2(237.02,125.76) v2(237.02,123.22) v2(237.02,120.68) v2(237.02,118.14) v2(237.2,11.53) v2(237.2,9.34) v2(237.74,115.11) v2(237.82,27.14) v2(238.29,10.43) v2(238.75,20.36) v2(238.75,19.77) v2(238.75,18.78) v2(238.76,18.17) v2(239,3.83) v2(239.08,112.9) v2(239.38,11.53) v2(239.38,9.34) v2(239.56,42.81) v2(240.12,42.8) v2(240.11,41.68) v2(240.15,26.82) v2(240.17,26.27) v2(240.45,54.33) v2(240.45,53.17) v2(240.72,27.02) v2(240.71,26.42) v2(240.86,111.06) v2(241.3,26.38) v2(241.44,27.49) v2(241.43,26.93) v2(241.45,53.75) v2(241.54,3.83) v2(242.02,27.49) v2(242.02,26.93) v2(242.42,42.32) v2(242.45,54.33) v2(242.45,53.17) v2(242.6,27.49) v2(242.6,26.93) v2(242.87,14.99) v2(243.09,109.62) v2(243.45,14.99) v2(244.02,42.59) v2(244.04,14.99) v2(244.08,3.83) v2(245.62,108.73) v2(245.67,42.2) v2(246.62,3.83) v2(246.7,59.6) v2(246.69,58.96) v2(246.69,58.33) v2(246.69,57.7) v2(246.69,57.03) v2(246.96,42.2) v2(246.97,8.34) v2(247.54,42.2) v2(247.55,8.34) v2(248.14,8.34) v2(248.47,108.45) v2(248.94,8.29) v2(248.97,7.73) v2(249.16,3.83) v2(249.45,27.67) v2(249.52,8.29) v2(249.64,33.62) v2(249.56,7.73) v2(249.68,33.07) v2(250.11,8.29) v2(250.14,7.73) v2(250.16,33.84) v2(250.26,33.07) v2(250.66,33.6) v2(250.69,8.29) v2(250.73,7.73) v2(250.83,33.07) v2(251.01,108.45) v2(251.26,33.58) v2(251.48,33.07) v2(251.51,3.92) v2(251.84,33.59) v2(252.04,33.07) v2(252.1,39.54) v2(252.54,85.21) v2(252.55,87.78) v2(252.73,90.33) v2(252.71,82.64) v2(252.68,39.54) v2(253.05,80.02) v2(253.05,92.83) v2(253.41,95.4) v2(253.4,68.9) v2(253.55,108.45) v2(253.69,76.93) v2(253.77,97.94) v2(254.12,100.46) v2(254.21,4.43) v2(254.33,74.65) v2(254.31,39.52) v2(254.49,103.04) v2(254.7,71.16) v2(254.7,66.65) v2(254.83,105.44) v2(255.16,107.95) v2(255.16,72.31) v2(255.19,13.86) v2(255.78,13.86) v2(255.97,39.94) v2(256.35,43.07) v2(256.36,13.86) v2(256.56,39.94) v2(256.75,4.43) v2(257.3,66.65) v2(258.27,66.03) v2(258.27,42.92) v2(258.4,41.3) v2(258.64,63.63) v2(259.32,3.83) v2(260,46.81) v2(260,46.23) v2(260.01,41.93) v2(260.13,61.62) v2(260.58,46.81) v2(260.58,46.23) v2(261.17,46.81) v2(261.17,46.23) v2(261.75,46.81) v2(261.75,46.23) v2(261.94,60.99) v2(261.86,41.52) v2(261.86,3.83) v2(262.33,46.81) v2(262.33,46.23) v2(262.29,41.93) v2(263.68,21.77) v2(264.26,21.77) v2(264.25,20.57) v2(264.4,3.83) v2(264.85,21.77) v2(265.26,19.28) v2(265.73,52.9) v2(265.84,19.28) v2(266.01,56.91) v2(266.32,44.51) v2(266.33,41.15) v2(266.62,54.43) v2(266.62,51.37) v2(266.6,42.88) v2(266.76,45.76) v2(266.9,44.51) v2(266.92,41.15) v2(266.94,3.83) v2(268.38,54.43) v2(268.38,51.37) v2(269.27,52.9) v2(269.48,3.83) v2(269.76,13.44) v2(269.79,12.88) v2(270.34,13.44) v2(270.38,12.88) v2(270.92,13.44) v2(270.96,53.28) v2(270.96,12.88) v2(271.51,13.44) v2(271.54,12.88) v2(272.02,3.83) v2(272.19,13.44) v2(272.23,12.88) v2(272.78,13.44) v2(272.81,12.88) v2(272.97,51.84) v2(273.36,13.44) v2(273.4,12.88) v2(273.87,49.42) v2(273.98,12.88) v2(274.38,39.1) v2(274.56,3.83) v2(275,39.1) v2(275.64,37.95) v2(276.44,48.3) v2(277.1,3.83) v2(278.74,45.24) v2(278.74,44.65) v2(279.24,44.96) v2(279.33,48.99) v2(279.64,3.83) v2(281.15,5.03) v2(281.47,48.75) v2(284.17,48.13) v2(285.31,21.45) v2(285.5,20.86) v2(285.65,22.52) v2(285.64,21.9) v2(285.87,21.39) v2(285.87,20.44) v2(286.18,20.92) v2(286.36,20.17) v2(286.72,47.74) v2(286.67,20.65) v2(286.99,20.19) v2(287.26,3.83) v2(289.27,47.51) v2(289.8,3.83) v2(291.93,47.44) v2(292.34,3.83) v2(293.05,23.2) v2(293.05,19.27) v2(293.93,7.9) v2(294.52,47.47) v2(294.82,9.43) v2(294.82,6.37) v2(294.88,3.83) v2(295.02,21.23) v2(295.02,19.27) v2(296.58,9.43) v2(296.58,6.37) v2(296.98,23.2) v2(296.98,19.27) v2(297.06,47.47) v2(297.42,3.83) v2(297.47,7.9) v2(299.22,10.29) v2(299.6,47.47) v2(299.96,3.83) v2(300.08,34.23) v2(300.06,33.54) v2(300.7,9.25) v2(301.02,10.42) v2(301.49,3.83) v2(302.14,47.47) v2(302.67,17.21) v2(303.6,38.06) v2(303.84,34.09) v2(303.84,33.47) v2(304.17,37.11) v2(304.61,17.49) v2(304.68,47.47) v2(304.77,19.28) v2(306.21,19.16) v2(306.19,17.06) v2(307.07,3.83) v2(307.22,47.47) v2(307.37,23.72) v2(307.43,21.95) v2(308.14,20.42) v2(308.14,13.99) v2(309.76,47.47) v2(310.12,3.83) v2(310.52,26.63) v2(311.5,29.33) v2(311.45,27.31) v2(312.24,47.47) v2(312.63,3.83) v2(313.17,46.79) v2(313.17,44.25) v2(313.17,41.71) v2(313.17,39.17) v2(313.17,36.63) v2(313.17,34.09) v2(313.17,31.55) v2(313.17,29.01) v2(313.17,26.47) v2(313.17,23.93) v2(313.17,21.39) v2(313.17,18.85) v2(313.17,16.31) v2(313.17,13.77) v2(313.17,11.23) v2(313.17,8.69) v2(313.17,6.15) v3(12.45,9.84) v3(14.61,124.93) v3(15.38,100.58) v3(31.25,50.86) v3(48.68,41.48) v3(60.03,7.71) v3(60.18,7.72) v3(75.73,8.93) v3(79.27,44.51) v3(109.31,93.29) v3(119.89,88.53) v3(139.59,96.92) v3(140.84,128.05) v3(144.66,121.96) v3(166.79,76.88) v3(167.89,130.16) v3(174.88,112.04) v3(193.44,63.12) v3(195.29,79.37) v3(227.28,55.45) v3(237.2,20.04) v3(238.56,11.14) v3(246.79,7.77) v3(250.91,34.19) v3(257.75,39.7) v3(260.65,45.3) v3(261.54,45.18) v3(273.65,12.33) v3(274.5,38.28) v3(286.9,21.23) v6(236.76,22.71) v6(236.76,22.1) v6(236.76,21.49) v6(236.78,20.85) v6(236.78,19.02) v6(236.78,18.36) v6(237.39,21.13) v6(237.42,18.92)
