# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_DPE_N3_C: length 2.3
  TOP w0.127: UT11.19 34.26,52.78 34.3,52.74 v4(34.84,52.74) 35.5,52.74 CT24.2
GPU_DPE_P0: length 229.6
  TOP w0.127: CT3.1 36.31,48.32 37.93,48.32 38.81,49.2 38.94,49.2 v2(39.16,48.99)
  IN1 w0.135: v2(39.16,48.99) 39.16,49.2 39.27,49.31 39.5,49.31 39.67,49.14 39.67,48.05 41.83,45.89 41.83,44.61 43.59,42.86 43.59,40.61 44.05,40.15 50.58,40.15 53.19,37.55 53.19,36.64 54.54,35.28 54.54,32.9 55.83,31.62 55.83,30.61 57.31,29.12 62.07,29.12 68.68,22.5 69.82,22.5 71.38,20.94 72.35,20.94 72.64,21.23 82.89,21.23 86.83,17.29 87.68,17.29 89.62,15.35 101.07,15.35 101.44,14.98 105.43,14.98 105.43,14.99 107.02,14.99 107.44,14.57 111.97,14.57 113.53,16.13 118.32,16.13 119.52,17.33 119.52,18.02 120.42,18.92 128.39,18.92 128.9,19.43 131.84,19.43 132.55,18.71 134.71,18.71 136.28,20.27 146.36,20.27 147.7,21.61 170.04,21.61 180.61,32.18 180.61,37.42 181.36,38.16 181.36,40.31 185.12,44.08 185.12,44.54 185.94,45.36 185.94,52.01 190.69,56.76 190.69,69.93 191.05,70.29 191.05,71.63 195.28,75.87 197.08,75.87 197.65,75.31 198.98,75.31 199.39,75.72 199.39,76.12 199.52,76.24 200.2,76.24 v2(200.29,76.15)
  BOTTOM w0.107: UG1.AD2 v2(200.29,76.15)
GPU_DPE_P0_C: length 2.3
  TOP w0.127: CT3.2 35.39,48.33 35.12,48.33 34.63,48.82 34.3,48.82 34.26,48.78 UT11.9
GPU_DPE_P1: length 234.2
  TOP w0.127: v2(38.04,49.5) 37.83,49.71 v4(37.36,49.71) 36.61,49.71 CT5.1
  IN1 w0.135: v2(200.29,75.35) 200.48,75.54 200.62,75.54 200.71,75.45 200.71,75.14 200.38,74.82 197.57,74.82 197.35,75.04 196.94,75.04 196.72,74.82 195.44,74.82 191.92,71.3 191.92,70.43 192.03,70.31 192.03,69.9 191.76,69.63 191.76,69.2 191.54,68.98 191.54,68.57 191.76,68.35 191.76,67.95 191.54,67.73 191.54,67.32 191.76,67.1 191.76,66.7 191.54,66.48 191.54,66.08 191.76,65.85 191.76,65.45 191.54,65.23 191.54,64.83 191.76,64.6 191.76,64.2 191.54,63.98 191.54,63.58 191.76,63.35 191.76,62.79 191.53,62.56 191.53,56.41 186.79,51.66 186.79,45.01 185.97,44.19 185.97,43.72 182.2,39.96 182.2,37.46 181.55,36.81 181.55,31.83 170.41,20.69 147.99,20.69 146.18,18.89 142.05,18.89 140.8,17.64 131.9,17.64 131.36,17.09 129.19,17.09 128.59,17.69 121.14,17.69 118.31,14.86 114.46,14.86 112.96,13.35 107.45,13.35 106.66,14.14 105.49,14.14 104.7,13.35 101.51,13.35 100.36,14.5 95.94,14.5 94.79,13.35 93.17,13.35 92.29,14.22 89.55,14.22 87.33,16.44 84.22,16.44 80.6,20.06 68.96,20.06 68.48,20.54 68.48,21.51 66.8,23.19 66.06,23.19 64.42,24.83 64.42,25.57 61.72,28.27 56.8,28.27 54.34,30.72 54.34,31.78 53.7,32.42 53.7,34.93 52.34,36.29 52.34,36.94 49.99,39.29 45.69,39.29 45.35,38.95 43.14,38.95 42.75,39.34 42.75,42.46 40.9,44.3 40.9,45.42 37.67,48.65 37.67,49.46 37.78,49.57 37.97,49.57 v2(38.04,49.5)
  BOTTOM w0.107: UG1.AD1 v2(200.29,75.35)
GPU_DPE_P1_C: length 2.4
  TOP w0.127: UT11.12 v4(34.84,49.98) 35.26,49.98 35.5,49.74 35.68,49.74 CT5.2
GPU_DPE_P2: length 243.2
  TOP w0.127: CT20.1 36.45,51.08 36.88,51.08 37.04,50.92 v4(37.73,50.92) 38.17,50.92 v2(38.44,50.64)
  IN1 w0.135: v2(38.44,50.64) 38.28,50.81 36.94,50.81 36.45,50.32 36.45,48.05 37.48,47.02 37.48,46.25 39.64,44.09 39.64,40.32 41.57,38.39 41.94,38.39 42.59,37.74 49.55,37.74 51.13,36.16 51.13,35.8 52.5,34.43 52.5,31.93 53.12,31.3 53.12,30.23 56.49,26.86 60.86,26.86 61.63,26.09 61.63,23.21 66.01,18.82 80.12,18.82 83.71,15.24 86.83,15.24 89.05,13.02 91.79,13.02 92.81,12 95.62,12 96.25,12.62 100.28,12.62 100.78,12.12 113.59,12.12 114.73,13.26 118.41,13.26 121.35,16.2 128.39,16.2 129.03,15.56 131.82,15.56 132.66,16.4 134.85,16.4 135.35,15.9 137.98,15.9 138.52,16.44 141.29,16.44 142.49,17.63 149.69,17.63 151.51,19.45 170.88,19.45 182.92,31.49 182.92,36.17 183.42,36.66 183.42,39.46 187.17,43.21 187.17,43.69 188.01,44.54 188.01,50.67 191.21,53.86 191.21,54.18 191.49,54.46 191.81,54.46 192.09,54.75 192.09,55.06 192.38,55.34 192.69,55.34 192.97,55.63 192.97,56.44 192.75,56.67 192.75,57.07 192.97,57.29 192.97,57.69 192.75,57.92 192.75,58.32 192.97,58.54 192.97,58.94 192.75,59.16 192.75,59.57 192.97,59.79 192.97,60.19 192.75,60.41 192.75,62.07 192.97,62.29 192.97,69.12 193.53,69.68 193.53,70.77 194.55,71.78 194.55,72.1 194.83,72.38 195.14,72.38 195.43,72.67 195.43,72.98 195.72,73.27 196.03,73.27 196.36,73.6 197.04,73.6 197.26,73.82 197.66,73.82 197.89,73.6 198.29,73.6 198.51,73.82 198.91,73.82 199.14,73.6 199.54,73.6 199.76,73.82 200.16,73.82 200.38,73.6 200.79,73.6 201.61,74.43 201.61,76.25 201.31,76.55 201.07,76.55 200.97,76.45 200.97,76.27 v2(201.09,76.15)
  BOTTOM w0.107: UG1.AC2 v2(201.09,76.15)
GPU_DPE_P2_C: length 2.3
  TOP w0.127: UT11.15 34.19,51.18 34.27,51.26 v4(34.84,51.26) 35.22,51.26 35.36,51.12 35.58,51.12 CT20.2
GPU_DPE_P3: length 230.7
  TOP w0.127: CT22.1 36.58,52.35 36.66,52.42 36.66,52.6 36.72,52.66 v4(37.72,52.66) 38.86,52.66 39.06,52.46 39.06,52.24 39.4,51.9 39.62,51.9 39.96,51.57 39.96,51.37 40.32,51 40.52,51 40.86,50.67 40.86,50.47 41.22,50.11 41.42,50.11 41.69,49.84 41.69,49.52 41.47,49.3 41.27,49.3 v2(41.15,49.42)
  IN1 w0.135: v2(41.15,49.42) 41.15,49.2 40.91,48.97 40.91,48.52 41.72,47.72 42.77,47.72 44.06,46.43 48.65,46.43 50.21,44.87 50.21,42.44 54.39,38.25 54.39,37.13 55.75,35.78 55.75,33.94 57.23,32.45 57.23,30.98 57.89,30.32 62.6,30.32 69.21,23.71 70.32,23.71 71.18,22.85 72.49,22.85 72.87,22.47 83.43,22.47 87.41,18.49 88.18,18.49 90.1,16.57 107.2,16.57 107.91,15.86 111.56,15.86 113.54,17.84 116.71,17.84 117.36,18.5 118.31,18.5 120.1,20.3 128.07,20.3 128.56,20.79 132.18,20.79 132.67,20.3 134.37,20.3 135.69,21.62 139.29,21.62 140.64,22.97 164.62,22.97 164.79,22.81 169.54,22.81 177.59,30.85 177.59,31.53 179.4,33.34 179.4,38.11 180.14,38.85 180.14,40.84 183.92,44.62 183.92,45.06 184.74,45.88 184.74,52.51 188.67,56.44 188.67,58.68 189.49,59.5 189.49,70.67 189.83,71.02 189.83,72.12 195.11,77.39 197.16,77.39 197.6,77.83 201.01,77.83 v2(201.09,77.75)
  BOTTOM w0.107: UG1.AC4 v2(201.09,77.75)
GPU_DPE_P3_C: length 2.2
  TOP w0.127: UT11.18 34.26,52.38 34.3,52.42 35.67,52.42 CT22.2
GPU_EVENT#: length 98.4
  TOP w0.127: v2(233.65,52.15) 233.36,52.45 233.36,54.26 233.87,54.78 233.87,58.39 233.29,58.98 233.29,59.32 232.79,59.81 232.61,59.81 232.35,59.81 232.01,60.15 232.01,60.15 231.61,60.55 231.61,60.55 231.49,60.67 228.08,60.67 227.37,61.38 226.9,61.38 226.19,60.67 225.29,60.67 225.28,60.68 224.81,60.68 224.25,60.12 222.78,60.12 221.37,61.53 221.37,63.23 221.69,63.55 223.76,63.55 DG243.1 ; v2(219.8,19.26) v1(221.06,19.26) 221.49,19.26 222.82,17.93 v2(223.27,17.93)
  TOP w0.135: RH186.1 200.51,22.22 200.03,22.22 v2(199.93,22.33)
  IN1 w0.127: v2(219.8,19.26) 219.72,19.34 218.99,19.34 218.62,18.97 215.57,18.97 215.1,19.45 214.42,19.45 213.91,18.93 211.67,18.93 211.61,19 209.45,19 208.6,19.86 207.02,19.86 206.71,20.18 206.71,20.52 206.04,21.19 206.04,23.09 205.97,23.17 205.97,23.28 204.01,25.25 201.09,25.25 200.59,24.75 200.59,22.66 200.27,22.33 v2(199.93,22.33)
  IN3 w0.127: v2(233.65,52.15) 234.15,51.66 234.15,50.54 233.59,49.98 233.59,48.99 234.13,48.45 234.13,47.69 233.68,47.24 233.68,41.67 226.05,34.03 226.05,31.41 222.43,27.8 222.43,18.76 v2(223.27,17.93)
GPU_EVENT#_1: length 24.1
  TOP w0.127: v2(213.23,74.36) 213.12,74.25 213.12,72.63 217.08,68.67 220.32,68.67 220.83,68.15 222.11,68.15 v1(223.62,66.63) 224.15,66.1 DG243.2 224.15,65.06 RG400.2
  BOTTOM w0.109: UG1.L6 211.87,79.4 211.87,75.78 213.23,74.42 v2(213.23,74.36)
GPU_EVENT#_R: length 6.2
  TOP w0.127: v2(202.57,22.72) 202.74,22.56 202.74,22 202.52,21.78 202.05,21.78 v1(201.85,21.98)
  TOP w0.135: v2(202.57,22.72) 202.39,22.91 RH186.2 RH192.2
  BOTTOM w0.127: UH1.AW26 202.53,21.75 202.72,21.95 202.72,22.57 v2(202.57,22.72)
GPU_HDMI_CTRLCLK: length 270
  TOP w0.127: QV2.4 20.15,69.32 RV36.1 19.97,70.48 19.97,71.6 19.59,71.98 18.34,71.98 v1(17.83,71.48) 16.62,70.26 16.62,69.11 17.3,68.43 v2(17.83,68.43)
  IN1 w0.127: v2(17.83,68.43) 17.52,68.43 17.28,68.19 17.28,64.71 19.94,62.04 19.94,48.86 20.81,47.99 23.14,47.99 23.34,48.2 26.17,48.2 27.64,46.73 28.03,46.73 28.49,46.26 31.45,46.26 31.6,46.41 34.87,46.41 37.91,43.38 37.91,37.58 39.49,36 44.49,36 45.08,35.41 47.57,35.41 48.07,35.92 49.06,35.92 49.54,35.43 49.54,34.51 49.95,34.11 49.95,32.41 51.66,30.69 51.66,29.6 56.11,25.16 v2(58.99,25.16)
  IN2 w0.127: v2(198.58,76.94) 197.8,76.15 193.54,76.15 v2(192.75,76.94) ; v2(92.99,59.45) 92.99,57.78 87.05,51.84 87.05,47.24 84.9,45.09 83.11,45.09 80.66,42.64 78.33,42.64 78.12,42.44 68.99,42.44 67.14,40.59 63.66,40.59 63.09,40.02 63.09,34.1 62.55,33.55 56.91,33.55 55.91,32.55 55.91,29.3 57.5,27.71 57.5,26.86 57.95,26.41 58.41,26.41 59.03,25.78 59.03,25.2 v2(58.99,25.16)
  BOTTOM w0.127: v2(192.75,76.94) 192.1,76.94 191.6,76.45 186.77,76.45 185.47,75.15 183.19,75.15 177.49,80.86 174.54,80.86 159.53,65.84 101.25,65.84 94.87,59.45 v2(92.99,59.45) ; UG1.AG3 v2(198.58,76.94)
GPU_HDMI_CTRLDAT: length 259.4
  TOP w0.127: QV2.1 18,67.21 RV37.1 17.79,67.25 v2(17.79,67.81) 17.1,67.81 v1(16.97,67.94)
  IN1 w0.127: v2(58.61,25.61) 58.42,25.42 56.22,25.42 51.92,29.71 51.92,30.8 50.21,32.51 50.21,34.21 49.81,34.62 49.81,35.54 49.15,36.2 47.98,36.2 47.46,35.67 45.19,35.67 44.6,36.26 39.6,36.26 38.17,37.69 38.17,43.49 34.98,46.68 31.49,46.68 31.34,46.52 28.6,46.52 28.14,46.99 27.75,46.99 26.28,48.46 23.24,48.46 23.03,48.26 20.91,48.26 20.2,48.97 20.2,62.33 19.6,62.93 19.6,64.76 19.21,65.15 19.21,66.39 v2(17.79,67.81)
  IN2 w0.127: v2(191.97,76.18) 192.21,76.41 192.86,76.41 193.49,75.78 198.24,75.78 v2(198.59,76.13) ; v2(58.61,25.61) 58.08,26.14 57.84,26.14 57.23,26.74 57.23,27.6 55.64,29.19 55.64,32.66 56.8,33.82 62.43,33.82 62.82,34.21 62.82,40.13 63.55,40.86 67.03,40.86 68.87,42.71 78.01,42.71 78.22,42.91 80.55,42.91 83,45.36 84.78,45.36 86.79,47.36 86.79,51.95 92.51,57.68 v2(92.51,58.94)
  BOTTOM w0.127: v2(191.97,76.18) 191.97,76.19 186.87,76.19 185.58,74.89 183.09,74.89 177.38,80.6 174.65,80.6 159.63,65.58 101.36,65.58 94.72,58.94 v2(92.51,58.94) ; UG1.AG2 v2(198.59,76.13)
GPU_HDMI_TX0N: length 196.2
  BOTTOM w0.076: 197.54,75.11 197.54,75.13 197.46,75.21 197.46,75.96 197.8,76.3 197.8,77.54 197.33,78.01 UG1.AH4
  BOTTOM w0.102: CV39.1 24.25,55.33 24.25,54.97 24.71,54.52 25.31,54.52 26.42,53.41 29.49,53.41 v5(29.92,53.83) 30.66,54.57 33.43,54.57 33.71,54.85 35.91,54.85 36.83,53.94 37.63,53.94 39.76,51.81 40.38,51.81 44.86,47.33 49.22,47.33 52.25,44.3 62.44,44.3 63.38,43.36 69.88,43.36 71.4,44.88 72.65,44.88 74.11,45.57 74.12,45.58 74.16,45.6 74.16,45.6 75.61,46.28 82.72,49.41 90.07,49.41 90.71,48.78 94.71,48.78 100.89,54.96 105.4,54.96 113.71,63.26 161.46,63.26 168.75,70.55 177.97,70.55 179.78,72.36 186.2,72.36 187.69,73.86 196.56,73.86 197.54,74.84 197.54,75.11
GPU_HDMI_TX0N_C: length 2.2
  BOTTOM w0.102: CV39.2 24.36,56.69 24.36,56.95 24.92,57.5 24.92,57.73 24.86,57.79 UV2.45
GPU_HDMI_TX0P: length 196.2
  BOTTOM w0.076: 197.24,75.04 197.24,75.13 197.31,75.21 197.31,76.03 197.65,76.36 197.65,77.47 197.35,77.77 197.02,77.77 196.92,77.67 196.92,77.47 197.05,77.34 UG1.AH3
  BOTTOM w0.102: 197.24,75.04 197.24,74.97 196.43,74.17 187.57,74.17 186.07,72.67 179.66,72.67 177.84,70.85 168.62,70.85 161.33,63.56 113.58,63.56 105.28,55.26 100.76,55.26 94.58,49.08 90.83,49.08 90.2,49.72 82.66,49.72 75.48,46.56 75.48,46.56 73.99,45.85 73.99,45.85 73.98,45.85 72.58,45.18 71.27,45.18 69.75,43.66 63.51,43.66 62.57,44.61 52.38,44.61 49.35,47.63 44.99,47.63 40.5,52.11 39.88,52.11 37.75,54.24 36.95,54.24 36.04,55.16 33.59,55.16 33.31,54.88 30.53,54.88 29.36,53.71 v5(27.25,53.71) 26.54,53.71 25.44,54.82 24.84,54.82 24.56,55.1 24.56,55.42 24.64,55.5 CV38.1
GPU_HDMI_TX0P_C: length 2.2
  BOTTOM w0.102: CV38.2 24.67,56.72 24.67,56.82 25.22,57.38 25.22,57.73 25.26,57.77 UV2.44
GPU_HDMI_TX1N: length 190.6
  BOTTOM w0.076: UG1.AJ2 196.31,76.71 196.24,76.71 196.15,76.62 196.15,76.34 196.28,76.21 196.68,76.21 196.94,75.94 196.95,75.88 197,75.47 196.78,75.25 196.73,75.2 196.73,75.09 196.72,75.08
  BOTTOM w0.102: 196.72,75.08 196.14,74.5 191.35,74.5 191.19,74.66 187.49,74.66 186.13,73.3 179.72,73.3 177.67,71.26 168.4,71.26 161.18,64.04 101.97,64.04 95.23,57.3 92.24,57.3 89.16,54.65 85.56,51.92 83.58,50.82 81.65,49.82 72.38,45.59 71.06,45.59 69.54,44.07 63.68,44.07 62.74,45.01 52.54,45.01 49.52,48.04 46.93,48.04 45.08,49.89 43.3,49.89 40.67,52.52 40.05,52.52 37.92,54.65 37.12,54.65 36.21,55.56 33.42,55.56 33.14,55.28 v5(31.06,55.28) 30.36,55.28 29.67,54.59 26.57,54.59 26.16,55 26.16,55.33 CV37.1
GPU_HDMI_TX1N_C: length 2
  BOTTOM w0.102: UV2.42 26.06,57.78 26.14,57.71 26.14,57.04 26.31,56.88 26.31,56.73 CV37.2
GPU_HDMI_TX1P: length 190.6
  BOTTOM w0.076: 196.5,75.29 196.61,75.29 196.84,75.53 196.8,75.87 196.61,76.06 196.22,76.06 196,76.28 196,76.68 196.18,76.86 196.36,76.86 196.48,76.98 UG1.AJ3
  BOTTOM w0.102: 196.5,75.29 196.01,74.8 191.48,74.8 191.32,74.96 187.36,74.96 186,73.61 179.59,73.61 177.55,71.56 168.27,71.56 161.06,64.35 101.85,64.35 95.1,57.6 92.12,57.6 88.97,54.89 85.4,52.18 83.43,51.09 81.51,50.09 72.31,45.9 70.93,45.9 69.41,44.37 63.8,44.37 62.86,45.32 52.67,45.32 49.64,48.34 47.05,48.34 45.2,50.19 43.43,50.19 40.8,52.83 40.18,52.83 38.05,54.95 37.25,54.95 36.33,55.87 33.29,55.87 33.01,55.59 30.24,55.59 29.54,54.9 v5(28.41,54.9) 26.7,54.9 26.47,55.12 26.47,55.4 26.57,55.5 CV36.1
GPU_HDMI_TX1P_C: length 2
  BOTTOM w0.102: UV2.41 26.46,57.78 26.44,57.75 26.44,57.71 26.45,57.71 26.45,57.17 26.61,57 26.61,56.68 CV36.2
GPU_HDMI_TX2N: length 186.1
  BOTTOM w0.102: CV35.1 31.55,56.59 31.78,56.59 32.33,56.05 32.9,56.05 33.12,56.27 36.5,56.27 v5(36.94,55.84) 37.42,55.36 38.22,55.36 40.34,53.24 41,53.24 43.56,50.69 45.29,50.69 46.22,49.75 47.14,49.75 48.13,48.76 49.81,48.76 51.98,46.59 55.02,46.59 55.88,45.72 70.1,45.72 70.73,46.35 72.14,46.35 76.71,48.4 81.23,50.43 84.64,52.24 88.18,54.8 89.34,55.75 89.35,55.75 89.73,56.08 89.73,56.09 91.18,57.4 91.81,58.04 94.95,58.04 101.69,64.78 160.86,64.78 167.04,70.96 167.04,71.86 174.48,79.3 177.55,79.3 182.75,74.09 185.91,74.09 187.21,75.38 191.57,75.38 191.86,75.09 196,75.09 196.33,75.43 196.33,75.59 UG1.AJ1
GPU_HDMI_TX2N_C: length 4.5
  BOTTOM w0.102: UV2.39 27.26,57.78 27.31,57.73 27.31,57.21 27.6,56.92 v5(28.03,56.92) 29.63,56.92 29.97,56.58 30.21,56.58 CV35.2
GPU_HDMI_TX2P: length 186.1
  BOTTOM w0.102: UG1.AK1 195.98,75.74 196.03,75.7 196.03,75.55 195.87,75.4 191.99,75.4 191.7,75.69 187.08,75.69 185.78,74.39 182.88,74.39 177.67,79.6 174.36,79.6 166.74,71.98 166.74,71.08 160.74,65.08 101.56,65.08 94.82,58.34 91.69,58.34 90.97,57.62 89.53,56.31 89.15,55.99 88,55.04 84.48,52.5 81.09,50.71 72.08,46.66 70.6,46.66 69.97,46.03 56.01,46.03 55.14,46.89 52.1,46.89 49.93,49.06 48.26,49.06 47.26,50.06 46.35,50.06 45.41,50.99 43.68,50.99 41.13,53.54 40.47,53.54 38.34,55.67 37.54,55.67 36.63,56.58 v5(34.65,56.58) 33,56.58 32.77,56.35 32.45,56.35 31.91,56.9 31.48,56.9 31.33,57.05 CV34.1
GPU_HDMI_TX2P_C: length 4.5
  BOTTOM w0.102: UV2.38 27.66,57.74 27.62,57.7 27.62,57.33 27.73,57.22 v5(29.27,57.22) 29.76,57.22 30.1,56.88 30.46,56.88 30.59,57.01 30.59,57.17 CV34.2
GPU_HDMI_TXCN: length 202.2
  BOTTOM w0.076: 199.54,75.49 199.54,75.51 199.47,75.59 199.47,77.55 199.21,77.81 197.99,77.81 197.81,77.99 197.81,78.2 197.92,78.32 198.01,78.32 UG1.AG4
  BOTTOM w0.102: 199.54,75.49 199.54,75.29 199.04,74.79 198.21,74.79 196.78,73.35 192.73,73.35 192.45,73.07 187.91,73.07 186.44,71.6 180.03,71.6 178.26,69.83 169.1,69.83 161.77,62.5 114.02,62.5 105.76,54.24 101.17,54.24 94.93,47.99 81.42,47.99 77.37,46.26 72.82,44.12 71.74,44.12 70.27,42.65 55.3,42.65 54.92,42.27 53.27,42.27 48.93,46.62 44.56,46.62 40.08,51.1 39.44,51.1 37.86,52.68 36.7,52.68 35.24,54.14 v5(34.7,54.14) 34.01,54.14 33.73,53.86 30.95,53.86 29.79,52.7 25.36,52.7 24.1,53.96 22.99,53.96 22.49,54.46 22.49,55.19 CV41.1
GPU_HDMI_TXCN_C: length 2.6
  BOTTOM w0.102: CV41.2 22.51,56.75 22.51,57.01 23.04,57.53 23.39,57.53 23.66,57.8 UV2.48
GPU_HDMI_TXCP: length 202.2
  BOTTOM w0.076: 199.24,75.49 199.24,75.51 199.31,75.59 199.31,77.49 199.15,77.66 197.92,77.66 197.65,77.93 197.65,78.26 197.86,78.47 198.4,78.47 198.46,78.53 198.46,78.66 UG1.AG5
  BOTTOM w0.102: CV40.1 22.8,55.23 22.8,54.59 23.12,54.27 24.22,54.27 25.49,53 29.66,53 30.83,54.17 v5(32.58,54.17) 33.6,54.17 33.88,54.45 35.36,54.45 36.83,52.98 37.99,52.98 39.57,51.4 40.21,51.4 44.69,46.92 49.05,46.92 53.4,42.57 54.79,42.57 55.17,42.95 70.14,42.95 71.61,44.42 72.75,44.42 77.24,46.54 81.36,48.3 94.8,48.3 101.05,54.54 105.63,54.54 113.89,62.8 161.64,62.8 168.98,70.14 178.13,70.14 179.9,71.91 186.31,71.91 187.79,73.38 192.32,73.38 192.6,73.66 196.65,73.66 198.08,75.09 198.91,75.09 199.24,75.42 199.24,75.49
GPU_HDMI_TXCP_C: length 2.6
  BOTTOM w0.102: UV2.47 24.06,57.77 23.87,57.57 23.52,57.22 23.16,57.22 22.82,56.88 22.82,56.66 CV40.2
GPU_I2C_8409_CLK: length 15.6
  TOP w0.127: RV41.2 23,66.24 v1(23.34,66.59) 23.56,66.81 v2(25.6,66.81) ; v2(29.91,59.91) 30.11,59.71 RV34.2
  IN1 w0.127: v2(29.91,59.91) 29.95,59.91 30.36,60.33 30.36,60.73 29.87,61.22 29.51,61.22 29.3,61.43 29.3,63.59 27.84,65.06 27.84,65.77 26.79,66.81 v2(25.6,66.81)
  BOTTOM w0.127: v2(29.91,59.91) 29.88,59.88 UV2.34
GPU_I2C_8409_DAT: length 21.1
  TOP w0.127: v2(29.86,60.5) 29.88,60.48 RV35.2 ; RV42.2 18.72,70.53 v2(18.98,70.79) 19.32,70.79 v1(19.61,71.08)
  IN1 w0.127: v2(29.86,60.5) 29.04,61.32 29.04,63.48 27.57,64.95 27.57,65.66 27.24,66 22.48,66 20.03,68.45 18.98,69.5 v2(18.98,70.79)
  BOTTOM w0.127: v2(29.86,60.5) 29.7,60.5 29.48,60.28 UV2.33
GPU_OVERT#: length 339.8
  TOP w0.127: v2(278.62,11.92) 278.62,12.77 278.24,13.15 278.24,15.25 279.72,16.73 v1(279.72,20.85) 279.72,21.5 278.2,23.02 278.2,24.01 278.45,24.26 278.45,25.65 284.36,31.56 291.78,31.56 292.35,32.13 292.35,34.55 291.48,35.42 v2(290.9,35.42) ; v2(144.06,9.81) 144.07,9.79 144.07,9.68 144.44,9.31 UK1.19
  IN2 w0.127: v2(190.28,82.78) 190.56,82.5 190.56,81.11 191.09,80.59 191.09,79.14 190.84,78.89 190.84,77.55 190.33,77.04 190.33,74.51 191.19,73.65 191.19,69.89 191.51,69.57 191.51,54.61 195.17,50.95 221,50.95 223.91,48.04 231.39,48.04 231.55,47.88 232.51,47.88 232.92,47.48 234.02,47.48 234.77,48.22 234.77,48.75 235.06,49.04 235.99,49.04 237.74,47.29 v2(238.18,47.29) 238.66,47.29 239.02,46.93 239.02,44.5 239.9,43.62 249.18,43.62 250.06,42.74 253.66,42.74 255.51,40.88 257.03,40.88 257.97,39.95 272.35,39.95 272.62,40.23 279.93,40.23 280.55,39.6 284.33,39.6 286.68,37.25 289.83,37.25 290.9,36.18 v2(290.9,35.42)
  IN3 w0.127: v2(278.62,11.92) 277.69,11.92 275.53,14.09 275.53,14.9 274.55,15.88 265.07,15.88 263.76,14.57 257.76,14.57 256.93,15.41 245.97,15.41 245.05,14.49 241.05,14.49 240.56,14.98 238.27,14.98 236.63,13.34 234.7,13.34 233.94,12.58 231.2,12.58 230.08,11.47 227.99,11.47 225.82,9.3 v2(225.36,9.3)
  BOTTOM w0.127: v2(238.18,47.29) 238.18,46.42 237.77,46.02 237.77,45.52 236.57,44.32 236.57,43.66 235.79,42.87 DG7.1 ; v2(190.28,82.78) 189.87,83.18 185.84,83.18 185.77,83.11 RG392.1 185.53,83.11 185.12,83.51 QG1.3 ; v2(144.06,9.81) 144.14,9.81 145.1,8.85 149.5,8.85 152.44,11.8 162.91,11.8 164.31,10.4 166.46,10.4 168.14,8.73 168.14,5.89 168.43,5.59 169.65,5.59 170.13,5.11 223.64,5.11 225.51,6.98 225.51,9.16 v2(225.36,9.3)
GPU_PEX_RST_HOLD#: length 49.6
  TOP w0.102: v2(207.75,81.02) 208.18,80.59 208.18,79.98 208.34,79.81 208.81,79.81 209.06,79.57 209.06,78.65 209.84,77.86 209.84,77.33 209.96,77.21 209.96,76.54 211.71,74.79 213.38,74.79 213.64,74.52 213.64,74.17 213.95,73.86
  TOP w0.127: 213.95,73.86 213.95,72.54 216.53,69.96 222.2,69.96 223.28,68.88 v1(223.39,68.88) 223.54,68.88 225.75,66.67 225.75,63.58 225.15,62.98 224.63,62.98 224.32,63.29 222.08,63.29 221.84,63.05 RG38.2 222.47,62.87 v2(222.5,62.9)
  IN1 w0.127: v2(234.5,59.47) 232.56,61.41 230.02,61.41 228.63,62.8 224.38,62.8 224.09,63.09 222.69,63.09 v2(222.5,62.9)
  BOTTOM w0.127: UG13.2 v2(234.5,59.47) ; UG1.T8 v2(207.75,81.02)
GPUCORE_EN: length 7.7
  BOTTOM w0.254: QG17.5 236.54,40.1 RG105.1 237.32,40.66 DG5.1 237.11,41.55 DG4.2 236.99,42.22 236.98,42.23 DG7.2 236.98,43.46 236.97,43.48 UG10.4 237.05,44.18 RG103.1
GPUCORE_EN#: length 5.7
  BOTTOM w0.127: v1(236.13,35.88) RG214.1 ; RG214.1 236.54,37.31 QG17.2 ; RG214.1 235.89,37.13 QG17.3 235.89,38.32 235.73,38.48 234.93,38.48 234.71,38.26 QG16.2
GS_SDO_SA0: length 4.9
  TOP w0.127: v1(180.99,42.47) 180.29,43.17 180.29,44.02 179.89,44.42 R5802.1 179.07,44.42 R5801.2
  TOP w0.254: U9.3 178.71,45.15 179.04,44.82 R5801.2
GSEN_I2CLK: length 1.7
  TOP w0.254: U9.1 177.71,45.44 177.26,45 R5800.2
GSEN_I2DAT: length 2.6
  TOP w0.254: U9.4 179.94,45.97 v1(180.32,45.59) 180.77,45.14 R5799.2
GSPI0_MOSI: length 4.5
  BOTTOM w0.102: UH1.BE30 200.37,18.75 200.37,18.18 200.45,18.11 200.45,16.74
  BOTTOM w0.127: 200.45,16.74 200.45,16.18 200.94,15.69 RH94.2
GSPI1_MOSI: length 3.2
  TOP w0.127: RH96.2 202.27,19.2 202.15,19.31 202.15,20.57 v1(202.27,20.69) 202.57,20.99 v2(202.57,21.14)
  BOTTOM w0.127: UH1.BA26 202.42,20.99 v2(202.57,21.14)
H_CPUPWRGD: length 232.4
  TOP w0.127: v2(212.7,29.19) v3(212.1,29.19)
  IN2 w0.127: v2(212.7,29.19) 212.2,29.68 210.54,29.68 210.04,30.18 210.04,31 210.1,31.06 210.1,31.9 209.54,32.46 208.75,32.46 208.5,32.7 208.5,33.31 208.02,33.79 207.66,33.79 207.32,34.13 207.32,36.19 207.4,36.26 207.4,37.3 206.57,38.13 206.57,38.28 206.19,38.66 204.94,38.66 204.17,37.89 202.83,37.89 201.5,39.23 200.96,39.23 200.59,38.86 197.88,38.86 197.29,38.26 196.8,38.26 196.34,38.72 194.63,38.72 193.69,37.78 193.69,36.96 192.05,35.32 188.79,35.32 188.56,35.55 186.66,35.55 185.49,34.37 185.49,31.95 183.78,30.24 182.05,30.24 180.46,28.65 176.18,28.65 171.64,24.11 164.17,24.11 164.02,23.95 152.05,23.95 151.18,23.09 142.28,23.09 141.99,23.38 137.65,23.38 136.77,22.49 134.67,22.49 134.08,23.09 132.95,23.09 131.91,22.05 128.88,22.05 128.64,21.81 116.96,21.81 116.29,21.14 112.64,21.14 109.57,24.21 107.75,24.21 106.63,25.32 v2(106.63,25.57)
  IN3 w0.127: 112.54,86.76 111.15,85.36 arc(109.74,83.38) 109.06,81.05 arc(109.02,80.63) 109.01,80.21 arc(109.01,80.06) 109.01,79.92 109.01,79.16 103.13,73.29 103.13,72.62 102.65,72.14 102.65,70.83 101.23,69.41 101.23,68.29 99.84,66.91 99.22,65.78 98.81,65.02 98.03,63.61 98.03,59.68 98.37,59.34 98.37,56.92 97.61,56.16 97.61,46.94 98.86,45.69 98.86,44.42 100.85,42.43 100.85,37.08 99.52,35.75 99.52,31.36 101.63,29.25 102.72,29.25 105.19,26.78 106.03,26.78 106.63,26.18 v2(106.63,25.57) ; 112.54,86.76 113.32,87.54 114.14,88.36 ; 112.54,86.76 114.14,88.36 ; v2(124.16,104.29) 122.76,102.89 121.87,102.89 121.24,102.26 121.24,101.56 122.2,100.6 122.2,99.41 121.26,98.47 121.26,95.34 120.12,94.21 120.12,92.63 115.85,88.36 114.14,88.36
  BOTTOM w0.102: UC1.BT31 127.19,104.59 125.09,104.59 124.78,104.29 v2(124.16,104.29)
  BOTTOM w0.127: UH1.AE3 213.06,28.83 v2(212.7,29.19) ; CC157.2 v2(124.16,104.29)
H_PECI: length 275.2
  TOP w0.127: v2(151.91,5.11) 151.91,5.8 154.75,8.65 154.75,9.29 156.42,10.95 167.25,10.95 169.24,8.96 169.24,7.89 170.04,7.09 170.04,5.53 170.51,5.06 206.04,5.06 219.01,5.06 224.11,10.16 224.11,14.67 225.11,15.68 225.11,19.11 v1(223.54,20.68) 219.05,20.68 218.3,21.43 218.3,22.54 218.7,22.94 219.09,22.94 220.71,24.56 220.71,25.64 219.18,27.17 v2(218.89,27.17) ; v2(129.86,10.18) 129.86,11.55 131.03,12.71 RK17.2
  IN2 w0.127: v2(151.91,5.11) 151.91,5.59 149.97,7.53 133.36,7.53 131.76,9.13 130.91,9.13 v2(129.86,10.18)
  IN3 w0.127: v2(103.65,24.23) 102.96,24.91 102.85,24.91 102.12,25.64 100.71,27.05 99.24,27.05 97.59,28.7 97.59,41.86 95.85,43.6 95.85,54.9 95.85,56.85 96.59,57.59 96.59,58.86 97.17,59.43 97.17,64.18 97.8,65.14 98.46,66.27 99.22,67.64 99.51,68.21 100.36,69.06 100.36,69.77 101.78,71.19 101.78,72.49 102.27,72.98 102.27,73.64 102.66,74.04 102.66,79.41 103.33,80.08 106.67,80.08 107.89,81.31 108.43,82.44 arc(109.24,84.31) 110.48,85.92 113.78,89.22 115.42,89.22 119.18,92.98 119.18,94.48 120.09,95.4 120.09,102.36 121.57,103.83 122.3,103.83 123.96,105.48 124.36,105.48 125.35,106.48 v2(125.35,106.98)
  BOTTOM w0.127: RH13.2 218.79,27.07 v2(218.89,27.17) ; UC1.BT34 125.91,106.21 125.35,106.77 v2(125.35,106.98) ; v2(129.86,10.18) 129.11,9.43 126.17,9.43 124.84,10.75 120.23,10.75 116.69,14.29 116.69,18.79 116.17,19.31 108.31,19.31 104.68,22.95 104.68,23.45 103.91,24.23 v2(103.65,24.23)
H_PLTRST_CPU#: length 256.9
  TOP w0.127: v2(103.09,80.78) 103.95,81.63 107.31,81.63 109.23,83.56 109.23,86.24 105.51,89.96 v2(105.51,91.95) ; v2(210.47,30.51) 210.14,30.19 210.14,29.5 210.69,28.95 CH81.1 210.98,28.57 211.57,28.57 211.88,28.26 v2(211.88,27.98)
  IN1 w0.127: v2(103.09,80.78) 103.09,74.23 103.45,73.87 103.45,70.15 97.75,64.45 97.75,59.68 96.95,58.88 96.95,58.35 v2(97.05,58.25)
  IN2 w0.127: v2(106.16,26.04) 106.16,26.23 106.71,26.78 107.61,26.78 112.82,21.57 116.11,21.57 116.8,22.26 125.56,22.26 126.2,22.9 128.01,22.9 128.42,22.48 131.73,22.48 132.77,23.52 134.26,23.52 134.85,22.93 136.59,22.93 137.47,23.81 142.17,23.81 142.46,23.52 151.01,23.52 151.87,24.38 163.84,24.38 163.99,24.54 171.46,24.54 176,29.08 180.16,29.08 183.32,32.24 183.32,33.94 185.36,35.98 188.74,35.98 188.97,35.75 191.87,35.75 193.26,37.14 193.26,37.96 194.25,38.95 196.51,38.95 196.69,39.14 200.26,39.14 200.71,39.59 201.75,39.59 203.07,38.26 203.93,38.26 204.66,38.99 206.33,38.99 206.59,38.73 207.3,38.73 208.32,37.7 208.32,34.31 209,33.63 209.43,33.63 211,32.06 211,31.04 v2(210.47,30.51)
  IN3 w0.127: v2(105.51,91.95) 105.51,93.82 105.8,94.11 105.8,104.59 107.57,106.35 111.9,106.35 119.19,113.65 119.19,114.14 119.11,114.22 v2(119.11,114.74) ; v2(97.05,58.25) 97.05,57.43 96.29,56.67 96.29,43.78 98.02,42.04 98.02,31.03 101.1,27.95 102.18,27.95 104.65,25.49 105.61,25.49 v2(106.16,26.04)
  BOTTOM w0.127: v2(119.11,114.74) 119.12,114.75 121.29,114.75 122.92,113.13 CH80.1 124.03,109.5 126.08,107.45 127,107.45 127.07,107.37 128.29,107.37 UC1.BP35 ; v2(211.88,27.98) UH1.AG5
H_PM_DOWN: length 5.4
  BOTTOM w0.102: RC22.2 124.08,105.18 124.44,104.82 v1(124.58,104.82) ; 126.31,105.01 128.29,105.01 UC1.BP31
  BOTTOM w0.127: 126.31,105.01 126.12,104.82 v1(124.58,104.82)
H_PM_DOWN_R: length 258.8
  TOP w0.127: v2(212.45,28.08) 213.35,28.98 RH14.2 ; v2(104.86,80.76) 105.3,81.2 107.49,81.2 109.66,83.38 109.66,86.42 105.95,90.13 v2(105.95,91.08)
  IN1 w0.127: v2(105.95,91.08) 106.51,91.64 106.51,104.16 110.19,107.85 113.25,107.85 118.75,113.35 v2(118.75,113.95) ; v2(97.51,58.83) 98.18,59.5 98.18,64.27 103.88,69.98 103.88,73.78 105.57,75.47 105.57,79.53 104.86,80.23 v2(104.86,80.76)
  IN2 w0.127: v2(212.45,28.08) 212.55,28.08 213.49,29.02 213.49,30.52 212.35,31.66 212.35,31.68 209.26,34.77 209.26,35.62 209.47,35.82 209.47,36.17 208.75,36.89 208.75,37.8 207.48,39.08 206.71,39.08 206.4,39.39 204.12,39.39 203.9,39.61 202.34,39.61 201.93,40.02 200.53,40.02 199.88,39.37 196.6,39.37 196.41,39.18 193.87,39.18 193.42,38.73 192.59,38.73 191.97,39.35 191.37,39.35 190.65,38.64 190.65,36.92 189.92,36.19 189.15,36.19 188.86,36.47 185.23,36.47 182.82,34.05 182.82,32.35 179.98,29.51 175.82,29.51 171.28,24.97 163.81,24.97 163.66,24.82 151.69,24.82 150.83,23.95 142.64,23.95 142.28,24.31 136.5,24.31 136.14,23.95 132.59,23.95 131.55,22.91 128.6,22.91 128.19,23.33 125.89,23.33 125.25,22.69 116.62,22.69 115.93,22.01 113,22.01 107.79,27.21 106.53,27.21 v2(105.67,26.35)
  IN3 w0.127: v2(97.51,58.83) 97.51,57.28 96.74,56.51 96.74,46.58 98,45.33 98,44.06 99.41,42.65 99.41,36.86 98.66,36.11 98.66,31 101.27,28.39 102.36,28.39 104.83,25.92 105.24,25.92 v2(105.67,26.35)
  BOTTOM w0.102: UH1.AE2 213.19,28.16 212.53,28.16 v2(212.45,28.08)
  BOTTOM w0.127: RC22.1 119.77,105.18 119.33,105.61 v1(119.33,106.03) 119.33,108.05 122.48,111.2 122.48,112.85 121.02,114.31 119.11,114.31 v2(118.75,113.95)
H_PM_SYNC: length 4.8
  BOTTOM w0.102: UH1.AF3 213.33,27.91 214.02,28.6 216.61,28.6 RH15.1
H_PM_SYNC_R: length 244.8
  IN2 w0.127: v2(218.89,27.76) 217.94,28.71 217.94,33.32 218.27,33.65 218.27,35.58 219.3,36.6 219.3,39.72 215.62,43.4 214.25,43.4 212.21,45.44 200.56,45.44 199.84,46.16 195.16,46.16 192.78,43.77 190.08,43.77 187.26,40.96 187.26,40.62 186.56,39.92 182.26,39.92 179.94,37.6 178.42,37.6 172.2,31.38 171.35,31.38 169.13,29.16 163.57,29.16 163.35,29.37 150.06,29.37 149.65,28.97 145.57,28.97 145.08,28.48 143.41,28.48 142.81,29.08 141.55,29.08 140.95,28.48 124.45,28.48 122.87,26.9 118.59,26.9 118.18,27.32 116.78,27.32 116.48,27.62 116.48,28.06 116.04,28.49 114.24,28.49 113.56,29.18 108.7,29.18 107.17,27.65 106.35,27.65 v2(105.06,26.35)
  IN3 w0.127: v2(125.94,106.98) 125.94,106.45 124.54,105.05 124.13,105.05 122.48,103.4 121.75,103.4 120.52,102.18 120.52,95.22 119.61,94.31 119.61,92.77 115.63,88.79 113.96,88.79 110.79,85.62 arc(109.32,83.55) 108.61,81.11 108.61,81.11 arc(108.59,80.88) 108.58,80.64 108.58,80.21 arc(108.57,80.07) 108.57,79.92 108.57,79.34 102.7,73.47 102.7,72.8 102.21,72.31 102.21,71.01 100.8,69.59 100.8,68.47 99.49,67.17 98.84,65.99 98.43,65.23 97.6,63.72 97.6,59.5 97.94,59.16 97.94,57.1 97.18,56.33 97.18,46.76 98.43,45.51 98.43,44.24 100.42,42.25 100.42,37.26 99.09,35.93 99.09,31.18 101.45,28.82 102.54,28.82 105.01,26.35 v2(105.06,26.35)
  BOTTOM w0.127: v2(125.94,106.98) 126.3,106.62 129.55,106.62 UC1.BM34 ; RH15.2 218.37,27.76 v2(218.89,27.76)
H_PROCHOT#: length 307.4
  TOP w0.127: v2(108.46,88.76) 108.46,88.23 110.1,86.6 110.1,83.2 107.64,80.74 v2(105.47,80.74) ; RK8.2 130.25,22.57 RK9.2 129.92,22.58 CK12.1 128.19,23.16 QK1.1 127.41,23.95 125.05,23.95 123.08,25.91 121.84,25.91 120.36,27.39 v2(120.36,27.76)
  IN1 w0.127: v2(120.36,27.76) 119.97,27.37 119.64,27.37 119.59,27.31 116.77,27.31 116.49,27.03 113.92,27.03 113.76,26.87 104.51,26.87 103.62,27.77 101.79,27.77 97.16,32.4 97.16,41.56 94.53,44.2 94.53,47.14 95.66,48.27 95.66,52.69 98.61,55.64 98.61,64 104.31,69.71 104.31,73.61 106.01,75.3 106.01,79.76 105.47,80.29 v2(105.47,80.74) ; v2(121.09,99.64) 121.09,95.97 114.43,89.31 112,89.31 111.45,88.76 v2(108.46,88.76)
  IN2 w0.127: v2(120.36,27.76) 120.36,28.15 120.89,28.68 123.42,28.68 124.09,29.35 140.59,29.35 141.19,29.94 143.17,29.94 143.77,29.35 144.72,29.35 145.21,29.83 149.29,29.83 149.7,30.24 163.71,30.24 163.93,30.02 168.77,30.02 172.52,33.77 172.52,36.27 173.69,37.44 176.19,37.44 178.71,39.96 180.49,39.96 181.31,40.79 185.25,40.79 189.1,44.64 192.34,44.64 194.73,47.03 200.37,47.03 201.15,46.24 214.47,46.24 222.3,38.42 236.91,38.42 237.37,38.88 239.26,38.88 239.72,38.42 243.99,38.42 244.94,37.47 v2(245.34,37.47)
  IN3 w0.127: v2(225.86,17.59) 226.35,18.09 226.35,19.89 224.85,21.4 224.85,26.79 228.47,30.41 228.47,31.88 233.77,37.18 245.05,37.18 v2(245.34,37.47)
  BOTTOM w0.127: v2(121.09,99.64) 120.22,100.5 RC18.1 RC42.2 ; v2(225.86,17.59) 225.86,15.28 226.77,14.36 PRB17.1
H_PROCHOT#_CPU: length 8.7
  BOTTOM w0.102: RC42.1 122.2,102.97 124.31,102.97 124.56,103.22 125.2,103.22 125.64,103.66 127.1,103.66 127.12,103.64 127.64,103.64 UC1.BR30
  BOTTOM w0.127: RC42.1 v1(121.14,102.93)
H_PROCHOT#_EC: length 13.3
  TOP w0.127: QK1.2 128.07,24.69 129.04,23.72 129.62,23.72 129.85,23.49 RK9.1 130.79,23.49 131.17,23.87 131.98,23.87 132.36,23.49 132.36,22.75 133.12,21.99 v1(133.13,21.99) 133.13,21.98 133.89,21.22 133.89,20.41 134.49,19.82 UK1.103
H_THERMTRIP#: length 16
  TOP w0.127: v2(162.54,104.96) 163.03,104.47 163.03,103.62 164.13,102.52 164.51,102.52 164.74,102.75 166.52,102.75 167.14,103.36 167.14,103.96 167.38,104.2 167.75,104.2 170.13,101.82 RC45.2
  BOTTOM w0.127: v2(162.54,104.96) UC1.J31
HDA_BIT_CLK: length 10.1
  BOTTOM w0.089: 211.03,14.72 210.4,15.35 210.4,15.81 209.3,16.9 209.3,17.79 209.03,18.06 209.03,18.87 209.02,18.88 209.02,19.36 UH1.BD11
  BOTTOM w0.127: RH245.1 214.94,14.07 v1(212.88,14.07) 211.68,14.07 211.03,14.72
HDA_BIT_CLK_R: length 93.3
  TOP w0.135: v2(299.48,15.77) 299.48,15.77 CA15.1 299.28,16.61 298.76,17.14 298.76,19.15 298.47,19.43 UA1.14
  IN1 w0.203: v2(221.07,15.26) 221.19,15.14 221.67,15.14 222.77,16.25 225.97,16.25 226.58,15.63 233.78,15.63 235.03,16.89 237.25,16.89 237.61,16.53 257.1,16.53 257.33,16.31 263.37,16.31 263.87,16.81 275.3,16.81 276.13,15.98 277.92,15.98 278.72,16.77 278.72,16.86 v2(278.72,16.86)
  IN3 w0.216: v2(299.48,15.77) 298.39,16.86 294.05,16.86 293.72,16.53 292.29,16.53 291.07,15.31 289.39,15.31 288.89,14.8 286.67,14.8 286.16,15.31 283.87,15.31 282.36,16.81 278.76,16.81 v2(278.72,16.86)
  BOTTOM w0.196: RH245.2 217.17,13.87 CH66.2 218.33,15.02 219.51,15.02 219.75,15.26 v2(221.07,15.26)
HDA_RST#: length 8.8
  BOTTOM w0.102: 211.52,14.89 211.18,15.24 211.18,16.05 210.9,16.33 210.9,17.28 210.02,18.16 210.02,18.8 UH1.BE10
  BOTTOM w0.127: 211.52,14.89 v1(211.71,14.7) 211.98,14.44 214.8,14.44 214.99,14.63 RH244.1
HDA_RST#_R: length 88.6
  TOP w0.196: v2(278.09,17.3) 278.2,17.18 278.2,15.72 277.88,15.4 277.88,10.73 v1(277.99,10.62) 278.82,9.78 282.39,9.78 282.63,9.54 284.95,9.54 287.79,12.38 287.79,12.63 288.04,12.88 290.94,12.88 QA2.3
  IN1 w0.203: v2(278.09,17.3) 277.16,17.3 275.61,18.85 274.82,18.85 274.57,18.6 272.62,18.6 271.41,17.39 263.58,17.39 263.09,16.89 257.57,16.89 257.34,17.12 237.85,17.12 237.5,17.47 234.79,17.47 233.72,16.41 226.64,16.41 226.21,16.83 222.53,16.83 v2(221.43,15.73)
  BOTTOM w0.196: v2(221.43,15.73) 221.28,15.87 219.83,15.87 219.38,15.42 218.58,15.42 CH69.2 218.07,15.77 216.93,14.63 RH244.2
HDA_SDIN0: length 105.3
  TOP w0.135: RA12.2 300.2,17.25 300.49,16.96 300.49,15.44 300.36,15.31 300.06,15.31 297.12,12.37 v1(296.5,12.37) 293.99,12.37 291.01,9.39 290.79,9.39 290.42,9.03 v2(289.56,9.03)
  IN1 w0.127: v2(209.94,16.88) 212.05,14.77 212.05,13.49 212.37,13.17 212.77,13.17 213.15,13.54 215.48,13.54 216.11,12.92 221.22,12.92 221.65,13.35 223.33,13.35 224.06,14.09 224.06,14.09 224.58,14.61 226.26,14.61 226.55,14.32 233.81,14.32 235.02,15.53 236.9,15.53 236.95,15.58 256.71,15.58 257.55,14.74 263.31,14.74 264.42,15.85 274.91,15.85 277.64,13.12 278.94,13.12 283.04,9.03 v2(289.56,9.03)
  BOTTOM w0.122: v2(209.94,16.88) 209.66,17.16 209.66,17.73 209.26,18.13 UH1.BE11
HDA_SDIN0_R: length 4.5
  TOP w0.127: 299.64,19.79 299.64,19.27 299.33,18.96 v1(299.33,18.74) 299.33,18.04 CA93.1 RA12.1
  TOP w0.135: 299.64,19.79 299.32,20.12 298.75,20.12 298.64,20.23 UA1.16
HDA_SDIN1: length 3.3
  BOTTOM w0.127: TH119.1 210.77,15.78 210.62,15.94 210.62,17.16 209.62,18.16 UH1.BF10
HDA_SDOUT: length 13.4
  TOP w0.196: QH2.3 211.33,13.68 v2(212.54,13.68) 212.93,13.29 RH118.2 212.96,12.22 RH196.1
  BOTTOM w0.089: 210.63,14.62 210.19,15.06 210.19,15.58 209,16.78 209,17.73 208.82,17.91 208.82,18.23 UH1.BF12
  BOTTOM w0.127: RH246.1 214.85,13.4 v1(214.08,13.4) 214.08,13.42 213.81,13.68 v2(212.54,13.68) 211.57,13.68 210.63,14.62
HDA_SDOUT_R: length 93.2
  TOP w0.135: UA1.17 298.68,20.63 298.96,20.35 299.65,20.35 v2(299.81,20.19)
  IN1 w0.203: v2(279.3,17.41) 279.3,16.53 278.16,15.39 275.89,15.39 275.06,16.22 264.27,16.22 263.15,15.1 257.71,15.1 256.86,15.95 236.8,15.95 236.75,15.89 234.86,15.89 233.66,14.69 226.7,14.69 225.73,15.66 223.01,15.66 221.91,14.56 220.94,14.56 v2(220.72,14.79)
  IN3 w0.216: v2(279.3,17.41) 282.61,17.41 284.12,15.9 290.82,15.9 292.37,17.45 297.83,17.45 299.81,19.44 v2(299.81,20.19)
  BOTTOM w0.196: RH246.2 CH68.2 218.65,13.94 219.45,13.94 v1(220.06,14.56) 220.29,14.79 v2(220.72,14.79)
HDA_SPKR: length 106
  TOP w0.127: v2(285.91,30.35) 286.03,30.35 v1(286.89,29.5) 286.89,27.67 CA28.1
  TOP w0.196: v2(201.35,22.46) 201.35,21.8 201.88,21.27 201.88,19.35 201.5,18.97 RH53.1
  IN2 w0.127: v2(285.91,30.35) 284.99,29.43 281.39,29.43 280.38,28.42 278.03,28.42 277.09,29.36 276.02,29.36 275.57,28.9 265.59,28.9 264.09,30.4 259.11,30.4 255.53,33.98 253.23,33.98 252.23,34.98 248.4,34.98 247.34,33.92 243.4,33.92 242.54,34.78 229.06,34.78 219.05,24.77 218.06,24.77 217.07,23.79 216.7,23.79 215.8,22.88 215.8,22.48 215.26,21.93 214.91,21.93 214.7,22.14 210.9,22.14 210.29,21.52 210.29,20.96 209.23,19.9 205.39,19.9 203.65,21.63 202.19,21.63 v2(201.35,22.46)
  BOTTOM w0.127: v2(201.35,22.46) 200.57,21.68 UH1.AW29
HDA_SYNC: length 4.2
  BOTTOM w0.089: 209.33,15.26 v1(209.33,15.89) 209.33,16.2 208.57,16.95 UH1.BG13
  BOTTOM w0.135: RH247.1 209.82,14.21 209.35,14.68 209.35,15.24 209.33,15.26
HDA_SYNC_R: length 103.7
  TOP w0.135: UA1.15 298.62,19.83 298.77,19.68 v2(299.13,19.68)
  IN1 w0.203: v2(278.71,17.46) 278.41,17.76 277.28,17.76 275.78,19.26 274.65,19.26 274.4,19 272.45,19 271.24,17.8 263.41,17.8 262.92,17.3 257.74,17.3 257.51,17.53 238.02,17.53 237.66,17.88 234.62,17.88 233.57,16.83 227.41,16.83 226.16,18.08 226.16,20.61 v2(226.2,20.64)
  IN3 w0.216: v2(299.13,19.68) 297.32,17.87 292.2,17.87 290.65,16.32 284.29,16.32 282.74,17.87 278.97,17.87 278.71,17.61 v2(278.71,17.46)
  BOTTOM w0.196: RH247.2 211,13.18 213.58,13.18 213.76,13 214.33,13 214.99,12.34 219.74,12.34 CH67.2 220.98,13.1 221.85,13.98 221.85,18.15 v1(223.47,19.77) 224.34,20.64 v2(226.2,20.64)
HDDHALT_LED#: length 146
  TOP w0.127: v2(278.23,18.21) v3(278.23,18.85)
  IN1 w0.127: v2(204.42,16.08) 204.79,16.08 209.79,11.08 216.36,11.08 218.04,9.4 218.61,9.4 v2(220.03,7.98)
  IN3 w0.127: v2(278.23,18.21) 278.23,18.34 276.6,19.96 272.82,19.96 270.57,17.71 264.31,17.71 263.48,16.89 258.04,16.89 257.69,17.25 237.94,17.25 237.48,16.79 235.55,16.79 234.74,15.98 226.49,15.98 224.15,13.63 224.15,13.17 220.63,9.66 220.63,8.58 v2(220.03,7.98)
  BOTTOM w0.127: UH1.BE23 203.29,18.51 203.29,17.03 204.25,16.08 v2(204.42,16.08) 205.09,15.41 RH194.2 ; v2(278.23,18.21) 278.23,22.11 279.95,23.83 279.95,24.27 279.19,25.03 279.19,28.15 277.58,29.76 277.58,37.49 278.72,38.63 278.72,40.49 282.48,44.25 291.42,44.25 294.75,40.92 303.79,40.92 305.62,42.75 JIO1.7
HDMI_1.2V_EN: length 14.6
  TOP w0.127: v2(33.44,58.41) 33.44,58.81 v3(32.86,59.38)
  TOP w0.254: UV3.1 26.11,55.48 26.48,55.85 RV30.1 27,55.79 28.83,55.79 v2(28.94,55.89)
  IN1 w0.254: v2(33.44,58.41) 33.05,58.8 32.71,58.8 32.01,59.49 30.55,59.49 30.22,59.16 29.34,59.16 28.24,58.06 28.24,56.23 28.59,55.87 28.92,55.87 v2(28.94,55.89)
  BOTTOM w0.254: RV11.1 33.03,57.82 33.03,58.01 v2(33.44,58.41)
HDMI_EQ: length 9.1
  TOP w0.127: RV21.2 20.66,63.9 RV22.2 19.86,63.9 v1(19.48,64.28) v2(19.12,64.65)
  IN3 w0.127: v2(19.12,64.65) 19.12,63.96 21.38,61.7 21.38,60.88 21.82,60.44 v2(21.98,60.44)
  BOTTOM w0.127: v2(21.98,60.44) 22.22,60.68 UV2.5
HDMI_HPD_GPU#: length 38.1
  IN1 w0.127: v2(218.03,66.12) 219.38,66.12 220.73,67.47 222.84,67.47 225.34,64.97 227.42,64.97 228.36,64.03 232.52,64.03 232.91,64.41 v2(233.38,64.41)
  IN3 w0.127: v2(206.84,77.75) 206.84,77.27 212.54,71.57 213.81,71.57 217.2,68.18 217.2,66.68 217.76,66.12 v2(218.03,66.12)
  BOTTOM w0.102: v2(206.84,77.75) 206.48,77.4 UG1.U3
  BOTTOM w0.127: v1(233.53,65.02) 233.38,64.87 v2(233.38,64.41) 233.7,64.41 233.82,64.29 QG55.1 234.78,64.67 RG180.2
HDMI_I2C_ADDR: length 1.9
  BOTTOM w0.127: UV2.31 29.47,61.08 29.57,61.18 30.26,61.18 30.33,61.1 RV23.2
HDMI_ID: length 2.1
  BOTTOM w0.127: RV26.2 30.62,60.34 30.04,60.92 29.68,60.92 29.44,60.68 UV2.32
HDMI_PRE: length 2.7
  TOP w0.127: v1(29.75,63.76) v2(29.75,63.12) 29.29,62.66 RV25.2
  BOTTOM w0.127: v2(29.75,63.12) 29.31,62.68 UV2.27
HDMI_SRC_HPD: length 269.5
  IN2 w0.127: v2(26.9,57.37) 26.9,55.25 27.26,54.89 27.26,53.82 28.07,53.01 30.88,53.01 31.38,53.52 31.73,53.52 32.5,52.75 33.12,52.75 33.38,52.48 34.57,52.48 35.93,51.13 35.93,50.06 38.77,47.21 40.93,47.21 41.32,46.82 41.32,45.09 42.25,44.16 44.1,44.16 44.2,44.26 45.89,44.26 46.27,43.88 48.33,43.88 49.56,42.64 49.81,42.64 50.51,41.95 56.03,41.95 57.03,42.95 67.18,42.95 68.89,44.65 77.2,44.65 77.85,45.3 80.52,45.3 82.08,46.86 v2(82.08,47.36) ; v2(234.6,49.56) 234.5,49.46 234.5,48.33 233.91,47.74 233.03,47.74 232.63,48.15 231.66,48.15 231.51,48.31 224.02,48.31 221.11,51.22 195.28,51.22 191.78,54.72 191.78,69.96 v2(191.61,70.13)
  IN3 w0.127: v2(234.66,60.07) 235,60.07 235.49,59.57 235.49,58.2 234.74,57.45 234.74,54.73 233.83,53.82 233.83,53.46 235.37,51.91 235.37,50.33 v2(234.6,49.56)
  BOTTOM w0.127: UG28.1 237.57,62.39 237.16,62.79 236.32,62.79 235.31,61.79 RG114.2 235.31,60.72 v2(234.66,60.07) ; UV2.40 26.86,57.41 v2(26.9,57.37) ; v2(82.08,47.36) 82.21,47.5 95.14,47.5 101.38,53.74 105.96,53.74 114.22,62 161.98,62 169.31,69.34 178.46,69.34 180.22,71.09 v1(183.48,71.09) 188.63,71.09 189.68,70.04 191.52,70.04 v2(191.61,70.13)
HDMICONN_HPD_LS: length 76.8
  IN1 w0.203: v2(12.75,117.73) 12.79,117.78 13.14,117.78 14.79,116.13 14.79,113.74 13.58,112.53 13.58,107.31 14.71,106.18 14.71,98.57 16.46,96.83 16.46,75.25 18.52,73.19 18.52,69.53 22.36,65.7 26.27,65.7 v2(26.86,65.1)
  BOTTOM w0.127: v2(26.86,65.1) v1(26.86,65.61)
  BOTTOM w0.203: v2(12.75,117.73) 12.87,117.73 12.91,117.7 15.82,117.7 QV1.1 17.08,117.56 RV29.1 16.75,116.09 DV1.1 DV1.9 14.66,116.09 13.65,117.1 11.45,117.1 10.75,116.4 JHDMI1.19 ; UV2.21 v2(26.86,65.1)
HDMICONN_SCL_LS: length 72.6
  TOP w0.127: RV39.2 22.07,67.5 v2(21.16,68.4) ; v2(14.22,115.74) v1(15.02,115.74)
  IN1 w0.127: v2(17.86,116.36) 17.86,113.18 15.28,110.59 15.28,98.8 17.02,97.06 17.02,75.49 20.11,72.4 20.11,70.59 21.54,69.16 21.54,68.78 v2(21.16,68.4) ; v2(14.22,115.74) 13.39,116.57 12.03,116.57 11.52,116.05 11.52,114.92 JHDMI1.15
  BOTTOM w0.127: v2(14.22,115.74) 14.38,115.58 DV1.8 DV1.2 17.65,115.58 RV27.1 17.66,115.88 17.86,116.09 v2(17.86,116.36) ; UV2.7 22.22,61.48 21.59,62.1 21.59,64.42 22.42,65.25 22.42,67.15 v2(21.16,68.4)
HDMICONN_SCL_LS_R: length 4.1
  TOP w0.127: v1(20.58,69.1) 20.58,67.99 21.16,67.41 RV39.1 RV41.1 20.75,66.24 20.64,66.35 QV2.3
HDMICONN_SDA_LS: length 66.9
  TOP w0.127: v2(14.2,114.37) v1(15.04,114.37) ; v2(18.98,71.42) 17.93,70.36 RV40.2
  IN1 w0.127: v2(14.2,114.37) 12.58,114.37 JHDMI1.16 ; v2(21.12,68.99) 19.46,70.65 19.46,70.94 v2(18.98,71.42) 18.82,71.58 18.82,73.32 16.76,75.38 16.76,96.95 15.01,98.7 15.01,112.11 v2(16.99,114.09)
  BOTTOM w0.127: UV2.8 22.19,61.88 21.85,62.21 21.85,64.31 22.68,65.14 22.68,67.72 21.41,68.99 v2(21.12,68.99) ; v2(16.99,114.09) 17.43,114.09 17.66,114.31 RV28.1 17.3,114.7 17.18,114.58 DV1.4 DV1.7 14.42,114.58 v2(14.2,114.37)
HDMICONN_SDA_LS_R: length 2.8
  TOP w0.127: QV2.6 18.85,68.95 RV42.1 RV40.1 17.43,69.08 v1(16.97,69.55)
HGATE_1.35VSDGPUP: length 16.3
  IN3 w0.762: 241.28,52.03 241.68,52.43 244.22,52.43 246.61,54.82 250.49,54.82 252.09,53.22 255.79,53.22
  BOTTOM w0.127: v2(240.37,50.89) 240.37,50.89
  vias: v2(240.79,51.36) v2(257.14,53.82) v2(257.15,53.24)
HP_OUT_L: length 4
  BOTTOM w0.254: JIO1.32 305.93,30.25 305.92,30.24 305.92,30.45 306.22,30.75 JIO1.31
  BOTTOM w0.381: 305.92,30.24 v2(305.55,29.87) 305.29,29.61 CA96.1 304.25,29.61 LA9.1
HP_OUT_R: length 4.1
  BOTTOM w0.254: JIO1.35 306.25,28.75 306.01,28.98 306.01,29.02 306.24,29.25 JIO1.34
  BOTTOM w0.381: LA8.1 304.25,28.34 CA95.1 305.1,28.26 v2(305.67,28.26) 305.77,28.36 305.77,28.74 306.01,28.98
HP_OUTL: length 8.5
  TOP w0.381: RA11.2 v2(296.63,26.82)
  BOTTOM w0.381: LA9.2 v1(300.19,29.49) 299.04,29.49 296.63,27.07 v2(296.63,26.82)
HP_OUTR: length 7.5
  TOP w0.381: RA9.2 v2(297.39,26.82)
  BOTTOM w0.381: v2(297.39,26.82) v1(298.73,28.17) 299.34,28.77 302.72,28.77 LA8.2
HPOUT_L: length 1.5
  TOP w0.203: UA1.27 296.42,24.9 296.63,25.11
  TOP w0.381: RA11.1 296.63,25.11
HPOUT_R: length 1.6
  TOP w0.203: UA1.26 296.82,24.7 297.22,25.1
  TOP w0.381: 297.22,25.1 297.39,25.27 RA9.1
HRESET_987: length 137.3
  TOP w0.127: v2(126.13,10.2) 123.91,12.42 117.52,12.42 116.22,13.72 116.22,17.75 117.3,18.83 117.3,21.03 118.18,21.9 v1(118.18,24) v2(118.18,26.73) ; v2(51.45,48.27) 51.03,48.27 50.61,48.69 50.03,48.69 49.59,49.13 48.92,49.13 RU64.1 ; UK1.18 144.04,9.23 v2(143.44,9.83)
  IN1 w0.127: v2(51.45,48.27) 53.33,46.38 53.33,43.89 54.59,42.64 56.01,42.64 57.79,44.42 65.24,44.42 67.86,41.8 67.86,31.3 70.51,28.65 85.31,28.65 87.14,26.82 89.75,26.82 91.08,25.48 94.6,25.48 96.39,27.28 98.6,27.28 99.38,26.5 100.85,26.5 101.14,26.21 102.01,26.21 103.02,25.19 103.66,25.19 104.6,24.25 112.69,24.25 114.91,26.47 117.92,26.47 v2(118.18,26.73)
  IN2 w0.127: v2(126.13,10.2) 126.13,10.7 127.23,11.81 131.87,11.81 132.59,11.09 135.09,11.09 135.26,10.92 142.35,10.92 v2(143.44,9.83)
HRESET_987_R: length 4
  TOP w0.127: UU4.44 49.14,47.58 49.44,47.88 RU63.1 48.97,48.74 48.46,48.74 48.31,48.89 RU64.2 v1(47.6,49.82)
I2C_0_SCL: length 19.6
  TOP w0.127: QC10.1 209.36,8.17 209.36,7.23 208.87,6.74 RH230.1 209.35,6.63 209.76,7.03 v2(209.76,7.57)
  BOTTOM w0.089: UH1.BC22 204.07,19.71 204.07,18.78 203.95,18.66 203.95,18.23 203.75,18.03 203.75,17.15 204.03,16.88 204.41,16.88 205.97,15.31 205.97,15 207.38,13.59 207.38,13.59 207.66,13.31
  BOTTOM w0.127: 207.66,13.31 207.8,13.17 v1(207.8,12.69) 207.8,12.48 210.72,9.55 210.72,8.53 v2(209.76,7.57)
I2C_0_SDA: length 12.1
  TOP w0.127: QC10.4 207.55,9.77 206.94,9.17 RH231.1 v2(206.84,9.78)
  BOTTOM w0.089: 206.84,13.54 v1(205.98,14.39) 205.72,14.65 205.72,15.31 204.6,16.44 204.2,16.44 203.54,17.1 203.54,18.26 UH1.BF23
  BOTTOM w0.127: v2(206.84,9.78) 206.84,13.54
I2C_1_SCL: length 13.6
  TOP w0.127: v2(212.45,10.13) 212.83,9.75 RH228.1
  BOTTOM w0.089: UH1.BE21 204.4,18.68 204.63,18.45 204.63,17.74 204.78,17.59 204.78,17.12 205.28,16.61 205.58,16.61
  BOTTOM w0.127: v2(212.45,10.13) 212.02,10.56 210.93,10.56 208.7,12.8 208.7,13.49 v1(206.37,15.82) 205.58,16.61
I2C_1_SDA: length 12.6
  TOP w0.127: RH229.1 212.07,9.85 v2(211.79,10.13)
  BOTTOM w0.089: 208.02,13.55 v1(207.48,14.09) 204.6,16.98 204.6,17.5 204.42,17.68 204.42,18.23 UH1.BF21
  BOTTOM w0.127: 208.02,13.55 208.24,13.34 208.24,12.65 210.75,10.13 v2(211.79,10.13)
I2C_INT#: length 7.4
  TOP w0.127: v2(91.37,12.24) 91.85,12.72 v3(92.31,12.72) 93.96,12.72 DT1.2 93.96,12.17 92.15,12.17 91.83,11.85 R5236.2
  BOTTOM w0.127: v2(91.37,12.24) 91.2,12.4 JTP1.2
ILIM_1PH: length 5.7
  TOP w0.127: v2(173.21,127.33) v1(174.08,127.33)
  TOP w0.203: v2(173.21,127.33) 173.13,127.33 172.23,128.23 PCZ9.2 PRZ20.2
  BOTTOM w0.203: v2(173.21,127.33) 173.13,127.33 172.65,127.81 172.35,127.81 171.92,128.24 PUZ1.49
ILIM_2PH: length 2.2
  BOTTOM w0.203: PRZ44.1 167.75,134 v1(167.75,133.56) 167.83,133.48 PUZ1.32
ILIM_4PH: length 4.3
  BOTTOM w0.203: PUZ1.7 v1(168.23,125.19) 168.23,125.14 168.46,124.91 168.46,124.73 168.73,124.46 169.01,124.46 170.34,123.14 PRZ43.2
ILIM_SEL: length 3.1
  BOTTOM w0.127: v1(18.04,76.15) 18.04,76.3 18.28,76.54 RS17.1 18.57,77.17 19.03,77.62 US2.4
ILMT_1.35VSDGPUP: length 3.4
  BOTTOM w0.254: PUW1.2 240.95,56.04 240.65,56.35 v2(239.83,56.35) 239.73,56.35 238.96,57.12 PRW4.2
ILMT_1V05: length 5.5
  BOTTOM w0.254: PU1001.13 237.82,25.11 238.4,24.53 v2(239.07,24.53) 239.74,24.53 240.08,24.19 240.08,23.05 PR1002.1 PR1004.2
ILMT_VCCIOP: length 2.9
  BOTTOM w0.254: PRH9.2 PRH10.1 181.64,101.95 v2(182.25,102.56) 182.25,102.69 182.52,102.96 PUH1.13
IMON_1PH: length 4.1
  TOP w0.127: v1(171.86,131.82) PRZ13.2
  TOP w0.203: PRZ13.2 PCZ6.2 172.47,129.4 172.47,129.3 v2(172.49,129.28)
  BOTTOM w0.203: v2(172.49,129.28) 172.45,129.28 172.29,129.44 PUZ1.46
IN_2.5V:
  vias: v1(106.25,19.21)
INT_MIC: length 3.5
  BOTTOM w0.254: JIO1.29 306.09,31.75 v2(305.83,31.49)
  BOTTOM w0.381: v2(305.83,31.49) 305.53,31.19 305.53,30.67 305.24,30.38 CA97.1 304.37,30.38 LA10.1
INT_MIC_R: length 12.4
  TOP w0.203: UA1.31 294.82,24.9 295.06,25.14 295.06,25.61
  TOP w0.381: 295.06,25.61 295.06,25.83 295.5,26.26 RA4.2 v2(295.86,26.82)
  BOTTOM w0.381: v2(295.86,26.82) 295.86,27.2 295.99,27.33 295.99,27.34 298.78,30.12 298.79,30.12 298.91,30.24 v1(302.07,30.24) 302.88,30.24 LA10.2
INVPWR_B+: length 1.8
  TOP w0.254: PRP4.1 PCP8.1 85.06,32.12 85.4,31.77 v2(85.81,31.77)
  vias: v2(87.46,30.63) v2(87.46,30) v3(86.29,33.73)
INVPWR_B+_R:
  vias: v2(79.33,31.77) v2(79.96,31.77) v2(80.59,31.79) v3(79.68,27.95) v3(80.54,31.2) v3(80.54,29.45)
INVTPWM: length 9.9
  BOTTOM w0.127: v1(74.31,23.01) 74.08,23.24 RV4.2 RV5.1 72.52,23.42 CV17.1 71.21,24.73 71.21,28.63 70.55,29.29 JEDP1.20
IST_TRIG: length 7.9
  BOTTOM w0.127: 167.37,82.8 166.98,82.8 166.91,82.87 166.39,82.87 UC1.E3
  BOTTOM w0.135: TC287.1 172.42,82.64 172.24,82.46 169.39,82.46 169.04,82.8 167.37,82.8
JTAG_RST: length 5.3
  BOTTOM w0.109: 192.24,83.68 192.51,83.68 192.61,83.78 192.63,83.78 192.89,84.04 UG1.AN11
  BOTTOM w0.127: 192.24,83.68 191.84,84.08 191.4,84.08 191.17,83.84 189.32,83.84 v1(189.26,83.78) 189.1,83.78 189.04,83.73 RG43.1
JTAG_TCK_VGA: length 6.5
  BOTTOM w0.102: 192.07,82.52 192.24,82.68 193.68,82.68 193.98,82.98 UG1.AM10
  BOTTOM w0.127: 192.07,82.52 191.03,82.52 190.64,82.13 190.64,81.8 190.48,81.63 TG5.1
JTAG_TDI: length 4.4
  TOP w0.127: TG6.1 190.73,83.06 190.96,82.83 191.57,82.83 v2(191.73,82.99)
  BOTTOM w0.102: 192.03,83.19 192.32,83.47 192.92,83.47 193.11,83.66 193.29,83.66 193.67,84.04 UG1.AM11
  BOTTOM w0.127: v2(191.73,82.99) 191.93,83.19 192.03,83.19
JTAG_TDO: length 2.2
  BOTTOM w0.127: UG1.AP12 192.02,84.84 192.01,84.83 190.3,84.83 TG7.1
JTAG_TMS: length 6.4
  BOTTOM w0.127: UG1.AP11 192.26,84.04 192,84.3 191.11,84.3 190.91,84.1 189.39,84.1 189.29,84.2 186.28,84.2 TG8.1
KBL_ON: length 88.4
  TOP w0.127: v2(220.51,14.15) 219.69,14.15 219.66,14.13 v1(219.66,14.12) 217.81,12.27 Q73.2 ; UK1.21 145.24,9.42 145.01,9.64 v2(145.01,9.81)
  IN2 w0.127: v2(145.01,9.81) 145.01,10.22 146.23,11.44 150.03,11.44 150.52,11.93 150.52,12.14 152.1,13.73 152.32,13.73 154.48,15.89 171.7,15.89 174.4,13.19 180.76,13.19 182.05,11.89 182.77,11.89 184.88,9.79 188.36,9.79 189.41,10.83 190.46,10.83 191.29,11.65 197.48,11.65 197.74,11.92 200.56,11.92 201.18,12.54 209.64,12.54 210.11,12.08 212.78,12.08 213.43,12.73 218.23,12.73 219.65,14.15 v2(220.51,14.15)
KBL_ON_GND: length 5
  TOP w0.127: v3(213.81,13.35) 214.05,13.1 Q73.1
  TOP w0.508: v2(217.25,10.79) 216.49,11.54 216.49,12.34 Q73.1
KSI0: length 49
  TOP w0.127: v2(155.09,21.16) 155.09,20.93 154.22,20.06 154.22,18.44 154.03,18.25 152.5,18.25 152.13,18.62 UK1.55 ; v2(186.11,11.47) 186.1,11.48 185.55,11.48 C389.2 v3(185.53,10.15)
  BOTTOM w0.127: v2(155.09,21.16) 155.55,21.62 156.01,21.62 156.88,20.75 157.31,20.75 157.56,21 157.56,21.41 158.03,21.88 165.85,21.88 167.89,23.91 171.54,23.91 171.65,23.8 171.65,22.72 175.62,18.75 177.72,18.75 180.23,16.24 180.23,15.4 180.73,14.9 182.87,14.9 183.9,13.87 185.75,13.87 186.35,13.27 JKB1.12 186.35,11.71 v2(186.11,11.47)
KSI1: length 29
  TOP w0.127: UK1.56 152.17,19.02 152.53,18.65 153.14,18.65 v2(153.15,18.67) 153.15,19.29 v3(153.05,19.39)
  BOTTOM w0.127: JKB1.1 175.35,13.21 175.2,13.36 174.07,13.36 171.14,16.29 166.72,16.29 164.92,18.1 159.62,18.1 158.28,19.43 155.16,19.43 153.97,18.23 153.59,18.23 v2(153.15,18.67)
KSI2: length 40.2
  TOP w0.127: v2(153.79,18.67) 153.79,20 154.14,20.35 154.14,20.65 v3(154.07,20.71) 153.74,20.71 152.45,19.42 UK1.57
  BOTTOM w0.127: JKB1.8 182.35,13.35 181.84,13.85 180.3,13.85 179.18,14.97 179.18,15.8 177.3,17.68 172.49,17.68 172.05,18.13 167.54,18.13 164.94,20.73 159.05,20.73 158.27,19.95 156.56,19.95 156.17,20.34 154.53,20.34 153.79,19.61 v2(153.79,18.67)
