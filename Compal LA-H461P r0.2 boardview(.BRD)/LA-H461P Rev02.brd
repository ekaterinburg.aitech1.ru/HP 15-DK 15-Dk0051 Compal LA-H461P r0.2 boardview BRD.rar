# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_M0_D60: length 56.7
  IN3 w0.076: 167.32,76.33 159.87,83.78 159.87,84.35 v2(160.29,84.77)
  IN3 w0.127: v2(165.87,48.92) 165.56,48.92 165.45,48.8 165.45,43.92 165.28,43.74 164.97,43.74 164.79,43.92 164.79,44.52 164.86,44.59 164.86,48.93 167.15,51.22 167.15,52.17 168.94,53.96 168.94,58.28 169.07,58.4 169.27,58.4 169.4,58.53 169.4,58.78 169.27,58.91 169.07,58.91 168.94,59.04 168.94,59.29 169.07,59.42 169.27,59.42 169.4,59.55 169.4,59.8 169.27,59.93 169.07,59.93 168.94,60.05 168.94,60.28 169.4,60.74 169.4,70.98 168.54,71.84 168.54,75.11 167.32,76.33
  BOTTOM w0.089: v2(160.29,84.77) UC1.M5
  BOTTOM w0.127: v2(165.87,48.92) 165.46,48.92 165.02,49.35 JDIMM1.237
DDR_M0_D61: length 52.7
  IN3 w0.127: v2(165.87,47.65) 165.98,47.53 166.17,47.53 166.3,47.66 166.3,49.83 167.99,51.52 167.99,52.4 168.95,53.37 169.6,53.37 169.81,53.58 169.81,54.67 169.93,54.79 170.2,54.79 170.33,54.92 170.33,55.27 170.24,55.36 169.46,55.36 169.34,55.48 169.34,55.75 169.47,55.88 170.2,55.88 170.33,56.01 170.33,56.26 170.2,56.39 169.47,56.39 169.34,56.51 169.34,56.77 169.47,56.89 170.2,56.89 170.33,57.02 170.33,57.28 170.2,57.4 169.47,57.4 169.34,57.53 169.34,57.88 169.51,58.04 170.23,58.04 170.33,58.14 170.33,58.61 170.2,58.73 169.9,58.73 169.78,58.86 169.78,71.14 168.92,72 168.92,75.26 164.75,79.44 v2(164.75,79.98)
  BOTTOM w0.127: v2(164.75,79.98) 162.14,79.98 160.3,81.82 160.3,82.77 UC1.M2 ; JDIMM1.233 164.02,49.49 v2(165.87,47.65)
DDR_M0_D62: length 56.4
  IN3 w0.076: 165.11,83.17 162.48,83.17 162.34,83.03 162.34,82.54 162.23,82.43 161.82,82.43 161.05,83.2 161.05,84.63 v2(161.87,85.45)
  IN3 w0.127: 165.11,83.17 165.25,83.17 171.48,76.94 171.48,73.05 172.33,72.2 172.33,71.5 172.46,71.37 172.75,71.37 172.88,71.24 172.88,70.99 172.75,70.86 172.46,70.86 172.33,70.73 172.33,70.48 172.46,70.35 172.75,70.35 172.88,70.23 172.88,69.97 172.75,69.85 172.46,69.85 172.33,69.72 172.33,69.46 172.46,69.34 172.75,69.34 172.88,69.21 172.88,68.96 172.75,68.83 172.46,68.83 172.33,68.7 172.33,68.45 172.46,68.32 172.75,68.32 172.88,68.19 172.88,67.94 172.75,67.81 172.46,67.81 172.33,67.69 172.33,67.43 172.46,67.31 172.75,67.31 172.88,67.18 172.88,52.65 172.19,51.96 172.19,51.75 172.53,51.4 172.53,51.3 172.32,51.08 172.1,51.08 171.87,51.31 171.69,51.31 171.23,50.85 170.73,50.35 170.73,49.42 169.68,48.36 169.68,47.63 169.6,47.55 169.16,47.55 v2(168.95,47.75)
  BOTTOM w0.089: UC1.L5 v2(161.87,85.45)
  BOTTOM w0.127: v2(168.95,47.75) 168.91,47.75 168.03,48.64 JDIMM1.249
DDR_M0_D63: length 53.7
  IN3 w0.076: v2(161.94,82.82) 161.53,83.24 161.53,83.56 161.74,83.77 164.09,83.77 164.18,83.86 165.64,83.86 165.73,83.77
  IN3 w0.127: v2(168.95,45.29) 169.14,45.48 169.14,45.51 170.88,47.25 170.88,48.17 173.69,50.98 173.69,72.32 172.24,73.77 172.24,77.26 165.73,83.77
  BOTTOM w0.076: UC1.L1 161.75,82.82 v2(161.94,82.82)
  BOTTOM w0.127: v2(168.95,45.29) 168.65,44.99 168.65,44.04 167.73,43.13 167.5,43.13 167.28,42.91 JDIMM1.246
DDR_M0_DQS0: length 60.1
  IN3 w0.127: v2(105.62,47.01) 105.47,47.16 105.26,47.16 104.73,47.69 104.73,49.38 105.05,49.7 105.05,63.95 107.17,66.07 107.17,66.32 106.99,66.49 106.99,66.89 107.42,67.32 107.82,67.32 108.03,67.11 108.21,67.11 108.48,67.38 108.48,67.56 108.27,67.77 108.27,68.17 108.7,68.6 109.1,68.6 109.29,68.4 109.44,68.4 109.75,68.71 109.75,69.65 113.06,72.96 113.06,74.98 114.58,76.5 118.6,76.5 120.52,78.42 120.52,81.85 121.09,82.42 122.39,82.42 123.39,83.43 v2(124.63,83.43)
  BOTTOM w0.076: UC1.BP5 128.44,84.89 128.11,85.22 127.72,85.22 127.51,85.02 126.55,85.02 125.65,84.12 125.65,83.84 124.97,83.16 124.76,83.16 124.63,83.29 v2(124.63,83.43)
  BOTTOM w0.127: JDIMM1.13 107.02,48.1 106.07,47.15 105.75,47.15 v2(105.62,47.01)
DDR_M0_DQS1: length 57.8
  IN3 w0.127: v2(126.54,79.98) 126.55,79.99 126.55,80.26 126.41,80.4 126.23,80.4 124.11,78.28 124.11,76.94 123.71,76.54 123.71,75.02 115.43,66.75 115.43,66.59 115.85,66.17 115.85,65.72 115.48,65.34 115.03,65.34 114.61,65.77 114.43,65.77 114.16,65.5 114.16,65.32 114.7,64.78 114.7,64.38 114.27,63.95 113.87,63.95 113.33,64.49 113.15,64.49 111.44,62.78 111.44,44.98 111.57,44.85 112.11,44.85 112.21,44.96 v2(112.21,45.16)
  BOTTOM w0.076: 129.06,80.78 129.07,80.79 129.07,80.87 129.55,81.35 129.83,81.35 130.58,82.11 130.58,82.63 130.99,83.04 130.99,83.49 UC1.BK3
  BOTTOM w0.127: v2(112.21,45.16) 112.45,44.92 112.77,44.92 113.06,44.63 113.06,43.66 112.27,42.87 JDIMM1.34 ; v2(126.54,79.98) 126.85,79.98 126.99,79.84 127.41,79.84 128.16,80.59 128.87,80.59 129.06,80.78
DDR_M0_DQS2: length 54.9
  IN3 w0.127: v2(128.21,78.39) 128.42,78.39 128.76,78.05 128.76,76.97 128.32,76.52 128.32,71.99 117.3,60.97 117.3,48.15 116.47,47.33 116.47,46.17 116.83,45.81 117.33,45.81 117.47,45.66 v2(117.47,45.49)
  BOTTOM w0.076: UC1.BF3 133.66,83.7 133.66,83.49 133.5,83.32 133.5,81.97 133.57,81.89 133.57,80.47 133.08,79.98 133.08,79.9 133.07,79.89
  BOTTOM w0.127: 133.07,79.89 131.26,78.08 128.74,78.08 128.42,78.39 v2(128.21,78.39) ; v2(117.47,45.49) 117.47,45.8 117.64,45.97 117.94,45.97 118.45,46.49 118.45,47.54 117.44,48.54 117.44,49.26 117.53,49.34 JDIMM1.55
DDR_M0_DQS3: length 50.8
  IN3 w0.127: v2(136.24,80.92) 136.03,80.71 135.53,80.71 134.94,80.12 134.94,76.03 133.08,74.16 133.08,70.19 123.93,61.04 123.93,56.13 123.15,55.35 123.15,45.71 123.52,45.33 124.07,45.33 v2(124.32,45.08)
  BOTTOM w0.076: v2(136.24,80.92) 136.01,80.69 135.88,80.69 135.77,80.8 135.77,81.57 136.01,81.81 136.01,83.53 UC1.BC3
  BOTTOM w0.127: JDIMM1.76 122.77,42.91 122.68,43 122.68,44.51 123.54,45.36 124.04,45.36 v2(124.32,45.08)
DDR_M0_DQS4: length 49.2
  IN3 w0.127: v2(151.91,47.02) 151.91,46.51 151.78,46.38 151.58,46.38 151.39,46.57 151.39,48.75 152.08,49.44 152.08,54.01 157.29,59.22 157.29,72.39 156.61,73.07 156.35,73.07 156.21,73.2 v2(156.21,73.3)
  BOTTOM w0.076: UC1.AB3 153.24,83.9 153.52,83.9 153.58,83.84 153.58,83.51 153.45,83.38 153.45,81.1 154.45,80.1 154.45,77.59 154.91,77.13 154.91,76.78 154.85,76.73 154.85,76.71
  BOTTOM w0.127: JDIMM1.179 150.52,49.38 150.45,49.3 150.45,49.1 151.11,48.44 151.11,47.03 151.62,46.51 151.77,46.51 151.91,46.65 v2(151.91,47.02) ; 154.85,76.71 154.85,75.95 156.71,74.09 156.71,73.24 156.54,73.07 156.33,73.07 156.21,73.19 v2(156.21,73.3)
DDR_M0_DQS5: length 49.6
  IN3 w0.127: v2(157.21,77.44) 157.36,77.44 157.4,77.48 157.58,77.66 158.05,77.66 160.95,74.77 160.95,73.35 161.8,72.5 161.8,56.72 157.5,52.42 157.5,50.36 156.97,49.83 156.97,46.96 157.49,46.44 157.49,45.12 157.21,44.84 156.97,44.84 156.79,44.65 v2(156.79,44.3)
  BOTTOM w0.076: UC1.V3 155.96,83.53 155.96,81.37 156.29,81.04 156.29,80.96 156.31,80.95
  BOTTOM w0.127: 156.31,80.95 157.68,79.58 157.68,77.81 157.31,77.44 v2(157.21,77.44) ; JDIMM1.200 155.77,42.89 155.68,42.98 155.68,43.35 156.32,43.99 156.32,44.57 156.45,44.7 156.66,44.7 156.79,44.57 v2(156.79,44.3)
DDR_M0_DQS6: length 50.4
  IN3 w0.076: 166.26,73.08 166.18,73.16 166.18,74.05 165.19,75.04 165.19,76.08 161.82,79.45 161.31,79.45 160.47,80.29 160.47,80.45 160.58,80.56 160.75,80.56 v2(160.84,80.46)
  IN3 w0.127: 166.26,73.08 166.26,54.87 163.14,51.75 163.14,50.71 162.88,50.46 162.88,46.56 163,46.45 163.53,46.45 163.68,46.6 v2(163.68,46.68)
  BOTTOM w0.076: v2(160.84,80.46) 160.78,80.52 160.49,80.52 160.35,80.39 160.06,80.39 159.42,81.03 159.42,81.24 158.47,82.19 158.47,83.35 158.65,83.53 158.65,83.6 158.65,83.74 158.57,83.82 UC1.R3
  BOTTOM w0.127: v2(163.68,46.68) 163.48,46.48 162.76,46.48 161.75,47.48 161.75,48.38 160.98,49.16 160.98,49.35 161.02,49.4 JDIMM1.221
DDR_M0_DQS7: length 54.3
  IN3 w0.127: v2(167.9,44.53) 167.9,44.58 167.69,44.78 167.32,44.78 167.09,45.01 167.09,45.9 167.92,46.74 167.92,48.32 168.84,49.23 169.09,49.23 169.55,49.7 169.55,50.63 170.82,51.89 170.82,52.35 171.85,53.39 171.85,62.51 171.3,63.06 171.3,63.98 171.55,64.24 171.75,64.24 171.85,64.34 171.85,64.77 171.75,64.87 171.56,64.87 171.3,65.12 171.3,71.77 170.45,72.63 170.45,76.51 164.72,82.24 163.38,82.24 163.24,82.11 163.24,81.84 v2(163.3,81.78)
  BOTTOM w0.076: UC1.M3 160.99,83.53 160.99,82.15 161.48,81.66 162.83,81.66 162.95,81.78 v2(163.3,81.78)
  BOTTOM w0.127: v2(167.9,44.53) 167.6,44.83 167.31,44.83 166.71,44.22 166.71,43.84 166.19,43.33 166.19,42.96 166.28,42.88 JDIMM1.242
DDR_M0_DQS#0: length 60.1
  IN3 w0.127: v2(105.62,47.9) 105.62,47.51 105.54,47.43 105.37,47.43 105,47.8 105,49.27 105.31,49.59 105.31,63.84 107.43,65.96 107.43,66.43 107.26,66.6 107.26,66.78 107.53,67.05 107.71,67.05 107.92,66.85 108.32,66.85 108.74,67.27 108.74,67.67 108.54,67.88 108.54,68.06 108.81,68.33 108.99,68.33 109.18,68.13 109.55,68.13 110.02,68.6 110.02,69.54 113.32,72.85 113.32,74.87 114.69,76.24 118.71,76.24 120.78,78.31 120.78,81.73 121.2,82.16 122.5,82.16 123.5,83.16 124.12,83.16 124.21,83.08 v2(124.21,82.83)
  BOTTOM w0.076: v2(124.21,82.83) 124.21,82.9 124.38,83.07 124.62,83.07 124.69,83 125.04,83 125.81,83.77 125.81,84.05 126.61,84.85 127.58,84.85 127.78,85.06 128.04,85.06 128.27,84.82 128.27,84.65 128.2,84.57 128.04,84.57 UC1.BR5
  BOTTOM w0.127: JDIMM1.11 106.53,49.41 106.75,49.19 106.75,48.22 105.95,47.43 105.71,47.43 105.62,47.52 v2(105.62,47.9)
DDR_M0_DQS#1: length 57.7
  IN3 w0.127: v2(126.95,80.41) 126.78,80.41 126.52,80.67 126.12,80.67 123.84,78.39 123.84,77.05 123.44,76.65 123.44,75.13 115.17,66.86 115.17,66.48 115.59,66.06 115.59,65.83 115.37,65.61 115.14,65.61 114.72,66.03 114.32,66.03 113.89,65.61 113.89,65.21 114.43,64.67 114.43,64.49 114.16,64.22 113.98,64.22 113.44,64.76 113.04,64.76 111.18,62.89 111.18,44.87 111.46,44.59 111.97,44.59 v2(112.24,44.32)
  BOTTOM w0.076: UC1.BL3 130.82,83.52 130.82,83.11 130.42,82.7 130.42,82.17 129.76,81.52 129.48,81.52 128.95,80.99 128.87,80.99 128.86,80.97
  BOTTOM w0.127: v2(112.24,44.32) 112.55,44.64 112.65,44.64 112.78,44.51 112.78,43.77 111.77,42.77 JDIMM1.32 ; 128.86,80.97 128.76,80.87 128.05,80.87 127.29,80.12 127.1,80.12 126.97,80.25 126.97,80.4 v2(126.95,80.41)
DDR_M0_DQS#2: length 54.9
  IN3 w0.127: v2(117.47,46.79) 117.47,46.2 117.35,46.07 116.94,46.07 116.74,46.28 116.74,47.22 117.56,48.04 117.56,60.86 128.58,71.88 128.58,76.41 129.03,76.86 129.03,78.16 128.56,78.63 128.56,78.75 v2(128.66,78.84)
  BOTTOM w0.076: 132.87,80.08 132.89,80.1 132.97,80.1 133.41,80.54 133.41,81.82 133.33,81.9 133.33,83.39 133.49,83.56 133.49,83.94 133.39,84.04 133.27,84.04 UC1.BG3
  BOTTOM w0.127: v2(117.47,46.79) 117.47,46.4 117.62,46.25 117.82,46.25 118.17,46.6 118.17,47.42 117.16,48.43 117.16,49.24 117.02,49.38 JDIMM1.53 ; 132.87,80.08 131.15,78.36 128.85,78.36 128.66,78.56 v2(128.66,78.84)
DDR_M0_DQS#3: length 50.8
  IN3 w0.127: v2(124.3,45.97) 124.3,45.75 124.16,45.6 123.63,45.6 123.41,45.82 123.41,55.24 124.2,56.02 124.2,60.93 133.35,70.08 133.35,74.05 135.21,75.91 135.21,80.01 135.64,80.44 136.07,80.44 136.1,80.41 136.11,80.41 v2(136.23,80.28)
  BOTTOM w0.076: UC1.BD3 135.85,83.53 135.85,81.88 135.61,81.64 135.61,80.73 135.81,80.53 135.98,80.53 v2(136.23,80.28)
  BOTTOM w0.127: JDIMM1.74 122.27,42.86 122.4,42.99 122.4,44.62 123.42,45.64 123.97,45.64 v2(124.3,45.97)
DDR_M0_DQS#4: length 49.2
  IN3 w0.127: v2(151.91,45.75) 151.91,45.94 151.73,46.12 151.47,46.12 151.12,46.46 151.12,48.86 151.81,49.56 151.81,54.12 157.03,59.33 157.03,72.28 156.5,72.8 156.33,72.8 v2(156.2,72.67)
  BOTTOM w0.076: UC1.AA3 153.74,83.66 153.74,83.44 153.62,83.31 153.62,81.17 154.61,80.17 154.61,77.66 155.07,77.2 155.07,76.78 155.13,76.73 155.13,76.71
  BOTTOM w0.127: v2(151.91,45.75) 151.91,46.1 151.78,46.22 151.78,46.22 151.77,46.23 151.51,46.23 150.83,46.91 150.83,48.33 150.34,48.81 150.33,48.81 150.17,48.98 150.17,49.07 150.16,49.07 150.16,49.31 150.02,49.44 JDIMM1.177 ; 155.13,76.71 155.13,76.06 156.99,74.2 156.99,73.12 156.66,72.8 156.33,72.8 v2(156.2,72.67)
DDR_M0_DQS#5: length 49.6
  IN3 w0.127: v2(157.62,77.03) 157.61,77.04 157.61,77.31 157.69,77.4 157.94,77.4 160.68,74.66 160.68,73.24 161.53,72.39 161.53,56.83 157.23,52.53 157.23,50.47 156.7,49.94 156.7,46.85 157.22,46.33 157.22,45.23 157.1,45.1 156.87,45.1 156.79,45.18 v2(156.79,45.59)
  BOTTOM w0.076: UC1.U3 156.13,83.54 156.13,81.44 156.41,81.16 156.49,81.16 156.5,81.15
  BOTTOM w0.127: v2(156.79,45.59) 156.79,45.12 156.66,44.98 156.34,44.98 156.04,44.69 156.04,44.11 155.4,43.47 155.4,43.05 155.28,42.92 JDIMM1.198 ; 156.5,81.15 157.96,79.69 157.96,77.7 157.62,77.36 v2(157.62,77.03)
DDR_M0_DQS#6: length 50.4
  IN3 w0.076: v2(160.43,80.88) 160.43,80.62 160.31,80.51 160.31,80.23 161.24,79.3 161.76,79.3 165.04,76.02 165.04,74.97 166.03,73.99 166.03,73.11 165.99,73.08
  IN3 w0.127: v2(163.68,46.05) 163.55,46.18 162.89,46.18 162.62,46.45 162.62,50.57 162.87,50.82 162.87,51.86 165.99,54.98 165.99,73.08
  BOTTOM w0.076: v2(160.43,80.88) 160.43,80.69 160.29,80.55 160.13,80.55 159.59,81.1 159.59,81.3 158.63,82.26 158.63,83.28 158.82,83.46 158.82,83.71 UC1.P3
  BOTTOM w0.127: JDIMM1.219 160.52,49.5 160.7,49.32 160.7,49.04 161.47,48.27 161.47,47.37 162.64,46.2 163.53,46.2 v2(163.68,46.05)
DDR_M0_DQS#7: length 54.3
  IN3 w0.127: v2(162.85,82.23) 162.99,82.23 163.26,82.51 164.83,82.51 170.71,76.63 170.71,72.74 171.57,71.88 171.57,65.24 171.67,65.14 171.86,65.14 172.12,64.88 172.12,64.23 172.07,64.18 171.86,63.97 171.66,63.97 171.57,63.87 171.57,63.17 172.12,62.62 172.12,53.28 171.08,52.24 171.08,51.78 169.82,50.52 169.82,49.59 169.2,48.96 168.95,48.96 168.19,48.21 168.19,46.63 167.35,45.79 167.35,45.12 167.43,45.05 167.83,45.05 167.9,45.12 v2(167.9,45.16)
  BOTTOM w0.076: UC1.L3 161.16,83.53 161.16,82.22 161.55,81.82 162.76,81.82 162.85,81.91 v2(162.85,82.23)
  BOTTOM w0.127: v2(167.9,45.16) 167.84,45.1 167.2,45.1 166.43,44.33 166.43,43.95 165.91,43.44 165.91,42.97 165.77,42.83 JDIMM1.240
DDR_M0_MA0: length 48.2
  IN3 w0.216: v2(142.64,45.16) 142.27,45.53 141.28,47.3 141.28,49.54 141,49.81 141,52.11 142.34,53.46 142.34,58.56 147.59,63.81 147.59,71.37 146.26,72.71 146.26,79.54 146.47,79.75 146.8,79.75 v2(146.81,79.76)
  BOTTOM w0.076: 148.17,81.07 148.42,81.33 148.42,83.53 148.13,83.82 UC1.AH3
  BOTTOM w0.196: v2(146.81,79.76) 146.86,79.76 148.17,81.07 ; v2(142.64,45.16) 140.22,43.31 139.77,42.87 JDIMM1.144
DDR_M0_MA1: length 46.5
  IN3 w0.216: v2(143.48,84.14) 142.75,84.14 142.53,84.36 142.53,84.96 142.83,85.26 143.84,85.26 145.51,83.59 145.51,71.34 144.7,70.53 144.7,68.67 144.4,68.38 144.4,64.27 137.32,57.18 137.32,52.94 137.85,52.4 137.85,49.25 137.73,49.13 v2(137.73,48.61)
  BOTTOM w0.089: v2(143.48,84.14) 143.47,84.14 UC1.AP4
  BOTTOM w0.196: JDIMM1.133 137.02,49.32 v2(137.73,48.61)
DDR_M0_MA2: length 47.3
  IN3 w0.216: v2(143.5,71.81) 143.13,71.45 143.13,69.32 142.84,69.03 142.84,64.91 135.76,57.83 135.76,49.52 136.06,49.21 136.06,44.89 136.78,44.18 v2(136.79,44.18)
  BOTTOM w0.076: UC1.AN4 144.39,83.91 144.39,81.77 144.93,81.23
  BOTTOM w0.196: v2(136.79,44.18) 136.77,44.16 JDIMM1.132 ; v2(143.5,71.81) 143.5,73.36 145.11,74.97 145.11,81.05 144.93,81.23
DDR_M0_MA3: length 48
  IN3 w0.216: v2(141.9,81.45) 143.54,81.45 144.99,80 144.99,71.56 144.18,70.74 144.18,68.89 143.88,68.6 143.88,64.48 136.8,57.4 136.8,49.95 137.1,49.64 137.1,47.93 137.6,47.44 v2(137.73,47.44)
  BOTTOM w0.076: UC1.AP5 142.53,84.55 142.53,81.87 142.11,81.45 v2(141.9,81.45)
  BOTTOM w0.196: v2(137.73,47.44) 137.2,47.44 136.85,47.79 136.85,48.76 136.52,49.09 JDIMM1.131
DDR_M0_MA4: length 49.5
  IN3 w0.216: v2(141.82,80.27) 141.93,80.38 143.24,80.38 144.47,79.15 144.47,71.77 143.65,70.96 143.65,69.11 143.36,68.81 143.36,64.7 136.28,57.61 136.28,49.73 136.58,49.43 136.58,46.66 136.98,46.26 v2(137.73,46.26)
  BOTTOM w0.076: v2(141.82,80.27) 141.97,80.27 142.77,81.07 142.77,82.83 UC1.AP2
  BOTTOM w0.196: JDIMM1.128 135.77,42.82 135.97,43.01 135.97,45.18 137.05,46.26 v2(137.73,46.26)
DDR_M0_MA5: length 47
  IN3 w0.216: v2(134.76,45.85) 134.85,45.85 135.54,46.53 135.54,48.99 135.23,49.3 135.23,58.04 142.32,65.13 142.32,69.24 142.61,69.54 142.61,71.66 143.95,73 143.95,77.89 142.14,79.69 v2(141.82,79.69)
  BOTTOM w0.076: v2(141.82,79.69) 142.1,79.69 143.1,80.69 UC1.AP1
  BOTTOM w0.196: JDIMM1.126 135.27,43.09 135.47,43.28 135.47,45.56 135.21,45.82 134.78,45.82 v2(134.76,45.85)
DDR_M0_MA6: length 48.9
  IN3 w0.216: v2(134.71,48.25) 134.61,48.25 134.28,48.58 134.28,50.48 134.09,50.67 134.09,52.45 134.71,53.08 134.71,58.26 141.8,65.35 141.8,69.46 142.09,69.75 142.09,71.88 143.43,73.21 143.43,77.4 142.32,78.51 v2(141.86,78.51)
  BOTTOM w0.076: UC1.AP3 143.39,83.52 143.39,80.33 143.08,80.02
  BOTTOM w0.196: 143.08,80.02 142.75,79.69 142.75,78.87 142.39,78.51 v2(141.86,78.51) ; JDIMM1.127 135.53,49.36 136.31,48.58 136.31,47.6 136.68,47.22 136.68,46.95 136.36,46.62 136.09,46.62 135.61,47.1 135.61,48.06 135.41,48.25 v2(134.71,48.25)
DDR_M0_MA7: length 47.2
  IN3 w0.216: v2(134.73,43.44) 134.57,43.44 132.72,45.28 132.72,49.83 132.53,50.02 132.53,53.1 133.09,53.67 133.09,58.88 140.24,66.03 140.24,70.11 140.53,70.4 140.53,72.53 141.46,73.46 141.46,75.08 141.88,75.5 v2(141.94,75.5)
  BOTTOM w0.076: 144.06,78.96 144.06,82.29 UC1.AN1
  BOTTOM w0.196: 144.06,78.96 144.06,76.73 142.83,75.5 v2(141.94,75.5) ; JDIMM1.122 134.27,43.17 134.54,43.44 v2(134.73,43.44)
DDR_M0_MA8: length 47.2
  IN3 w0.216: v2(141.91,76.11) 142.43,76.11 142.9,75.64 142.9,73.43 141.57,72.1 141.57,69.97 141.28,69.68 141.28,65.56 134.19,58.48 134.19,53.29 133.57,52.67 133.57,50.45 133.76,50.26 133.76,47.83 v2(134.59,47)
  BOTTOM w0.076: 143.55,79.02 143.55,79.26 143.76,79.47 143.76,82.08 143.56,82.28 143.56,83.54 UC1.AN3
  BOTTOM w0.196: v2(141.91,76.11) 142.7,76.11 143.55,76.97 143.55,79.02 ; v2(134.59,47) 134.43,47 134.06,47.37 134.06,48.32 135.02,49.28 JDIMM1.125
DDR_M0_MA9: length 49.3
  IN3 w0.216: v2(132.2,45.52) 132.2,49.62 132.01,49.81 132.01,53.32 132.57,53.88 132.57,59.1 139.72,66.24 139.72,70.32 140.01,70.62 140.01,72.74 140.94,73.67 140.94,75.29 141.39,75.74 141.39,76.85 v2(141.86,77.32)
  BOTTOM w0.076: 141.18,80.82 141.15,80.84 141.15,81.7 141.62,82.17 141.62,84.17 UC1.AT4
  BOTTOM w0.196: v2(141.86,77.32) 141.73,77.32 141.18,77.88 141.18,80.82 ; JDIMM1.121 134.02,49.13 132.2,47.31 v2(132.2,45.52)
DDR_M0_MA10: length 47.8
  IN3 w0.216: v2(146.79,81.61) 147.07,81.61 148.73,79.95 148.73,76.7 147.92,75.89 147.92,73.25 149.15,72.02 149.15,63.16 143.91,57.91 143.91,52.76 143.01,51.87 143.01,50.09 143.16,49.93 143.16,44.3 142.81,43.94 v2(142.64,43.94)
  BOTTOM w0.076: UC1.AH2 147.81,82.85 147.81,82.27
  BOTTOM w0.196: 147.81,82.27 147.81,82.02 147.4,81.61 v2(146.79,81.61) ; v2(142.64,43.94) 142.48,44.1 142.16,44.1 141.86,43.8 141.86,43.26 142.28,42.85 JDIMM1.146
DDR_M0_MA11: length 48.4
  IN3 w0.216: v2(134.76,44.67) 134.13,44.67 133.24,45.56 133.24,50.05 133.05,50.24 133.05,52.89 133.67,53.51 133.67,58.69 140.76,65.78 140.76,69.89 141.05,70.19 141.05,72.31 141.98,73.24 v2(141.98,74.18)
  BOTTOM w0.076: 144.6,79.47 144.6,81.07 144.23,81.44 144.23,83.09 144.15,83.17 UC1.AN2
  BOTTOM w0.196: v2(134.76,44.67) 134.5,44.67 133.77,43.95 JDIMM1.120 ; 144.6,79.47 144.6,76.27 142.51,74.18 v2(141.98,74.18)
DDR_M0_MA12: length 49.1
  IN3 w0.216: v2(138.82,80.8) 139.07,80.8 140.35,79.52 140.35,76.17 139.9,75.73 139.9,74.11 138.15,72.36 138.15,66.89 130.42,59.16 130.42,49.67 131.16,48.93 131.16,47.18 130.87,46.89 v2(130.64,46.89)
  BOTTOM w0.076: v2(138.82,80.8) 140.19,82.17 140.19,83.19 140.51,83.5 140.78,83.5 140.96,83.68 140.96,84.09 UC1.AU4
  BOTTOM w0.196: v2(130.64,46.89) 130.99,46.89 133.53,49.42 JDIMM1.119
DDR_M0_MA13: length 47
  IN3 w0.216: v2(146.77,44.47) 146.53,44.47 145.39,45.61 145.39,50.41 145.99,51 145.99,56.28 151.24,61.52 151.24,72.89 150.09,74.03 150.09,75.11 150.98,76 v2(150.98,78.59)
  BOTTOM w0.076: UC1.AE3 151.02,83.44 151.02,83.02 151.09,82.96 151.09,80.56 150.58,80.06 150.58,78.99 v2(150.98,78.59)
  BOTTOM w0.196: JDIMM1.158 145.28,43.15 146.6,44.47 v2(146.77,44.47)
DDR_M0_MA14_WE#: length 46.1
  IN3 w0.216: v2(149.77,81.34) 149.77,76.27 149.05,75.55 149.05,73.6 150.2,72.45 150.2,61.96 149.76,61.52 149.46,61.52 149.37,61.6 149.07,61.6 148.84,61.37 148.84,61.11 148.98,60.97 148.98,60.75 148.71,60.47 148.45,60.47 148.33,60.6 148.07,60.6 147.79,60.33 147.79,60.11 147.94,59.96 147.94,59.7 147.68,59.44 147.44,59.44 147.32,59.56 147.03,59.56 146.77,59.3 146.77,59.09 146.9,58.96 146.9,58.66 146.69,58.45 146.39,58.45 146.3,58.53 146,58.53 145.79,58.32 145.79,58.02 145.87,57.93 145.87,57.63 144.95,56.71 144.95,52.33 144.51,51.9 144.51,51.01 144.35,50.85 v2(144.35,48.54)
  BOTTOM w0.076: UC1.AG4 149.17,84.77 149.58,84.77 149.59,84.78 150.03,84.78 150.11,84.71 150.11,82.28 150.36,82.03 150.36,81.5 150.2,81.34 v2(149.77,81.34)
  BOTTOM w0.196: JDIMM1.151 143.52,49.2 144.19,48.54 v2(144.35,48.54)
DDR_M0_MA15_CAS#: length 46.9
  IN3 w0.216: v2(150.98,79.89) 151.27,80.19 151.7,80.19 151.96,79.93 151.96,78.05 151.59,77.68 151.59,75.88 150.61,74.9 150.61,74.24 151.76,73.1 151.76,61.31 146.52,56.08 146.52,50.8 145.92,50.19 145.92,46.04 146.21,45.74 v2(146.77,45.74)
  BOTTOM w0.076: UC1.AD1 151.38,80.3 v2(150.98,79.89)
  BOTTOM w0.196: v2(146.77,45.74) 146.64,45.74 146.19,45.3 146.19,44.79 144.77,43.37 JDIMM1.156
DDR_M0_MA16_RAS#: length 49.2
  IN3 w0.216: v2(146.79,82.23) 146.81,82.26 147.46,82.26 149.25,80.47 149.25,76.48 148.44,75.67 148.44,73.47 149.67,72.24 149.67,62.94 144.43,57.7 144.43,52.55 143.53,51.65 143.53,50.3 143.68,50.15 143.68,46 144.19,45.49 v2(144.35,45.49)
  BOTTOM w0.076: v2(146.79,82.23) 146.89,82.13 147.35,82.13 147.62,82.4 147.62,84.3 147.79,84.47 UC1.AH4
  BOTTOM w0.196: JDIMM1.152 143.77,43.17 144.1,43.49 144.1,45.24 v2(144.35,45.49)
DDR_M0_ODT0: length 52.4
  IN3 w0.216: v2(146.77,48.28) 147.01,48.28 147.23,48.5 147.23,49.11 146.77,49.57 146.77,49.84 147.38,50.45 147.38,55.72 152.61,60.96 152.61,70.94 152.81,71.14 153.06,71.14 153.2,71.28 153.2,71.83 153.05,71.98 152.76,71.98 152.61,72.13 152.61,72.63 152.78,72.8 153.1,72.8 153.31,73.01 153.31,73.42 153.15,73.58 152.8,73.58 152.61,73.77 152.61,74.02 152.89,74.3 152.89,74.57 152.31,75.15 152.07,75.15 151.69,74.77 v2(151.69,74.37)
  BOTTOM w0.076: UC1.AD3 151.64,83.82 151.91,83.55 151.91,82.4 151.94,82.38 151.94,79.84 151.68,79.59 151.68,78.14 151.43,77.89
  BOTTOM w0.196: v2(146.77,48.28) 146.49,48.28 146.35,48.42 146.35,48.73 146.15,48.92 145.79,48.92 145.59,48.73 145.59,48.14 145.46,48.01 145.11,48.01 144.89,48.23 144.89,48.82 144.52,49.19 JDIMM1.155 ; v2(151.69,74.37) 151.69,74.73 151.89,74.93 152.17,74.93 152.9,74.2 153.17,74.2 153.43,74.46 153.43,74.83 152.41,75.86 152.11,75.86 151.98,75.74 151.68,75.74 151.43,75.99 151.43,77.89
DDR_M0_ODT1: length 54.6
  IN3 w0.216: v2(148.42,52.42) 148.57,52.42 149.1,52.96 149.1,55.24 154.31,60.45 154.31,70.51 153.75,71.07 v2(153.68,71.07)
  BOTTOM w0.076: UC1.AE4 150.69,84.47 151.01,84.15 151.01,83.74 151.26,83.49 151.57,83.49 151.67,83.39 151.67,80.03 151.38,79.74 151.38,78.34 151.17,78.14
  BOTTOM w0.196: JDIMM1.161 146.02,51.48 146.96,52.42 v2(148.42,52.42) ; v2(153.68,71.07) 154.14,71.07 154.32,70.89 154.32,68.81 154.59,68.54 154.98,68.54 155.18,68.74 155.18,69.52 155.37,69.71 157.34,69.71 157.52,69.89 157.52,70.2 157.31,70.41 155.37,70.41 155.18,70.61 155.18,73.74 154.88,74.04 153.94,74.04 153.6,73.7 152.24,73.7 152.07,73.87 151.36,73.87 151.1,74.12 151.1,75.18 150.76,75.52 150.76,77.73 151.17,78.14
DDR_M0_PAR: length 46.8
  IN3 w0.216: v2(146.8,78.5) 146.8,72.9 148.11,71.59 148.11,63.59 142.86,58.34 142.86,53.24 141.52,51.9 141.52,50.03 141.8,49.75 141.8,47.51 142.48,46.84 v2(142.64,46.84)
  BOTTOM w0.076: UC1.AG3 148.66,83.82 148.59,83.74 148.59,81.11
  BOTTOM w0.196: 148.59,81.11 148.59,80.81 147.49,79.72 147.49,79.1 146.89,78.5 v2(146.8,78.5) ; v2(142.64,46.84) 140.24,49.24 139.74,49.24 139.52,49.45 JDIMM1.143
DDR_M1_ACT#: length 66.5
  IN1 w0.076: 139.97,74.44 139.97,74.77 140.62,75.42 140.62,81.81 141.25,82.45 141.25,83.22 142.37,84.33 142.37,85.76 142.66,86.05 142.66,87.33 v2(141.94,88.05)
  IN1 w0.203: v2(130.11,30.66) 129.27,31.5 129.27,32.27 128.95,32.59 128.95,46.34 128.54,46.76 128.54,53.77 129.79,55.02 129.79,59.57 139.97,69.75 139.97,74.44
  BOTTOM w0.076: v2(141.94,88.05) 141.61,87.73 UC1.AT9
  BOTTOM w0.196: v2(130.11,30.66) 130.23,30.66 130.78,30.11 JDIMM2.114
DDR_M1_ALERT#: length 67.3
  IN1 w0.076: v2(141.95,86.78) 141.45,86.28 141.2,85.95 140.37,83.35 140.37,82.58 139.86,82.07 139.86,76.63 138.11,74.88 138.11,74.82
  IN1 w0.203: 138.11,74.82 138.11,72.88 137.69,72.46 137.69,70.09 127.13,59.53 127.13,56.21 126.5,55.58 126.5,44.9 126.43,44.83 126.43,39.84 126.65,39.62 126.65,36.8 126.78,36.68 126.78,34.14 127.79,32.32 128.21,31.9 v2(128.22,31.9)
  BOTTOM w0.076: v2(141.95,86.78) 142.25,87.08 UC1.AR8
  BOTTOM w0.196: v2(128.22,31.9) 130.24,31.9 131.28,30.86 JDIMM2.116
DDR_M1_BA0: length 66.2
  IN1 w0.076: v2(148.34,87.4) 148.63,87.11 148.63,86.59 148.48,86.44 148.48,82.92 148.75,82.65 148.75,80.64 149.23,80.17 149.23,77.03 150.7,75.56 150.7,75.17
  IN1 w0.203: v2(142.17,31.44) 142.17,31.27 141.96,31.06 141.42,31.06 141.17,31.31 141.17,32.04 141.43,32.3 141.43,36.17 141.67,36.41 141.67,48.7 142.47,49.5 142.47,50.61 141.98,51.1 141.98,51.96 142.47,52.45 142.47,56.63 151.17,65.32 151.17,73.3 150.7,73.76 150.7,75.17
  BOTTOM w0.089: v2(148.34,87.4) 148.2,87.4 UC1.AH8
  BOTTOM w0.196: v2(142.17,31.44) 141.78,31.05 JDIMM2.150
DDR_M1_BA1: length 67.5
  IN1 w0.076: v2(147.42,87.37) 147.7,87.37 147.82,87.26 147.82,86.55 148.07,86.29 148.07,82.71 148.21,82.57 148.21,80.25 148.64,79.82 148.64,76.31 149.68,75.27 149.68,75.11
  IN1 w0.203: v2(139.4,33.42) 139.41,33.42 140.04,32.79 140.24,32.79 140.42,32.96 140.42,33.46 139.93,33.94 139.93,34.44 140.09,34.6 140.27,34.6 140.42,34.74 140.42,36.6 140.65,36.83 140.65,39.33 140.25,39.74 140.25,40.95 140.65,41.36 140.65,42.04 140.25,42.44 140.25,43.07 140.65,43.48 140.65,49.28 140.96,49.59 140.96,52.38 141.46,52.87 141.46,57.06 150.14,65.74 150.14,72.88 149.68,73.34 149.68,75.11
  BOTTOM w0.089: UC1.AH9 147.78,87.73 v2(147.42,87.37)
  BOTTOM w0.196: JDIMM2.145 140.53,34.37 139.58,33.42 v2(139.4,33.42)
DDR_M1_BG0: length 65.6
  IN1 w0.076: 139.46,74.71 139.46,74.78 140.31,75.64 140.31,81.81 140.95,82.45 140.95,83.32 142.16,84.53 142.16,85.86 142.21,86.07 142.31,86.76 142.31,86.98 v2(141.95,87.42)
  IN1 w0.203: 139.46,74.71 139.46,72.32 139.03,71.89 139.03,69.53 129.28,59.78 129.28,55.24 128.03,53.98 128.03,44.53 127.77,44.28 127.77,41.91 127.95,40.23 128.22,39.96 128.22,33.77 v2(128.37,33.62)
  BOTTOM w0.076: UC1.AR9 142.08,87.42 v2(141.95,87.42)
  BOTTOM w0.196: JDIMM2.115 131.03,36.47 128.37,33.82 v2(128.37,33.62)
DDR_M1_BG1: length 65.4
  IN1 w0.076: 138.95,74.68 138.95,75.09 140.11,76.25 140.11,81.94 140.66,82.48 140.66,83.51 141.37,84.22 141.37,85.61 v2(141.82,86.07)
  IN1 w0.203: v2(127.72,34.44) 127.71,34.44 127.71,39.75 127.27,40.19 127.27,44.49 127.52,44.74 127.52,54.19 127.96,54.64 127.96,55.68 128.17,55.88 128.57,55.88 128.78,56.09 128.78,56.49 128.57,56.7 128.17,56.7 127.96,56.9 127.96,57.31 128.17,57.51 128.57,57.51 128.78,57.71 128.78,58.12 128.57,58.32 128.17,58.32 127.96,58.52 127.96,59.18 138.52,69.74 138.52,72.11 138.95,72.53 138.95,74.68
  BOTTOM w0.089: v2(141.82,86.07) 142.18,86.43 UC1.AR7
  BOTTOM w0.196: JDIMM2.113 130.53,36.7 128.26,34.44 v2(127.72,34.44)
DDR_M1_CKE0: length 68.5
  IN1 w0.076: v2(141.07,87.4) 140.48,86.81 140.48,86 139.72,85.23 139.72,82.8 139.35,82.43 139.35,76.97 139.01,76.62 138.64,76.62 136.98,74.96
  IN1 w0.203: v2(125.3,34.57) 124.89,34.98 124.89,36.44 125.3,36.85 125.3,37.85 124.99,38.17 124.99,55.98 125.68,56.67 125.68,57.06 125.48,57.26 125.19,57.26 124.99,57.47 124.99,57.83 125.19,58.03 125.58,58.03 125.78,58.24 125.78,58.54 125.58,58.75 125.19,58.75 124.99,58.95 124.99,59.3 136.34,70.65 136.34,73.02 136.76,73.44 136.76,74.74 136.98,74.96
  BOTTOM w0.076: 141.39,87.08 v2(141.07,87.4)
  BOTTOM w0.089: UC1.AT8 141.39,87.08
  BOTTOM w0.196: v2(125.3,34.57) 126.67,34.57 128.45,36.35 129.19,36.35 129.53,36.68 JDIMM2.109
DDR_M1_CKE1: length 67.6
  IN1 w0.076: v2(141.06,88.09) 141.43,87.51 141.43,87.38 141.37,86.73 140.86,85.88 140.53,84.74 140.1,83.21 139.93,82.75 139.6,82.08 139.6,76.93 137.69,75.02
  IN1 w0.203: v2(128.22,30.63) 128.11,30.71 127.23,31.67 126.89,32.13 126.19,33.47 125.81,34.15 125.81,38.06 125.5,38.77 125.5,55.77 126.29,56.56 126.29,59.88 136.85,70.44 136.85,72.81 137.27,73.23 137.27,73.95 137.69,75.02
  BOTTOM w0.076: UC1.AT10 141.35,88.38 v2(141.06,88.09)
  BOTTOM w0.196: v2(128.22,30.63) 129.24,30.63 129.78,30.09 JDIMM2.110
DDR_M1_CLK0: length 64.3
  IN1 w0.076: 146.73,77.8 146.73,77.82 146.66,77.88 146.66,78.1 146.4,78.37 146.4,83.93 146.55,84.09 146.55,85.62 145.97,86.2 145.56,86.2 145.19,86.57 145.19,87.37 145.08,87.48 145.08,87.71 v2(144.72,88.06)
  IN1 w0.127: 146.73,77.8 146.73,75.3 147.12,74.91 147.12,72.3 147.55,71.87 147.55,66.73 138.89,58.07 138.16,53.04 138.16,51.73 137.31,49.22 137.31,46.18 137.48,45.15 137.52,44.87 137.52,44.84 137.52,44.07 137.31,42.69 137.31,37.77 136.59,37.05 136.59,35.01 136.77,34.83 137.01,34.83 137.13,34.96 v2(137.13,35.01)
  BOTTOM w0.076: UC1.AM9 145.2,87.79 145.2,87.97 145.08,88.09 144.75,88.09 v2(144.72,88.06)
  BOTTOM w0.127: v2(137.13,35.01) 137.28,34.87 137.29,34.87 137.31,34.85 137.65,34.85 137.88,35.07 137.88,35.6 137.42,36.05 137.13,36.05 136.53,36.66 JDIMM2.137
DDR_M1_CLK1: length 65.8
  IN1 w0.076: 147.3,79.35 147.3,79.37 147.36,79.43 147.36,79.65 147.25,79.77 147.25,83.81 146.93,84.13 146.93,86.09 145.93,87.09 145.71,87.09 145.58,86.97 v2(145.58,86.68)
  IN1 w0.127: v2(137.12,32.52) 137.12,32.48 137.25,32.35 137.53,32.35 137.67,32.49 137.67,37.31 138.15,37.79 138.15,49.62 138.59,50.05 138.59,53.01 139.36,53.78 139.36,57.93 148.04,66.6 148.04,72.01 147.58,72.46 147.58,75.35 147.3,75.62 147.3,79.35
  BOTTOM w0.076: v2(145.58,86.68) 145.39,86.68 UC1.AM7
  BOTTOM w0.127: v2(137.12,32.52) 137.12,32.5 136.94,32.31 136.65,32.31 136.3,31.96 136.3,31.02 136.89,30.44 136.89,30.2 136.78,30.09 JDIMM2.138
DDR_M1_CLK#0: length 64.3
  IN1 w0.076: 146.45,77.8 146.45,77.82 146.51,77.88 146.51,78.04 146.4,78.15 146.24,78.31 146.24,84 146.4,84.15 146.4,85.55 145.9,86.05 145.49,86.05 145.04,86.5 145.04,87.3 144.88,87.47 v2(144.72,87.47)
  IN1 w0.127: v2(137.13,34.43) 137.02,34.55 136.66,34.55 136.31,34.89 136.31,37.17 137.03,37.89 137.03,42.71 137.24,44.09 137.24,44.83 137.24,44.85 137.03,46.16 137.03,49.27 137.88,51.77 137.88,53.06 138.63,58.2 147.27,66.85 147.27,71.75 146.84,72.18 146.84,74.79 146.45,75.19 146.45,77.8
  BOTTOM w0.076: v2(144.72,87.47) 144.48,87.47 UC1.AN9
  BOTTOM w0.127: JDIMM2.139 137.03,36.56 137.25,36.33 137.53,36.33 138.16,35.71 138.16,34.95 137.77,34.57 137.27,34.57 v2(137.13,34.43)
DDR_M1_CLK#1: length 65.7
  IN1 w0.076: v2(145.61,87.47) 145.83,87.24 145.99,87.24 147.08,86.15 147.08,84.19 147.4,83.87 147.4,79.83 147.52,79.71 147.52,79.43 147.58,79.37 147.58,79.35
  IN1 w0.127: 147.58,79.35 147.58,75.74 147.86,75.46 147.86,72.58 148.32,72.12 148.32,66.49 139.64,57.82 139.64,53.67 138.87,52.89 138.87,49.93 138.43,49.5 138.43,37.68 137.95,37.2 137.95,32.38 137.65,32.07 137.26,32.07 v2(137.12,31.93)
  BOTTOM w0.076: UC1.AM8 145.22,87.08 v2(145.61,87.47)
  BOTTOM w0.127: JDIMM2.140 137.28,30.09 137.16,30.2 137.16,30.55 136.58,31.14 136.58,31.84 136.77,32.03 137.03,32.03 v2(137.12,31.93)
DDR_M1_CS#0: length 69.5
  IN1 w0.076: v2(150.15,88.67) 150.57,88.25 150.57,86.53 150.49,86.46 150.49,83.7 151.38,82.81 151.38,79.17 154.7,75.84 154.7,75.34
  IN1 w0.203: v2(144.61,33.81) 144.73,33.81 145.55,34.62 145.55,36.94 146.31,37.71 146.31,41.83 145.9,42.24 145.9,44.49 146.16,44.74 146.16,49.28 146.7,49.82 146.7,54.32 148.01,55.63 148.01,56.02 147.48,56.54 147.48,56.84 155.06,64.42 155.06,71.04 154.7,71.4 154.7,75.34
  BOTTOM w0.089: UC1.AF11 149.79,89.03 v2(150.15,88.67)
  BOTTOM w0.196: v2(144.61,33.81) 144.4,33.6 142.06,33.6 141.53,34.14 JDIMM2.149
DDR_M1_CS#1: length 69
  IN1 w0.076: v2(151.02,86.08) 150.66,85.72 150.66,83.99 151.62,83.03 151.62,79.46 155.21,75.87 155.21,75.4
  IN1 w0.203: 155.21,75.4 155.21,71.6 155.57,71.25 155.57,64.2 151.63,60.26 151.63,58.53 150.74,57.64 150.45,57.64 149.95,58.14 149.68,58.14 149.37,57.84 149.37,57.53 149.86,57.04 149.86,56.76 149.64,56.54 149.35,56.54 148.78,57.12 148.49,57.12 148.22,56.85 148.22,56.52 148.78,55.97 148.78,55.68 147.22,54.12 147.22,43.67 146.82,43.27 146.82,37.49 146.06,36.73 146.06,33.88 146.39,33.55 v2(146.51,33.55)
  BOTTOM w0.076: UC1.AE7 150.97,86.08 v2(151.02,86.08)
  BOTTOM w0.196: v2(146.51,33.55) 145.88,33.55 145.12,34.31 145.12,35.33 144.73,35.71 144.31,35.71 143.53,36.5 JDIMM2.157
DDR_M1_D0: length 77.4
  IN1 w0.127: v2(104.6,31.72) 103.65,32.66 103.65,33.44 102.42,34.68 102.42,37.59 101.95,38.06 101.95,43.07 100.41,44.6 100.41,49.42 103.12,52.13 103.12,58.05 103.7,58.64 103.7,63.78 112.43,72.51 112.43,79.99 arc(112.77,81.7) 113.74,83.15 115.17,84.58 118.23,84.58 122.2,88.55 123.02,88.55 123.53,89.06 124.74,89.06 v2(124.79,89.02)
  BOTTOM w0.076: v2(124.79,89.02) 125.21,88.59 126.4,88.59 126.61,88.8 127.12,88.8 UC1.BT11
  BOTTOM w0.127: JDIMM2.8 104.28,31.4 v2(104.6,31.72)
DDR_M1_D1: length 78.3
  IN1 w0.127: v2(104.57,33.04) 104.57,33.13 102.8,34.91 102.8,37.82 102.38,38.24 102.38,43.25 100.84,44.78 100.84,49.24 103.5,51.9 103.5,57.89 104.13,58.53 104.13,63.67 112.82,72.35 112.82,79.99 arc(113.13,81.55) 114.01,82.88 115.33,84.2 118.46,84.2 122.38,88.11 123.2,88.11 123.7,88.62 v2(124.36,88.62)
  BOTTOM w0.076: v2(124.36,88.62) 124.58,88.39 126.6,88.39 126.74,88.54 127.5,88.54 UC1.BR11
  BOTTOM w0.127: JDIMM2.7 104.03,36.35 103.67,35.99 103.67,33.95 v2(104.57,33.04)
DDR_M1_D2: length 76.4
  IN1 w0.127: v2(106.51,34.69) 106.22,34.69 106.09,34.83 106.09,38.05 106.32,38.28 106.32,39.62 106.19,39.75 105.71,39.75 105.58,39.88 105.58,40.13 105.71,40.26 106.19,40.26 106.32,40.38 106.32,41.64 106.19,41.77 105.71,41.77 105.58,41.9 105.58,42.15 105.71,42.28 106.19,42.28 106.32,42.4 106.32,42.77 106.13,42.95 105.76,42.95 105.63,43.08 105.63,43.33 105.76,43.46 106.19,43.46 106.32,43.59 106.32,43.84 106.19,43.97 105.76,43.97 105.63,44.1 105.63,44.35 105.76,44.48 106.22,44.48 106.32,44.57 106.32,56.94 107.04,57.67 107.04,60.26 106.7,60.6 106.7,62.6 115.47,71.38 115.47,74.06 115.95,74.53 118.7,74.53 121.34,77.17 121.34,82.35 121.63,82.64 121.63,83.74 122.58,84.69 124.45,84.69 125.66,85.9 125.66,87.03 126.11,87.48 126.29,87.48 v2(126.81,88)
  BOTTOM w0.076: UC1.BT9 126.99,88.18 v2(126.81,88)
  BOTTOM w0.127: JDIMM2.16 106.28,30.51 105.64,31.14 105.64,33.83 v2(106.51,34.69)
DDR_M1_D3: length 77.3
  IN1 w0.127: v2(125.01,87.95) 124.91,87.85 124.91,87.2 123.84,86.13 122.94,86.13 120.86,84.05 120.86,82.95 120.58,82.66 120.58,77.49 118.4,75.31 115.65,75.31 114.71,74.37 114.71,71.7 105.94,62.92 105.94,57.78 105.3,57.15 105.3,49.95 104.18,48.83 104.18,38.99 105.22,37.95 105.22,33.44 v2(106.51,32.15)
  BOTTOM w0.076: v2(125.01,87.95) 125.01,87.56 125.88,86.69 127.23,86.69 UC1.BR8
  BOTTOM w0.127: v2(106.51,32.15) 107.14,32.79 107.14,36.24 107.53,36.62 JDIMM2.21
DDR_M1_D4: length 78.7
  IN1 w0.127: v2(101.87,35.74) 101.51,36.1 101.51,42.89 99.98,44.43 99.98,49.53 102.1,51.65 102.1,52.08 102.23,52.21 102.61,52.21 102.74,52.34 102.74,52.59 102.61,52.72 102.23,52.72 102.1,52.84 102.1,53.1 102.23,53.23 102.61,53.23 102.74,53.35 102.74,53.61 102.61,53.73 102.23,53.73 102.1,53.86 102.1,54.11 102.23,54.24 102.61,54.24 102.74,54.37 102.74,54.62 102.61,54.75 102.23,54.75 102.1,54.88 102.1,57.58 103.27,58.74 103.27,59.02 103.18,59.11 102.65,59.11 102.53,59.24 102.53,59.49 102.65,59.62 103.18,59.62 103.27,59.71 103.27,63.88 112.05,72.67 112.05,79.99 arc(112.42,81.85) 113.47,83.42 115.01,84.96 117.75,84.96 121.77,88.98 122.84,88.98 123.39,89.53 125.71,89.53 v2(126,89.24)
  BOTTOM w0.076: v2(126,89.24) 126.26,88.98 126.78,88.98 127.06,89.26 128.29,89.26 UC1.BP11
  BOTTOM w0.127: v2(101.87,35.74) 102.57,35.74 102.81,35.98 102.81,36.36 103.03,36.58 JDIMM2.3
DDR_M1_D5: length 79.5
  IN1 w0.127: v2(126.18,89.88) 126.1,89.96 123.21,89.96 122.66,89.41 121.66,89.41 117.6,85.34 114.86,85.34 113.2,83.69 arc(112.07,81.99) 111.67,79.99 111.67,72.83 102.84,63.99 102.84,61.5 102.19,59.69 101.67,57.94 101.67,53.96 99.55,49.51 99.55,44.25 101.08,42.71 101.08,36.14 101.59,34.9 102.61,33.88 v2(102.9,31.1)
  BOTTOM w0.076: UC1.BN11 128.77,89.44 126.62,89.44 v2(126.18,89.88)
  BOTTOM w0.127: JDIMM2.4 103.28,30.72 v2(102.9,31.1)
DDR_M1_D6: length 77.2
  IN1 w0.127: v2(106.53,35.96) 106.8,35.96 106.94,36.1 106.94,36.79 106.47,37.26 106.47,37.89 106.7,38.12 106.7,56.71 107.55,57.56 107.55,60.6 107.42,60.72 107.21,60.72 107.08,60.85 107.08,61.1 107.21,61.23 107.42,61.23 107.55,61.36 107.55,61.61 107.42,61.74 107.21,61.74 107.08,61.87 107.08,62.38 116,71.3 116,71.9 116.15,72.05 116.75,72.05 116.87,72.16 116.87,72.43 116.73,72.57 115.97,72.57 115.85,72.69 115.85,73.03 115.98,73.15 116.89,73.15 117.89,74.15 118.85,74.15 121.87,77.17 121.87,80.77 122.03,80.92 122.37,80.92 122.5,81.05 122.5,81.39 122.3,81.58 121.91,81.58 121.78,81.72 121.78,82.25 121.95,82.42 122.14,82.42 122.51,82.05 122.76,82.05 122.89,82.17 122.89,82.33 122.01,83.21 122.01,83.58 122.1,83.67 122.27,83.67 123.31,82.63 123.46,82.63 123.67,82.84 123.67,82.99 122.65,84.01 122.65,84.17 122.77,84.3 123.08,84.3 123.79,83.59 124.12,83.59 124.33,83.8 124.33,83.95 126.43,86.05 127.03,86.05 127.18,86.2 127.18,86.43 127.05,86.56 126.36,86.56 126.22,86.7 v2(126.22,87.06)
  BOTTOM w0.076: UC1.BP8 128.27,87.71 127.38,87.71 127.13,87.45 126.62,87.45 v2(126.22,87.06)
  BOTTOM w0.127: v2(106.53,35.96) JDIMM2.17
DDR_M1_D7: length 78.1
  IN1 w0.127: v2(106.51,33.42) 105.66,34.28 105.66,38.13 105.2,38.58 105.2,41.39 105.07,41.52 104.91,41.52 104.78,41.65 104.78,41.9 104.91,42.03 105.07,42.03 105.2,42.16 105.2,42.41 105.07,42.54 104.69,42.54 104.56,42.66 104.56,42.92 104.69,43.05 105.07,43.05 105.2,43.17 105.2,46.73 105.07,46.86 104.69,46.86 104.56,46.99 104.56,47.24 104.69,47.37 105.07,47.37 105.2,47.49 105.2,47.75 105.07,47.87 104.69,47.87 104.56,48 104.56,48.26 104.69,48.38 105.07,48.38 105.2,48.51 105.2,48.71 105.68,49.19 105.68,56.92 106.32,57.55 106.32,62.76 115.09,71.54 115.09,74.22 115.81,74.93 118.56,74.93 120.96,77.33 120.96,82.51 121.25,82.79 121.25,83.89 123.05,85.7 124.02,85.7 125.25,86.94 125.25,87.64 v2(125.63,88.02)
  BOTTOM w0.076: UC1.BN8 128.74,87.89 127.31,87.89 127.05,87.63 126.02,87.63 v2(125.63,88.02)
  BOTTOM w0.127: v2(106.51,33.42) 106.08,32.99 106.08,31.32 107.28,30.12 JDIMM2.20
DDR_M1_D8: length 73
  IN1 w0.076: 128.48,86.92 128.48,87.12 128.76,87.41 129.11,87.41 130.97,89.26 v2(130.97,89.29)
  IN1 w0.127: v2(108.62,32.79) 108.35,32.52 107.89,32.52 107.75,32.66 107.75,33.14 107.88,33.27 108.29,33.27 108.41,33.38 108.41,33.63 108.27,33.77 107.88,33.77 107.75,33.9 107.75,38.21 107.46,38.51 107.46,56.25 108.31,57.1 108.31,62.53 122.95,77.17 122.95,80.11 125.87,83.04 125.87,83.79 128.48,86.39 128.48,86.92
  BOTTOM w0.076: 130.54,89.72 v2(130.97,89.29)
  BOTTOM w0.089: UC1.BL12 130.54,89.72
  BOTTOM w0.127: v2(108.62,32.79) 108.28,32.44 JDIMM2.24
DDR_M1_D9: length 72.5
  IN1 w0.076: v2(130.21,89.36) 130.21,88.74 129.04,87.57 128.6,87.57 128.14,87.11 128.12,87.09
  IN1 w0.127: 128.12,87.09 127.99,86.96 127.99,86.44 125.49,83.95 125.49,83.27 122.52,80.29 122.52,77.28 107.93,62.69 107.93,57.33 107.08,56.48 107.08,38.28 107.32,38.03 107.32,31.46 107.43,31.35 107.79,31.35 107.9,31.45 107.9,31.58 108.06,31.74 108.35,31.74 v2(108.74,31.35)
  BOTTOM w0.076: v2(130.21,89.36) 130.54,89.03 UC1.BL11
  BOTTOM w0.127: v2(108.74,31.35) 109.28,30.82 JDIMM2.28
DDR_M1_D10: length 70.7
  IN1 w0.076: v2(130.19,87.77) 129.91,87.49 129.91,86.83 129.67,86.59 129.6,86.59
  IN1 w0.097: 129.6,86.58 129.6,86.59
  IN1 w0.127: v2(108.6,34.73) 108.33,34.73 108.19,34.87 108.19,37.59 108.69,38.09 108.69,38.35 108.58,38.47 108.58,39.55 108.3,39.83 108.3,40.21 108.58,40.49 108.58,41.34 108.43,41.49 108.04,41.49 107.89,41.63 107.89,43.61 108.1,43.82 108.44,43.82 108.58,43.95 108.58,47.32 108.5,47.4 108.25,47.4 108.1,47.55 108.1,47.76 108.24,47.9 108.5,47.9 108.58,47.98 108.58,48.74 108.27,49.05 108.27,49.77 108.14,49.89 107.96,49.89 107.84,50.02 107.84,50.81 108.23,51.21 108.59,51.21 108.69,51.31 108.69,51.8 108.55,51.95 108.41,51.95 108.32,52.04 108.32,52.27 107.89,52.7 107.89,56.07 108.69,56.87 108.69,62.37 123.37,77.05 123.37,79.92 126.81,83.37 126.81,83.98 129.41,86.58 129.6,86.58
  BOTTOM w0.076: v2(130.19,87.77) 130.21,87.72 UC1.BL8
  BOTTOM w0.127: JDIMM2.25 108.53,36.55 107.77,35.79 107.77,34.89 107.93,34.73 v2(108.6,34.73)
DDR_M1_D11: length 71.7
  IN1 w0.076: v2(131.88,87.4) 131.48,87.01 131.48,86.55 129.68,84.75 129.68,84.29 129.82,84.15 129.82,83.94
  IN1 w0.127: v2(111.84,32.79) 111.67,32.62 111.67,31.42 111.55,31.3 111.2,31.3 111.05,31.45 111.05,33.27 110.84,33.48 110.84,36.52 111.31,36.99 111.31,54.9 111.99,55.59 111.99,58.56 111.33,59.23 111.33,61.38 126.53,76.58 126.53,78.57 129.38,81.42 129.38,83.12 129.82,83.57 129.82,83.94
  BOTTOM w0.076: v2(131.88,87.4) 131.75,87.4 UC1.BJ8
  BOTTOM w0.127: JDIMM2.38 111.78,30.27 111.84,30.34 v2(111.84,32.79)
DDR_M1_D12: length 73.1
  IN1 w0.076: v2(131.88,88.7) 131.51,88.34 131.51,87.6 131.31,87.39 131.31,86.63 129.37,84.69 129.37,84.15
  IN1 w0.127: 129.37,84.15 129.37,83.65 129,83.28 129,81.65 128.7,81.35 128.52,81.35 128.33,81.54 128.15,81.54 127.97,81.36 127.97,81.18 128.16,80.99 128.16,80.81 126.15,78.8 126.15,78.26 126.02,78.13 125.68,78.13 125.55,78.01 125.55,77.75 125.68,77.63 126.02,77.63 126.15,77.5 126.15,76.74 110.88,61.47 110.88,58.57 111.01,58.44 111.45,58.44 111.59,58.3 111.59,58.01 111.48,57.9 111.02,57.9 110.88,57.75 110.88,57.44 111,57.32 111.5,57.32 111.61,57.2 111.61,56.96 111.46,56.81 111,56.81 110.88,56.68 110.88,56.43 111,56.3 111.5,56.3 111.61,56.18 111.61,55.95 111.46,55.79 111,55.79 110.88,55.66 110.88,37.1 110.42,36.64 v2(110.42,34.05)
  BOTTOM w0.076: v2(131.88,88.7) 131.75,88.7 UC1.BJ11
  BOTTOM w0.127: v2(110.42,34.05) 110.42,35.53 111.53,36.64 JDIMM2.37
DDR_M1_D13: length 72.3
  IN1 w0.076: v2(131.88,88.05) 132.23,87.7 132.23,86.56 131.31,85.64 131.31,84.02
  IN1 w0.127: 131.31,84.02 131.31,83.52 131.19,83.39 130.74,83.39 130.61,83.26 130.61,83.01 130.73,82.89 131.66,82.89 131.79,82.76 131.79,82.5 131.64,82.35 131.49,82.35 131.31,82.17 131.09,82.17 130.92,82.35 130.76,82.35 130.6,82.19 130.6,81.42 127.29,78.11 127.29,76.27 112.76,61.73 112.76,54.06 112.17,53.48 112.17,51.22 112.3,51.09 112.59,51.09 112.71,50.98 112.71,50.73 112.57,50.59 112.23,50.59 112.12,50.48 112.12,50.22 112.24,50.1 112.55,50.1 112.66,50 112.66,49.71 112.46,49.51 112.46,49.28 112.66,49.08 112.66,43.33 112.53,43.2 112.25,43.2 112.12,43.08 112.12,42.83 112.25,42.7 112.58,42.7 112.71,42.57 112.71,42.31 112.58,42.19 112.24,42.19 112.12,42.07 112.12,41.82 112.26,41.68 112.53,41.68 112.66,41.55 112.66,40.53 112.4,40.27 112.4,39.89 112.66,39.63 112.66,38.28 112.53,38.16 112.23,38.16 112.12,38.05 112.12,37.79 112.27,37.65 112.58,37.65 112.71,37.52 112.71,37.25 112.57,37.11 112.26,37.11 112.17,37.03 112.17,36.57 112.69,36.05 112.69,35.22 112.58,35.11 112.4,35.11 112.26,35.24 112.26,35.68 111.98,35.96 v2(111.84,35.96)
  BOTTOM w0.076: UC1.BJ10 131.75,88.05 v2(131.88,88.05)
  BOTTOM w0.127: JDIMM2.41 112.53,36.65 v2(111.84,35.96)
DDR_M1_D14: length 69.7
  IN1 w0.076: 128.46,85.02 130.27,86.83 v2(130.27,86.97)
  IN1 w0.127: v2(108.62,35.95) 108.62,37.39 109.07,37.84 109.07,38.58 108.96,38.69 108.96,41.76 108.83,41.89 108.45,41.89 108.32,42.01 108.32,42.27 108.45,42.39 108.93,42.39 109.07,42.53 109.07,42.77 108.95,42.9 108.45,42.9 108.32,43.03 108.32,43.28 108.45,43.41 108.83,43.41 108.96,43.54 108.96,49.08 108.83,49.21 108.77,49.21 108.65,49.34 108.65,49.59 108.77,49.72 108.94,49.72 109.07,49.86 109.07,50.14 108.95,50.26 108.59,50.26 108.46,50.39 108.46,50.63 108.6,50.77 108.95,50.77 109.07,50.9 109.07,52.13 108.48,52.73 108.48,52.9 108.6,53.03 108.82,53.03 108.96,53.17 108.96,53.43 108.83,53.56 108.53,53.56 108.4,53.68 108.4,53.94 108.53,54.07 108.95,54.07 109.07,54.19 109.07,54.44 108.94,54.57 108.53,54.57 108.4,54.7 108.4,54.95 108.53,55.08 108.95,55.08 109.07,55.21 109.07,55.46 108.95,55.59 108.53,55.59 108.4,55.72 108.4,55.97 108.53,56.1 108.83,56.1 109.07,56.34 109.07,62.21 123.75,76.89 123.75,79.69 127.2,83.14 127.2,83.75 128.46,85.02
  BOTTOM w0.076: UC1.BL7 130.53,86.7 v2(130.27,86.97)
  BOTTOM w0.127: JDIMM2.29 109.53,36.59 108.88,35.95 v2(108.62,35.95)
DDR_M1_D15: length 71.6
  IN1 w0.076: 130.43,83.82 130.43,85.04 131.88,86.49 v2(131.88,86.75)
  IN1 w0.127: v2(111.84,34.06) 111.84,34.02 111.56,33.73 111.34,33.73 111.22,33.85 111.22,34.73 111.42,34.93 111.42,35.55 111.22,35.75 111.22,36.36 111.43,36.57 111.7,36.57 111.74,36.61 111.74,40.85 112.04,41.15 112.04,41.36 111.74,41.66 111.74,53.58 112.12,53.96 112.12,54.25 112,54.37 111.81,54.37 111.7,54.48 111.7,54.75 111.88,54.94 112.23,54.94 112.38,55.08 112.38,59.16 112.26,59.28 111.83,59.28 111.71,59.41 111.71,59.66 111.83,59.79 112.25,59.79 112.38,59.92 112.38,60.19 112.27,60.3 111.83,60.3 111.71,60.42 111.71,60.67 111.84,60.8 112.25,60.8 112.38,60.93 112.38,61.05 112.17,61.26 112.17,61.68 126.91,76.42 126.91,78.34 130.22,81.65 130.22,83.41 130.43,83.62 130.43,83.82
  BOTTOM w0.076: UC1.BJ7 131.75,86.75 v2(131.88,86.75)
  BOTTOM w0.127: v2(111.84,34.06) 112.85,33.05 112.85,30.47 112.78,30.39 JDIMM2.42
DDR_M1_D16: length 70.7
  IN1 w0.076: 130.19,79.77 132.17,81.75 132.17,85.92 132.4,86.15 132.4,87.8 133.19,88.59 133.19,88.82 v2(133.71,89.34)
  IN1 w0.127: 130.19,79.77 130.19,78.62 113.14,61.57 113.14,53.9 112.67,53.44 112.67,51.82 113.09,51.4 113.09,36.7 113.07,36.69 113.07,31.76 113.19,31.65 v2(113.87,31.65)
  BOTTOM w0.076: v2(133.71,89.34) 133.56,89.34 UC1.BG11
  BOTTOM w0.127: v2(113.87,31.65) 114.34,31.18 114.34,30.63 113.78,30.07 JDIMM2.46
DDR_M1_D17: length 70.3
  IN1 w0.076: 130.65,79.77 132.35,81.47 132.35,85.82 132.93,86.4 132.94,86.4 133.15,86.61 133.15,88.14 v2(133.71,88.7)
  IN1 w0.127: 130.65,79.77 130.65,78.54 113.57,61.46 113.57,56.87 113.65,56.79 113.83,56.79 113.96,56.66 113.96,56.41 113.83,56.28 113.65,56.28 113.52,56.15 113.52,55.9 113.65,55.77 113.83,55.77 113.96,55.65 113.96,55.39 113.83,55.27 113.65,55.27 113.52,55.14 113.52,36.52 113.45,36.46 113.45,32.96 113.56,32.85 113.81,32.85 v2(113.87,32.92)
  BOTTOM w0.076: UC1.BG10 133.57,88.7 v2(133.71,88.7)
  BOTTOM w0.127: JDIMM2.50 114.78,32.01 v2(113.87,32.92)
DDR_M1_D18: length 68.8
  IN1 w0.076: 131.21,79.9 132.53,81.23 132.53,85.74 133.31,86.53 133.31,87.01 v2(133.71,87.4)
  IN1 w0.127: 131.21,79.9 131.21,78.56 113.95,61.31 113.95,58.49 114.08,58.36 114.32,58.36 114.44,58.24 114.44,57.99 114.3,57.85 114.08,57.85 113.95,57.73 113.95,57.47 114.08,57.35 114.29,57.35 114.39,57.25 114.39,54.81 113.95,54.37 113.95,46.75 114.08,46.62 114.17,46.62 114.3,46.49 114.3,46.24 114.17,46.11 114.08,46.11 113.95,45.98 113.95,45.73 114.08,45.6 114.17,45.6 114.3,45.48 114.3,45.22 114.17,45.1 114.08,45.1 113.95,44.97 113.95,44.71 114.08,44.59 114.17,44.59 114.3,44.46 114.3,44.21 114.17,44.08 114.08,44.08 113.95,43.95 113.95,43.7 114.08,43.57 114.17,43.57 114.3,43.44 114.3,43.19 114.17,43.06 114.08,43.06 113.95,42.94 113.95,42.68 114.08,42.56 114.17,42.56 114.3,42.43 114.3,42.17 114.17,42.05 114.08,42.05 113.95,41.92 113.95,41.67 114.08,41.54 114.17,41.54 114.3,41.41 114.3,41.16 114.17,41.03 114.08,41.03 113.95,40.9 113.95,40.65 114.08,40.52 114.17,40.52 114.3,40.4 114.3,40.14 114.17,40.02 114.08,40.02 113.95,39.89 113.95,39.63 114.08,39.51 114.17,39.51 114.3,39.38 114.3,39.13 114.17,39 114.08,39 113.95,38.87 113.95,38.62 114.08,38.49 114.17,38.49 114.3,38.36 114.3,38.11 114.17,37.98 114.08,37.98 113.95,37.86 113.95,37.6 114.08,37.48 114.17,37.48 114.3,37.35 114.3,37.09 114.17,36.97 114.08,36.97 113.95,36.84 113.95,36.62 114.3,36.27 114.3,35.52 114.17,35.4 113.93,35.4 v2(113.87,35.46)
  BOTTOM w0.076: v2(133.71,87.4) 133.57,87.4 UC1.BG8
  BOTTOM w0.127: v2(113.87,35.46) 114.53,36.11 JDIMM2.49
DDR_M1_D19: length 70.5
  IN1 w0.076: 133.13,79.96 133.58,80.41 133.58,85.21 134.98,86.6 134.98,87.02 134.61,87.39 v2(134.61,87.41)
  IN1 w0.127: 133.13,79.96 133.13,76.83 117.05,60.76 117.05,51.7 117.18,51.57 117.34,51.57 117.47,51.44 117.47,51.19 117.34,51.06 117.18,51.06 117.05,50.94 117.05,50.68 117.18,50.55 117.34,50.55 117.47,50.43 117.47,50.17 117.34,50.05 117.18,50.05 117.05,49.92 117.05,49.67 117.18,49.54 117.34,49.54 117.47,49.41 117.47,49.16 117.34,49.03 117.18,49.03 117.05,48.9 117.05,48.65 117.18,48.52 117.34,48.52 117.47,48.4 117.47,48.14 117.34,48.01 117.18,48.01 117.05,47.89 117.05,46.5 117.18,46.38 117.32,46.38 117.47,46.23 117.47,46.02 117.35,45.89 117.18,45.89 117.05,45.77 117.05,41.9 117.21,41.75 117.21,41.18 117.05,41.03 117.05,35.82 116.98,35.74 116.98,34.3 117.21,34.07 117.21,32.54 117.34,32.42 117.52,32.42 v2(117.82,32.72)
  BOTTOM w0.076: UC1.BF8 134.5,87.41 v2(134.61,87.41)
  BOTTOM w0.127: v2(117.82,32.72) 118.15,32.39 118.15,31.17 117.87,30.88 117.87,30.25 117.78,30.16 JDIMM2.62
DDR_M1_D20: length 71.7
  IN1 w0.076: v2(134.61,89.32) 135.14,88.78 135.14,87.32 135.31,87.15 135.31,86.47 134.89,86.05 134.89,85.88 134.57,85.57 134.57,77.69 134.34,77.47 134.1,77.47 133.94,77.3
  IN1 w0.127: 133.94,77.3 133.94,76.56 118.34,60.96 118.34,60.26 118.21,60.14 117.94,60.14 117.82,60.01 117.82,59.76 117.94,59.63 118.21,59.63 118.34,59.5 118.34,59.25 118.21,59.12 118.09,59.12 117.95,58.98 117.95,58.73 118.06,58.61 118.21,58.61 118.34,58.49 118.34,56.2 118.46,56.08 118.7,56.08 118.82,55.95 118.82,55.7 118.7,55.57 118.46,55.57 118.34,55.44 118.34,55.19 118.46,55.06 118.7,55.06 118.82,54.93 118.82,54.68 118.7,54.55 118.46,54.55 118.34,54.43 118.34,54.17 118.46,54.05 118.7,54.05 118.82,53.92 118.82,53.66 118.7,53.54 118.46,53.54 118.34,53.41 118.34,53.16 118.46,53.03 118.7,53.03 118.82,52.9 118.82,52.65 118.7,52.52 118.46,52.52 118.34,52.39 118.34,52.14 118.46,52.01 118.7,52.01 118.82,51.89 118.82,51.63 118.7,51.51 118.46,51.51 118.34,51.38 118.34,51.12 118.46,51 118.7,51 118.82,50.87 118.82,50.62 118.7,50.49 118.46,50.49 118.34,50.36 118.34,37.76 118.21,37.63 118.05,37.63 117.92,37.51 117.92,37.25 118.05,37.13 118.21,37.13 118.34,37 118.34,36.75 118.21,36.62 118.05,36.62 117.92,36.49 117.92,36.24 118.05,36.11 118.21,36.11 118.34,35.98 118.34,35.51 118.16,35.33 v2(117.94,35.33)
  BOTTOM w0.076: v2(134.61,89.32) 134.45,89.32 UC1.BF11
  BOTTOM w0.127: JDIMM2.59 117.03,35.52 117.28,35.27 117.87,35.27 v2(117.94,35.33)
