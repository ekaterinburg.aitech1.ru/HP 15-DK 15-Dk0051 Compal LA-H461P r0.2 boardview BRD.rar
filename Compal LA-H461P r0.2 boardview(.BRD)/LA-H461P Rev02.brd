# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35VSDGPU: length 220.6
  TOP w0.254: CG19.1 217.43,91.65 216.98,91.2 v2(216.98,91.12)
  TOP w0.4: v2(212.6,133.4) v2(213.2,133.4) ; v2(223,129) v2(223,129.8) v2(222.2,129.8) v2(221.4,129.8) ; v2(212.6,131.8) v2(213.2,131.8) ; v2(212.6,129.4) v2(213.2,129.4) v2(213.2,130.2) ; v2(213.2,130.2) UG4.M1 v2(214.2,129.8) ; v2(213.2,130.2) v2(212.6,130.2)
  TOP w0.406: v2(224.8,129.4) UG4.L14 v2(223.8,129) v2(223,129) ; v2(215,129) v2(215.8,129.8)
  IN1 w0.508: 242.14,65.42 242.14,63.95 244.2,61.89 v2(244.2,61.52)
  IN3 w0.4: v2(222.2,132.2) v2(222.2,133) v2(221.4,133)
  BOTTOM w0.127: v2(215,121) v2(215,121.8) ; v2(235.04,102.09) v2(235.84,102.09)
  BOTTOM w0.15: v2(235.04,94.89) v2(235.84,94.89)
  BOTTOM w0.152: v2(235.04,78.27) v2(235.84,78.27)
  BOTTOM w0.254: v2(216.6,122.6) 216.99,122.99 UG4.C5 ; v2(220.58,130.63) 220.94,131 UG4.N10 ; UG5.R5 v2(194.75,122.6) ; v2(222.2,129.8) 222.59,130.2 UG4.M12 222.6,130.2 v2(223,129.8)
  BOTTOM w0.305: v2(239.84,94.89) UG7.M3 239.44,94.49 ; UG7.L2 239.84,94.08 v2(239.84,94.09) ; UG7.L2 v2(240.64,94.09) UG7.K3 ; UG7.L2 v2(239.84,93.29) ; v2(240.23,104.48) 240.23,103.9 v2(240.24,103.89) UG7.L14 240.24,103.28 v2(239.85,102.88) UG7.M14 239.44,103.29 v2(239.44,103.89) v2(239.44,104.49) ; v2(244.64,94.09) 244.64,94.09 UG7.F3 244.24,94.49 v2(243.84,94.89) 243.44,95.29 UG7.G4 ; UG6.D14 237.84,68.48 v2(237.84,68.47) v2(237.84,67.87) ; UG4.M3 v2(215.8,129.8) UG4.L4 v2(216.6,129) ; v2(224.8,130.2) UG4.M14 ; v2(224.8,130.2) v2(225.4,130.2) ; v2(224.8,130.2) v2(224.8,129.4) 224.2,129.4 UG4.L14 223.8,129 v2(223.8,129) ; v2(195.55,123.4) 195.95,123.8 UG5.P3 ; UG6.M14 244.24,69.07 v2(243.84,69.47) 243.44,69.87 UG6.L13 243.44,69.87 v2(243.04,70.27) UG6.K12 ; v2(214.2,125.8) UG4.G1 213.79,126.2 v2(213.2,126.2) v2(212.6,126.2) ; v2(214.2,125.8) 214.59,126.2 UG4.G2 ; v2(214.2,125.8) UG4.F1 v2(213.2,125.4) v2(212.6,125.4) ; UG7.G11 v2(243.84,101.29) UG7.F12 v2(243.84,102.09) UG7.G13 ; UG4.G11 221.8,126.2 v2(222.2,125.8) UG4.F12 ; v2(236.64,76.67) 237.04,76.28 UG6.C5 ; v2(239.04,95.69) 238.64,96.09 UG7.N5 ; UG7.K12 241.04,101.69 v2(240.64,102.09) ; UG4.L11 v2(221.4,129.8) ; UG6.P14 v2(245.84,68.47) v2(245.84,67.87) ; v2(225.4,122.2) v2(224.8,122.2) 224.79,122.19 UG4.B14 ; UG5.K12 188.75,127 v2(188.35,126.6) UG5.L13 v2(188.35,125.8) ; v2(196.35,133) 195.95,133.39 UG5.B3 ; v2(239.84,77.47) 239.44,77.87 UG6.F3 v2(239.04,78.27) ; UG6.G2 v2(239.84,79.07) 239.44,79.47 UG6.F1 ; v2(239.44,68.47) 239.44,68.48 UG6.F14 ; UG6.E5 238.64,76.27 v2(239.04,76.67) ; v2(215.8,125.8) 216.19,126.2 UG4.G4 ; UG7.L13 v2(239.84,102.09) UG7.M12 ; UG4.G2 v2(215,125.8) UG4.F3 ; UG4.G2 v2(215,126.6) 215.39,127 UG4.H3 v2(215.8,127.4) ; UG7.L11 240.24,100.89 v2(239.84,101.29) ; v2(243.04,69.47) 243.44,69.07 UG6.L14 ; v2(223.8,125.8) 223.4,126.2 UG4.G13 v2(223.04,125.84) ; v2(198.75,123.8) v2(198.15,123.8) 198.15,123.8 UG5.P1 ; v2(198.15,125.4) 197.55,125.4 UG5.M1 197.15,125.8 v2(197.15,125.8) ; v2(196.35,132.2) 195.95,131.8 UG5.D3 ; UG7.L1 240.24,92.29 v2(240.24,92.29) v2(240.24,91.69) ; UG7.G13 v2(243.04,102.09) UG7.H12 ; UG7.G13 v2(243.04,102.89) UG7.G14 v2(243.44,103.89) ; v2(244.24,104.49) v2(244.24,103.89) UG7.F14 ; UG5.T14 186.55,122.19 v2(186.55,122.2) v2(185.95,122.2) ; v2(236.24,104.49) v2(236.24,103.89) 236.24,103.29 UG7.T14 ; v2(247.04,76.67) UG6.R5 v2(247.04,75.87) ; UG4.H12 222.6,126.99 v2(223,126.6) ; v2(225.4,125.39) 225.39,125.4 v2(224.8,125.4) 224.2,125.4 UG4.F14 ; v2(243.44,92.29) UG7.G1 v2(243.84,93.29) ; UG5.T3 195.95,122.19 v2(195.55,121.8) ; v2(213.2,130.2) UG4.M1 v2(214.2,129.8) UG4.L1 v2(213.2,129.4) ; UG7.D3 245.84,94.49 v2(246.24,94.09) ; v2(245.84,91.69) v2(245.84,92.29) 245.84,92.89 UG7.D1 ; UG4.R5 217.75,131.85 v2(217.79,131.85) ; v2(223,129.8) UG4.L13 223,129 v2(223,129) 222.6,128.6 UG4.K12 ; UG7.B1 v2(247.44,92.29) v2(247.44,91.69) ; UG6.G14 v2(240.24,68.48) v2(240.24,67.87) ; v2(246.24,79.07) UG6.P1 v2(245.84,80.07) ; UG6.G1 240.24,80.07 v2(240.24,80.07) ; v2(235.84,94.89) 236.04,94.69 236.24,94.49 UG7.T3 236.24,94.49 v2(236.64,94.09) ; UG5.D1 v2(198.15,131.8) v2(198.75,131.8) ; v2(215.8,128.2) UG4.K3 v2(215,129) UG4.L2 ; UG7.B3 v2(247.04,94.89) ; v2(246.24,100.49) UG7.D11 ; v2(246.24,101.29) UG7.D12 ; UG4.D14 224.79,123.8 v2(224.8,123.8) v2(225.4,123.8) ; v2(237.84,104.49) v2(237.84,103.89) UG7.P14 ; v2(239.44,91.69) v2(239.44,92.29) 239.44,92.29 UG7.M1 ; v2(185.95,123.8) v2(186.55,123.8) 186.55,123.8 UG5.P14 ; v2(190.76,133) UG5.C10 190.35,132.6 v2(189.95,132.2) UG5.D11 ; v2(225.4,126.2) v2(224.8,126.2) 224.79,126.2 UG4.G14 ; v2(242.24,94.89) 242.64,94.49 UG7.H3 242.64,94.49 v2(243.04,94.09) 243.44,93.69 UG7.G2 243.84,93.29 v2(243.84,93.29) ; v2(243.84,93.29) UG7.F1 ; UG5.L11 189.55,126.2 v2(189.15,125.8) ; v2(247.04,77.47) UG6.T3 ; UG5.F3 195.55,129.8 v2(195.55,129.8) 195.15,129.4 UG5.G4 ; UG7.D14 v2(245.84,103.89) v2(245.84,104.49) ; UG6.K3 v2(243.04,77.47) ; v2(240.64,77.47) UG6.G4 ; UG6.B3 236.24,77.88 v2(235.84,78.27) ; v2(185.95,125.4) v2(186.55,125.4) 186.55,125.4 UG5.M14 v2(187.55,125.8) UG5.L14 ; UG5.E10 v2(190.75,131.4) ; 222.2,123.4 UG4.D12
  BOTTOM w0.33: v2(194.75,125.8) 195.15,126.2 UG5.L4 v2(195.55,125.8) UG5.M3 196.35,125.79 v2(196.35,125.8) ; v2(195.55,128.2) 195.95,128.6 UG5.H3 ; v2(198.75,126.2) v2(198.15,126.2) 197.55,126.2 UG5.L1 197.55,126.2 v2(197.15,125.8) 196.75,126.2 UG5.L2 v2(196.35,126.6) 195.95,126.99 UG5.K3 ; UG5.F3 195.95,130.2 v2(196.35,129.8) ; v2(198.75,125.4) v2(198.15,125.4)
  BOTTOM w0.356: v2(243.84,71.87) 243.44,71.47 UG6.L11 v2(243.84,71.07) 244.24,70.67 UG6.M12 ; v2(239.84,70.27) 239.84,70.27 UG6.F12 ; v2(239.84,71.07) UG6.G11 ; v2(239.44,68.47) 239.44,68.47 v2(239.44,67.87)
  BOTTOM w0.381: UG4.T14 v2(224.8,133.4) v2(225.4,133.4) ; UG5.D14 186.55,131.8 v2(186.55,131.8) v2(185.95,131.8) ; v2(245.84,91.69) 245.84,91.45 245.7,91.3 CG105.1 CG104.1 247.44,90.67 v2(247.44,91.69) ; v2(187.55,130.6) UG5.F14 186.55,130.2 v2(186.55,130.2) ; v2(198.77,129.37) 198.74,129.4 v2(198.15,129.4) UG5.G1 ; v2(198.78,130.31) 198.7,130.39 v2(198.15,130.39) 197.74,130.39 UG5.F1 ; UG5.G11 v2(189.15,129.8) UG5.F12 188.75,130.2 v2(188.35,129.8) UG5.G13 v2(188.35,129) UG5.H12 ; v2(243.44,80.67) v2(243.44,80.07) ; v2(187.55,129) UG5.G14 186.55,129.4 v2(186.55,129.4) ; v2(196.35,129.8) UG5.G2 ; v2(246.24,96.49) 245.73,97 v2(245.73,97) ; CG79.1 185.21,126.2 v2(185.95,126.2) ; v2(217.4,130.6) UG4.N5 ; UG6.M3 v2(243.84,78.27) UG6.L2 ; v2(189.15,133) UG5.B12 ; v2(213.2,122.2) v2(212.6,122.2) ; v2(237.84,91.69) 237.95,91.58 CG186.1 CG95.1 236.17,91.62 v2(236.24,91.69) ; v2(244.24,80.66) v2(244.24,80.07) ; UG4.P14 v2(224.8,131.8) v2(225.4,131.8)
  BOTTOM w0.4: v2(219.63,88.19) UG1.B16 ; UG1.E13 v2(216.16,86.12) ; UG1.W30 205.22,99.55 v2(205.28,99.55) ; v2(206.91,101.94) 206.93,101.94 UG1.T33 ; v2(219.38,85.27) 219.38,85.29 UG1.B13 ; v2(213.2,129.4) v2(213.2,130.2) v2(212.6,130.2) v2(212.6,129.4) ; v2(247.44,103.89) v2(247.44,104.49) ; v2(185.95,126.2) v2(185.95,125.4) ; v2(247.44,80.67) v2(247.44,80.07) ; UG1.T30 v2(207.76,99.52) ; v2(219.38,91.12) 219.38,91.09 UG1.B19 ; v2(201.91,102.74) 201.93,102.74 202.08,102.59 UG1.AB33 ; UG1.W33 v2(204.83,102.94) ; UG1.E19 216.98,91.09 v2(216.98,91.12) ; v2(198.75,122.2) v2(198.15,122.2) 197.55,122.2 UG5.T1 ; UG1.AA30 v2(202.76,99.52) ; v2(245.84,80.67) v2(245.84,80.07) ; v2(216.16,88.62) UG1.E16
  BOTTOM w0.406: UG6.E10 238.64,72.27 v2(238.24,71.87) UG6.D11 v2(237.44,71.07) 237.84,70.68 UG6.D12 ; UG6.M1 v2(244.24,80.07) ; UG4.P12 v2(222.2,132.2) 221.8,131.8 UG4.P11 ; UG6.D1 237.84,80.07 v2(237.84,80.07) v2(237.84,80.67) ; UG4.R5 v2(217.4,133) ; v2(246.24,100.49) UG7.C10 v2(247.04,99.69) ; UG6.C10 237.04,72.27 v2(236.64,71.87) ; UG7.E5 245.04,96.09 v2(244.64,96.49) ; v2(222.2,133) UG4.T12 ; UG6.B1 236.24,80.07 v2(236.24,80.07) v2(236.24,80.67) ; v2(247.44,67.87) v2(247.44,68.47) UG6.T14 ; v2(188.35,123.4) 188.35,123.4 UG5.P12 v2(189.15,123.4) 189.55,123.8 UG5.P11 189.55,123.8 v2(189.95,124.2) 190.35,124.6 UG5.N10 ; v2(237.44,78.27) 237.84,77.88 UG6.D3 ; UG5.N5 194.35,124.6 v2(194.75,125) ; UG4.T1 v2(213.2,133.4) v2(212.6,133.4) ; v2(223,121.8) UG4.B12 ; v2(190.75,130.6) UG5.E10 ; v2(185.95,133.4) v2(186.55,133.4) UG5.B14 ; UG5.T12 188.75,122.19 v2(188.35,121.8) ; v2(215,123.4) 215.39,123.8 UG4.D3 ; v2(213.2,123.8) 213.2,123.8 UG4.D1 ; UG6.P3 v2(245.44,78.27) ; v2(216.6,125) UG4.E5 ; v2(236.24,92.29) 236.24,92.29 UG7.T1 ; v2(213.2,122.2) 213.2,122.19 UG4.B1 ; v2(243.44,68.47) v2(244.24,68.47) v2(244.24,67.87) ; v2(237.84,91.69) v2(237.84,92.29) 237.84,92.29 UG7.P1 ; UG6.T1 v2(247.44,80.07) ; v2(235.84,102.09) 236.24,101.69 UG7.T12 ; v2(215,121.8) 215.39,122.19 UG4.B3 215.4,122.19 v2(215.8,121.8) ; v2(247.04,101.29) UG7.B12 ; UG6.L1 v2(243.44,80.07) ; UG5.C5 194.35,132.6 v2(193.95,133) ; v2(237.44,102.09) 237.84,101.69 UG7.P12 v2(237.44,101.29) 237.44,101.29 UG7.P11 238.24,100.49 v2(238.24,100.49) 238.64,100.09 UG7.N10 ; UG6.N10 v2(244.61,72.7) ; v2(247.04,71.87) UG6.R10 v2(247.04,72.67) ; UG6.P11 245.84,71.47 v2(246.24,71.07) 245.84,70.67 UG6.P12 ; v2(243.04,76.67) UG6.L4 ; UG6.L4 v2(243.04,77.47) ; UG6.L4 v2(243.84,77.47) UG6.M3 ; v2(236.64,100.49) 237.04,100.09 UG7.R10 ; 222.2,123.4 v2(222.2,123.4) UG4.D11 v2(221.4,124.2) UG4.E10 ; UG4.C10 v2(221.4,122.6) ; UG5.R10 190.35,122.99 v2(189.95,122.6) ; v2(212.6,131.8) v2(213.2,131.8) UG4.P1 ; v2(240.24,80.67) v2(240.24,80.07) ; v2(245.47,99.66) UG7.E10 v2(244.64,99.69) ; v2(220.6,133) UG4.R10 221,132.6 v2(221.4,133) ; v2(198.15,133.37) 197.58,133.37 UG5.B1 ; UG4.P3 v2(215,132.2) ; v2(240.64,77.47) UG6.H3 ; UG6.B14 236.24,68.48 v2(236.24,68.47) ; UG5.D12 v2(189.15,132.2) ; v2(193.95,130.6) 194.35,131 UG5.E5 ; UG6.T12 247.44,70.67 v2(247.04,71.07) ; v2(240.64,70.27) UG6.H12 ; UG4.T3 v2(215.8,133) ; UG7.B14 v2(247.44,103.89) ; UG7.P3 238.24,94.09 v2(238.24,94.09)
  BOTTOM w0.508: v2(212.6,129.4) v2(213.2,129.4) ; v2(244.2,61.52) 244.2,61.32 RG45.2 ; v2(236.24,91.69) v2(236.24,92.29) ; RG50.1 230.06,128.67 v2(230.22,128.51)
  vias: v2(185.95,130.2) v2(186.55,126.2) v2(188.35,121) v2(193.3,131.4) v2(193.95,124.2) v2(194.75,124.2) v2(196.36,120.94) v2(197.15,124.2) v2(197.15,121.8) v2(198.75,127.78) v2(200.34,96.98) v2(201.06,97.01) v2(201.91,97.08) v2(202.76,97.08) v2(203.55,97.85) v2(203.59,97.06) v2(205.26,97.84) v2(205.25,97.08) v2(208.58,97.06) v2(209.41,97.07) v2(210.26,97.09) v2(211.03,97.01) v2(212.6,123.8) v2(212.82,96.55) v2(213.34,94.65) v2(213.53,94.11) v2(213.6,91.17) v2(213.6,89.27) v2(213.63,84.49) v2(213.69,92.69) v2(213.68,85.25) v2(213.66,82.67) v2(213.69,81.92) v2(214.49,92.77) v2(214.47,83.58) v2(216.6,124.2) v2(232.79,136.52) v2(235.04,70.27) v2(235.84,70.27) v2(236.64,95.69) v2(238.24,95.69) v2(238.24,76.67) v2(238.36,96.5) v2(238.46,75.81) v2(239.84,95.69) v2(240.99,67.85) v2(241.44,77.47) v2(242.24,77.47) v2(243.44,91.69) v2(243.53,104.55) v2(244.24,92.29) v2(244.24,91.69) v2(244.64,75.87) v2(245.44,71.87) v2(245.48,74.27) v2(246.24,95.69) v2(246.24,76.67) v2(246.24,75.87) v2(247.04,96.49) v2(248.64,76.67) v2(249.04,104.49) v2(249.43,65.76) v2(249.84,66.21) v2(249.84,65.35) v2(250.27,66.63) v2(250.25,65.79) v2(250.26,64.93) v2(250.68,66.21) v2(250.66,65.38) v2(250.67,64.52) v2(250.76,67.01) v2(251.1,65.8) v2(251.08,64.97) v2(251.08,64.11) v2(251.16,67.46) v2(251.17,66.6) v2(251.51,65.39) v2(251.49,64.55) v2(251.58,67.04) v2(251.58,66.19) v2(251.92,64.97) v2(251.9,64.14) v2(251.99,66.63) v2(252.04,65.76) v2(252.34,64.56) v2(252.45,66.21) v2(252.45,65.35) v3(245.71,87.62)
+2.5V: length 8.2
  BOTTOM w0.305: v2(171.76,49.64) 171.3,50.1 171.3,51.07 171.07,51.3 170.74,51.3 170.52,51.09 JDIMM1.259 ; JDIMM1.257 170.03,51.5 170.37,51.84 171.28,51.84 171.88,51.23 171.88,50.44 v2(172.22,50.1)
  vias: v2(111.98,26.41) v2(112.54,26.42) v2(113.1,26.42) v2(113.66,26.41) v2(170.68,37.36) v2(171.15,37.87) v2(174.07,39.2) v2(174.07,38.61) v2(174.07,38.03) v2(174.61,47.09) v2(174.6,46.53) v2(174.6,45.97) v2(174.6,45.41) v3(174.08,48.42)
+2.5VP: length 14.8
  TOP w0.127: PC2506.1 v1(113.81,16)
  TOP w0.254: v2(112.05,13.88) 112.67,13.88 113.01,14.22 113.01,15.23 PC2506.1 ; PC2504.1 104.46,14.69 104.46,13.74 104.74,13.46 105.15,13.46 105.62,13.93 105.62,13.96 PR2506.1 v2(106.02,13.31)
  BOTTOM w0.254: v2(112.05,13.88) 111.48,13.31 v2(106.02,13.31)
+3.3V_HDA: length 8.2
  TOP w0.254: RH117.1 208.47,15.25 208.47,17.45 207.57,18.35 RH163.2 206.85,18.69 v1(206.65,18.89) 206.46,19.09 CH64.1 206.96,20.09 v2(207.22,20.34)
  BOTTOM w0.254: v2(207.22,20.34) 208.08,20.34 UH1.BB14
+3V_1.8V_PGPPA: length 30.3
  TOP w0.254: 197.12,10.09 195.92,11.3 RH67.2
  TOP w0.381: 194.39,9.62 195.01,9.62 RH255.2 195.01,8.61 195.32,8.3 195.91,8.3 196.37,8.76 196.37,9.34 198.47,11.45 198.47,12.22 198.09,12.6 RH155.2 197.57,12.72 197.57,14.83 197.16,15.24 RH143.2 196.93,15.42 197.71,16.2 v1(197.71,16.48) 197.71,17 197.2,17.5 197.2,18.64 198.04,19.48 RH181.2 198.07,19.86 198.18,19.96 RH169.2 198.11,20.43 197.57,20.98 197.57,21.77 197.07,22.26 197.07,23.28 197.31,23.52 RH44.2 197.77,23.97 198.59,24.79 v2(198.73,24.79) 199.19,25.25 RH150.1 ; 194.39,9.62 RH64.1 ; 194.39,9.62 194.27,9.51 RH257.2
  BOTTOM w0.254: UH1.AN32 198.82,24.7 v2(198.73,24.79)
+3V_1.8V_PGPPD: length 2.8
  TOP w0.381: v2(204,24.11) 204.2,23.9 RH141.2 204.75,24.03 RH148.1
  BOTTOM w0.305: UH1.AN24 203.31,24.8 203.52,24.59 v2(204,24.11)
+3V_1.8V_PGPPEF: length 12.4
  TOP w0.508: CH33.1 197.7,27.33 v2(197.7,27.77) ; CH33.1 RH147.1 195.41,27.07 194.9,27.59 194.9,28.01 193.99,28.92 v1(192.3,28.92) 191.61,28.92 191.17,29.36 RH140.2 190.2,29.33 RH191.2 ; CH33.1 196.94,27.58 v2(196.94,27.8)
  BOTTOM w0.254: UH1.AE36 v2(196.94,27.8) ; v2(197.7,27.77) UH1.AE35
+3V_1.8V_PGPPHK: length 15.5
  TOP w0.508: RH139.2 v1(190.23,33.16) 190.23,32.71 v2(190.5,32.43) 191.57,32.43 CH32.1 192.51,31.49 RH146.1 195.76,31.49 v2(196.94,30.31)
  BOTTOM w0.254: UH1.AC36 v2(196.94,30.31) 197.06,30.31 UH1.AC35
  BOTTOM w0.356: RH99.2 187.36,32.31 186.96,32.71 RH203.2 RH202.2
  BOTTOM w0.508: RH99.2 RH100.1 190.38,32.31 v2(190.5,32.43)
+3V_GSEN: length 20.8
  TOP w0.254: U9.10 v1(177.71,48.61) 177.71,48.73 C5246.2 ; C5247.2 178.92,48.96 178.21,48.25 U9.9
  TOP w0.381: C5246.2 177.87,49.3 v2(177.1,50.06) ; v2(179.22,42.77) 179.04,42.96 R5801.1 178.18,43.53 R5798.2
  TOP w0.508: D511.1 181.39,48.74 180.78,49.35 R5247.2 C5245.2 179.63,49.3 C5247.2 C5246.2
  IN2 w0.381: v2(177.1,50.06) 176.98,49.94 176.98,43.8 178.01,42.77 v2(179.22,42.77)
+3V_IRCAM: length 0.7
  TOP w0.127: v2(62.19,31.48) v3(62.19,30.79)
  vias: v2(61.88,31.95) v2(62.1,32.63) v2(62.42,32.09)
+3V_LDO3V3: length 6.9
  TOP w0.203: UU4.9 42.95,42.86 42.71,43.09
  TOP w0.254: RU65.1 39.58,44.74 39.58,44.12 39.84,43.86 41.95,43.86 42.71,43.09
  TOP w0.508: RU65.1 38.64,45.05 QT2.3
+3V_LID: length 725.6
  TOP w0.254: v2(102.14,14.24) 102.14,15.14 98.36,18.91 98.36,25.5 99.51,26.65 103.9,26.65 104.68,25.87 105.65,25.87 107.58,23.94 108.74,23.94 108.88,24.08 U4019.8 108.88,25.36 108.12,26.12 R13.2 R125.2 108.12,27.4 RK33.1
  TOP w0.381: U7.2 208.49,136.37 C395.1 206.11,135.86 205.95,135.7 D508.1 205.95,134.64 v2(205.19,133.88) 203.92,132.61 203.92,130.41 204.38,129.94 R5242.1
  TOP w0.508: RH92.2 176.84,16.94 176.84,24.42 173.93,27.33 v2(171.2,27.33) ; R5243.1 11.62,121.07 v2(11.5,121.07) ; PR18.1 273.11,18.44 v2(272.81,18.14) ; PR21.2 281.83,13.49 v2(281.52,13.17) ; v2(191.07,8.2) 190.28,7.41 186.47,7.41 184.44,9.44 177.47,9.44 174.87,12.04 173.52,12.04 172.78,12.78 172.63,12.78 165.02,20.38 165.02,21.22 163.83,22.42 v1(163.83,23.33) 163.74,23.41 163.74,26.36 163.32,26.77 162.92,26.77 v2(162.72,26.58)
  IN1 w0.381: v2(183.25,136.09) 183.72,135.62 183.72,135.18 182.63,134.09 182.63,132.69 180.45,130.51 180.45,128.14 181.36,127.23 181.36,124.05 177.86,120.55 173.51,120.55 168.86,115.9 168.86,111.25 169.52,110.59 171.8,110.59 174.73,107.67 174.73,107.38 175.95,106.15 175.95,104.17 177.38,102.74 177.38,100.21 177.38,100.21 177.38,94.59 185.54,86.43 186.16,86.43 189.02,83.56 189.02,81.37 189.43,80.96 189.43,78.87 189.18,78.61 v2(188.79,78.61)
  IN1 w0.508: v2(191.07,8.2) 193.93,5.35 223.51,5.35 226.35,8.2 226.35,8.54 228.39,10.58 230.88,10.58 232.05,9.41 232.05,8.73 234.7,6.08 240.05,6.08 240.61,6.64 243.06,6.64 244.18,5.52 v2(245.9,5.52)
  IN2 w0.381: v2(276.19,39.19) 276.19,39.4 275.87,39.72 272.68,39.72 272.51,39.55 257.8,39.55 256.87,40.49 255.35,40.49 253.49,42.34 249.9,42.34 249.02,43.22 245.54,43.22 243.59,41.27 240.47,41.27 240.12,40.91 238.74,40.91 238.36,41.29 238.36,42.7 237.87,43.19 221.93,43.19 215.75,49.37 194.43,49.37 189.93,53.87 189.93,68.61 188.91,69.63 188.91,70.95 189.24,71.28 189.24,72.67 188.74,73.16 188.74,78.56 v2(188.79,78.61)
  IN2 w0.508: v2(11.5,121.07) 11.59,120.97 13.95,120.97 14.79,120.12 16.71,120.12 17.79,119.04 17.79,117.37 18.47,116.69 18.47,114.6 18.84,114.23 18.84,99.96 19.13,99.67 19.13,86.76 20.53,85.37 20.53,76.6 21.61,75.52 21.61,73.73 22.42,72.92 22.42,66.68 21.89,66.15 v2(21.89,65.41) ; v2(102.14,14.24) 101.78,14.24 99.04,16.98 76.11,16.98 74.91,18.18 66.24,18.18 61.32,23.11 61.32,23.69 60.79,24.21 58.58,24.21 53.93,28.85 53.93,35.33 52.77,36.49 52.77,37.27 v2(51.34,38.7) ; v2(245.9,5.52) 246.59,6.21 248.86,6.21 249.5,5.57 275.43,5.57 281.52,11.66 v2(281.52,13.17)
  IN3 w0.254: 48.92,40.57 48.92,40.17 48.6,39.85 44.82,39.85 43.61,41.07 43.61,41.5 48.54,41.5 48.92,41.12 48.92,40.57
  IN3 w0.508: 43.61,41.5 43.61,42.3 41.44,44.47 41.44,46.66 40.96,47.14 39,47.14 36.78,49.35 36.78,51.37 35.31,52.84 33.73,52.84 32.86,53.71 31.44,53.71 30.41,54.74 28.43,54.74 26.76,56.41 24,56.41 22.7,57.72 22.7,61.68 21.27,63.11 21.27,64.79 v2(21.89,65.41) ; v2(281.52,13.17) 278.96,13.17 273.99,18.14 v2(272.81,18.14) ; v2(51.34,38.7) 51.34,39.15 49.91,40.57 48.92,40.57 48.92,40.57 ; v2(171.2,27.33) 170.72,26.84 167,26.84 166.43,27.41 163.56,27.41 v2(162.72,26.58) 162.21,27.09 161.05,27.09 160.79,26.83 150.25,26.83 148.98,25.57 140.91,25.57 139.31,27.17 136.98,27.17 131.94,22.13 131.94,20.51 132.95,19.51 132.95,18.87 134.55,17.27 134.55,16.5 134.15,16.1 133.42,16.1 132.31,14.99 129.06,14.99 127.53,16.52 124.72,16.52 124.32,16.12 122.53,16.12 121.94,16.71 115.93,16.71 115.71,16.5 111.56,16.5 110.99,15.93 104.48,15.93 103.56,15.01 102.79,15.01 102.14,14.35 v2(102.14,14.24)
  BOTTOM w0.381: v2(272.81,18.14) 274.83,20.16 274.83,23.3 277.06,25.53 277.06,28.82 276.55,29.33 276.55,38.83 v2(276.19,39.19) ; v2(183.25,136.09) 183.61,136.44 196.92,136.44 200.21,133.16 203,133.16 203.73,133.88 v2(205.19,133.88)
+3V_PCH_PRIM: length 344.3
  TOP w0.254: v2(207.4,16.43) 207.01,16.43 205.69,17.75 RH179.1 ; QC7.2 205.05,9.31 205.24,9.5 RH226.2 205.81,9.5 206.3,9 206.3,8.79 RH231.2 207.71,9.12 QC10.5 208.64,9.12 ; 208.64,9.12 208.64,8.33 208.87,8.1 RH230.2 ; 208.64,9.12 QC10.2
  TOP w0.381: R5219.2 22.16,5.72 v2(21.4,5.72) ; v2(172.95,18.67) 172.6,19.02 172.6,22.4 173.28,23.09 v2(173.28,24.18) ; RH222.2 201.63,13.99 v2(202.14,13.49) 202.39,13.74 RH223.2 ; v2(126.97,10.2) 126.37,10.79 v2(126.37,14.11)
  TOP w0.508: RH140.1 189.01,29.36 188.24,30.12 188.24,31.85 187.3,32.79 ; v2(196.78,13.74) 196.78,14.17 RH143.1 ; RH91.1 203.15,34.3 v2(203.39,34.53) ; 187.3,32.79 188.7,34.19 RH139.1 ; 187.3,32.79 186.24,32.79 184.71,31.26 RH215.2 ; RH231.2 206.84,7.56 206.45,7.17 205.74,7.17 205.34,7.58 205.34,7.59 205.04,7.9 204.54,7.9 203.13,9.31 QC7.5 202.38,9.31 202.14,9.55 202.14,10.22 202.72,10.8 RH227.2 202.72,12.9 v2(202.14,13.49) 201.5,12.85 199.28,12.85 198.86,13.27 v2(198.86,13.68) ; RH218.2 RH219.2 RH221.2 ; RH213.1 RH178.1 RH34.1 RH33.1 RH37.1 RH38.1 214.2,25.68 213.36,26.52 C5278.2 211.53,27.32 RH36.1 210.01,26.69 RH35.1 209.25,25.93 206.84,25.93 206.2,25.3 ; RH217.2 RH216.2
  IN1 w0.254: v2(216.46,8) 214.81,9.65 209.68,9.65 208.82,10.51 207.59,10.51 206.77,11.34 206.77,11.69 204.26,14.2 202.85,14.2 v2(202.14,13.49)
  IN1 w0.381: v2(209.73,14.84) 208.98,14.84 v2(207.4,16.43)
  IN1 w0.508: v2(203.39,34.53) 203.39,33.78 204.35,32.81 205.61,32.81 207.53,30.89 207.53,28.92 205.89,27.27 205.89,25.47 v2(205.24,24.83)
  IN2 w0.381: v2(172.95,18.67) 172.88,18.74 169.45,18.74 167.99,17.27 154.16,17.27 152.9,16.01 151.03,16.01 149.9,14.87 144.22,14.87 142.92,13.57 135.51,13.57 134.41,14.67 133.61,14.67 133.24,15.05 132.07,15.05 131.7,14.67 126.93,14.67 v2(126.37,14.11) ; v2(126.97,10.2) 126.97,9.46 125.58,8.07 91.1,8.07 89.12,10.04 75.73,10.04 72.42,13.35 66.64,13.35 66.25,12.96 62.72,12.96 59.41,9.65 46.07,9.65 41.97,5.55 21.57,5.55 v2(21.4,5.72)
  IN3 w0.254: v2(269.28,21.37) 269.23,21.32 269.23,18.4 268.88,18.05 264.17,18.05 263.35,17.22 258.18,17.22 257.83,17.58 237.8,17.58 237.35,17.12 235.41,17.12 234.6,16.31 226.36,16.31 223.81,13.77 223.81,13.31 221.82,11.32 221.14,11.32 219.44,9.62 219.44,9.09 218.1,7.74 216.72,7.74 v2(216.46,8)
  BOTTOM w0.254: v2(193.59,24.22) 193.2,23.83 UH1.AT44 ; PR1801.1 267.7,23.4 269.28,21.82 v2(269.28,21.37) ; UH1.AN21 205.22,24.8 v2(205.24,24.83)
  BOTTOM w0.305: v2(202.14,13.49) RH224.2 RH225.2 202.91,14.21 RH95.1 RH97.1 RH194.1 ; v2(196.78,13.74) 196.7,13.74 196.55,13.89 196.55,14.25
  BOTTOM w0.356: v2(201.38,24.78) 201.9,24.78 UH1.AN26 ; RH63.1 198.66,13.89 v2(198.86,13.68) ; v2(201.38,24.19) 201.77,24.19 UH1.AP26
  BOTTOM w0.381: v2(179.24,30.12) 178.24,30.12 173.28,25.17 v2(173.28,24.18)
  vias: v2(183.3,25.96) v2(183.73,26.4) v2(184.13,26.8) v2(209.73,15.43) v2(216.48,19.56) v2(217.01,19.39) v3(182.05,27.85)
+3V_PHVC: length 2.7
  TOP w0.33: v2(209.87,21.13) 209.94,21.07 v1(209.94,20.63) 209.94,20.04 RH90.2
  BOTTOM w0.305: UH1.AW9 209.94,21.13 v2(209.87,21.13)
+3V_PHVLDO: length 1.7
  BOTTOM w0.305: v2(211.51,21.4) 211.23,21.4 UH1.AY8 v2(211.03,20.73) 211.03,20.16 UH1.BB7
  vias: v1(210.24,18.79)
+3V_SMBUS: length 70.9
  TOP w0.381: v2(115.36,17.12) 114.93,17.55 114.93,18.83 116.31,20.21 116.31,24.67 v1(117.1,25.45) 117.25,25.61 v2(117.25,26.89) 116.36,26.89 116.26,26.79 114.4,26.79 113.95,27.24 111.89,27.24 111.35,26.71 111.35,26.12 111.71,25.76 D517.1 ; RH233.2 144.24,26.49 v2(144.55,26.18) 144.79,26.42 RH232.2 ; D510.1 D514.1 128.3,7.03 v2(128.44,6.9)
  BOTTOM w0.381: v2(117.25,26.89) 117.25,26.88 118.68,25.45 121.49,25.45 122.19,26.16 123.67,26.16 123.89,26.37 131.4,26.37 132.18,25.6 143.98,25.6 v2(144.55,26.18) ; v2(115.36,17.12) 115.95,16.53 115.95,14.25 120,10.19 124.61,10.19 125.94,8.87 127.39,8.87 128.3,7.96 128.3,7.03 v2(128.44,6.9)
+3V_SPI: length 60.2
  TOP w0.508: RH98.2 RH138.2 v2(183.75,24.79) ; v2(183.97,32.47) 185.48,33.98 185.48,36.9 188.18,39.6 v2(188.18,43.12) v3(188.18,44.18) v2(185.16,47.2)
  IN2 w0.381: v2(183.75,24.79) 184.22,24.31 187.38,24.31 187.94,24.88 188.94,24.88 189.84,25.77 190.35,25.77 191.81,24.3 v2(193.01,24.3)
  BOTTOM w0.254: v2(193.01,24.3) 193.01,24.68 UH1.AN44
  BOTTOM w0.508: 182.12,54.06 182.33,53.86 CH2.1 183.18,53.36 183.35,53.54 UH2.8 ; 182.12,54.06 182.56,54.5 185.16,54.5 185.49,54.17 185.49,47.53 v2(185.16,47.2) ; 182.12,54.06 180.43,54.06 179.92,53.56 179.92,52.99 180.44,52.47 RH4.2 ; RH3.2 188.37,43.31 v2(188.18,43.12) ; RH175.1 183.75,24.34 v2(183.75,24.79) 183.07,24.79 182.52,25.33 182.52,27.3 183.97,28.75 v2(183.97,32.47)
+3V_TBTC_PDLDO: length 99.1
  TOP w0.381: RU51.1 53.65,42.97 54.19,42.43 54.84,42.43 56.29,43.89 56.29,46.92 v2(56.27,46.94)
  TOP w0.508: RU66.1 40.7,45.4 40.14,45.97 RU65.2 39.89,47.11 CU71.1 38.9,47.19 38.71,47 QT2.1 37.53,44.36 36.28,43.1 RU67.1 36.01,42.95 35.32,42.26 35.32,41.06 35.51,40.87 35.51,38.53 36.28,37.77 v2(36.44,37.77) ; v2(57.32,30.27) 57.56,30.27 v3(58.05,30.75) v2(58.64,31.34)
  IN3 w0.381: v2(58.64,31.34) 59.07,30.91 60.09,30.91 60.34,30.65 63.92,30.65 64.3,31.03 64.3,32.17 63.48,32.99 63.48,39.7 64.86,41.08 64.86,43.96 63.2,45.62 56.87,45.62 56.27,46.22 v2(56.27,46.94)
  BOTTOM w0.508: 54.13,29.95 RU68.1 RU69.1 RU70.1 ; 54.13,29.95 53.58,30.5 53.58,34.62 52.37,35.83 52.37,36.87 51.71,37.53 47.34,37.53 46.44,36.62 46.44,36.32 45.93,35.81 45.38,35.81 44.49,34.92 42.35,34.92 41.43,35.84 40.38,35.84 39.3,36.92 37.29,36.92 36.44,37.76 v2(36.44,37.77) ; 54.13,29.95 57,29.95 v2(57.32,30.27) ; UU5.8 61.56,24.6 61.14,24.18 61.14,23.53 CU72.1 60.74,23.31 60.4,23.64 60.4,24.43 60.84,24.86 60.84,25.87 59.63,27.08 59.63,28.5 59.06,29.07 59.06,29.33 RU71.1 58.83,30.6 58.64,30.8 v2(58.64,31.34)
+3V_USB2: length 1.5
  TOP w0.508: v2(202.89,31.81) 203.03,31.95 203.03,32.51 RH91.2
  BOTTOM w0.254: UH1.V23 v2(202.89,31.81)
+3VALW: length 419.4
  TOP w0.381: v2(191.99,8.22) 191.87,8.22 191.28,8.82 190.15,8.82 187.53,11.43 v2(186.85,11.43) ; RC81.2 203.21,7.24 RC82.2 203.67,7.88 v2(203.45,8.11)
  TOP w0.457: RK12.2 139.72,26.5 RK13.2 139.36,26.5 v2(139.03,26.18)
  TOP w0.508: v2(90.18,11.04) 90.18,10.81 89.59,10.23 C388.1 88.93,10.23 88.67,10.49 DM5.5 ; v2(40.45,48.7) 41.24,47.92 RU53.2 ; v2(186.85,11.43) 186.85,11.71 186.39,12.16 RH162.1 ; PR2504.1 103.61,16.57 103.56,16.62 102.96,16.62 101.75,17.84 101.75,19.17 102.69,20.11 103.53,20.11 103.54,20.1 ; v2(11.75,124.1) 11.34,123.7 D1.2 8.34,123.06 v2(8.76,122.64)
  TOP w0.762: 57.93,16.99 57.94,17.01 57.94,18.69 58.6,19.35 59.28,19.35 61.09,21.17 61.09,24.33 64.48,27.71 64.48,29.07 64.07,29.48 62.85,29.48 61.77,28.4 57.27,28.4 v2(55.05,30.62) 54.17,31.5 54.17,38.07 54.23,38.13 54.23,39.04
  TOP w1.016: 183.96,40.52 183.96,35.6 182.06,33.7 182.06,33.21
  IN1 w0.381: v2(270.57,48.28) 264.44,48.28 263.54,49.18 263.54,54.01 261.09,56.46 243.69,56.46 242.77,55.54 v2(232.88,55.54)
  IN1 w0.508: v2(186.85,11.43) 189.76,11.43 192.04,13.71 v2(193.96,13.71)
  IN2 w0.508: 48.6,44.52 49.01,44.1 50.24,44.1 51.68,42.67 v2(51.68,42.5) ; 43.98,45.34 43.34,44.69 42.36,44.69 41.78,45.28 41.78,47.77 40.85,48.7 v2(40.45,48.7) 40.45,48.44 39.69,47.67 38.96,47.67 36.39,50.25 36.39,51.32 34.76,52.94 33.57,52.94 33.31,53.21 32.69,53.21 31.92,53.98 31.19,53.98 30.69,53.47 28.26,53.47 27.82,53.92 27.82,54.98 27.5,55.3 27.5,57.63 27.15,57.98 23.34,57.98 22.58,58.74 22.58,61.72 19.85,64.46 19.85,64.91 19.34,65.42 19.34,66.01 19.86,66.52 19.86,70.23 20.1,70.46 20.1,72.19 18.15,74.14 18.15,75.43 17.44,76.14 17.44,82.91 17.22,83.13 17.22,83.82 17.2,83.84 17.2,84.35 17.21,84.36 17.21,84.41 17.83,85.03 17.83,99.17 v2(17.35,99.64)
  IN2 w1.016: 185.55,43.34 190.52,48.32 190.52,48.94 188.04,51.41 182,51.41 180.94,52.47 180.05,52.47 178.14,54.38 178.14,59.1 178.9,59.87 182.35,59.87 184.33,61.85 184.33,65.66 181.97,68.02 181.97,77.52 179.89,79.6 179.89,86.26 174.15,92 174.15,101.14 172.5,102.79
  IN3 w0.254: v2(241.8,21.95) 241.26,22.49 241.26,23.14 241.87,23.74 241.87,26.28 242.02,26.44 242.82,26.44 243.12,26.74 243.12,27.57 243.45,27.9 245.64,27.9 247.57,29.83 247.57,32.77 249.41,34.62 251.64,34.62 252.74,33.52 252.74,32.94 253.14,32.54 253.63,32.54 v2(253.96,32.86)
  IN3 w0.381: v2(133.18,14.21) 133.45,14.21 133.8,14.57 134.56,14.57 135.41,15.41 135.41,17.76 134.66,18.51 134.66,23.34 136.45,25.13 138.37,25.13 139.03,25.79 v2(139.03,26.18)
  IN3 w0.508: v2(92.6,21.91) 92.6,22.22 95.31,24.93 96.72,24.93 96.88,25.09 97.72,25.09 98.19,24.62 98.19,23.81 101.41,20.6 v2(104.32,20.6) ; v2(8.76,122.64) 9.02,122.37 10.41,122.37 10.96,121.82 12.88,121.82 15.21,119.49 15.21,117.38 15.98,116.62 15.98,107.27 17.35,105.89 v2(17.35,99.64)
  BOTTOM w0.254: v2(253.96,32.86) 253.96,33.17 253.55,33.58 PR303.1 ; PR1004.1 241.25,21.95 v2(241.8,21.95)
  BOTTOM w0.305: JPWR1.5 v2(11.75,124.1) ; v2(193.96,13.71) 193.97,13.72 193.97,14.15 RH12.1
  BOTTOM w0.381: v2(232.88,55.54) 232.65,55.31 PRV29.1 ; v2(191.99,8.22) 192.16,8.05 198.25,8.05 198.73,8.53 203.03,8.53 v2(203.45,8.11) ; v2(270.57,48.28) 270.57,46.99 272.35,45.2 272.35,40.47 271.58,39.7 269.91,39.7
  BOTTOM w0.457: PRH9.1 v2(179.86,101.19)
  BOTTOM w0.508: v2(84.57,13.07) 84.99,13.07 85.2,13.28 JTP1.8 ; RR1.1 46.31,20.47 v2(46.92,20.47) ; v2(57.19,15.44) 57.63,15.44 59.24,13.84 CL28.1 60.13,12.85 UL2.5 ; PRM8.1 v2(92.6,21.91) ; v2(55.05,30.62) 55.05,33.14 54.22,33.97 54.22,34.89 53.01,36.09 53.01,41.16 51.68,42.5 v2(51.68,42.5)
  vias: v2(56.57,15.44) v2(57.51,16.14) v2(97.41,13.55) v2(97.71,13.04) v2(97.97,13.59) v2(98.29,13.12) v2(104.96,20.6) v2(105.53,20.6) v2(106.09,20.6) v2(118.51,20.7) v2(119.07,20.71) v2(172.24,104.51) v2(172.24,103.94) v2(173.92,24.81) v2(174.25,14.25) v2(174.37,23.54) v2(174.76,23.94) v2(174.86,14.86) v2(174.91,14.27) v2(179.56,32.66) v2(181.04,32.81) v2(181.04,32.26) v2(181.4,106.79) v2(181.9,105.46) v2(183.12,43.22) v2(184.04,42.39) v2(236.46,25.54) v2(236.48,24.99) v2(244.19,21.7) v2(244.19,21.12) v2(244.77,21.7) v2(244.77,21.12) v2(245.36,21.7) v2(245.36,21.12) v2(245.94,21.7) v2(245.94,21.12) v2(246.52,21.7) v2(246.52,21.12) v2(247.11,21.7) v2(247.11,21.12) v2(267.49,41.25) v2(268.02,40.7) v2(268.05,41.26) v2(268.42,41.68) v2(268.6,41.14) v2(268.57,40.58) v2(268.99,41.69) v2(269.13,40.56) v2(269.16,41.13) v2(269.55,41.68) v2(269.73,41.16) v2(269.71,40.57) v2(270.42,20.69) v2(270.42,20.14) v2(270.42,19.58) v2(270.42,19.02) v2(271,20.69) v2(271,20.14) v2(271,19.58) v2(271,19.02) v2(303.97,7.92) v2(304.07,8.51) v2(304.45,10.56) v2(304.5,8.1) v2(305.14,8.91) v2(305.08,8.35) v2(305.06,7.67) v3(174.4,18.74) v3(174.41,16.08) v3(174.45,21.85)
+3VALW_DSW: length 13.9
  TOP w0.508: RH211.1 188.19,11.96 RH171.2 187.81,11.94 187.24,12.51 v1(187.24,12.93) 187.24,14.06 RH162.2 187.3,14.7 RH47.2 ; RH211.1 189.03,10.97 189.59,10.41 RH45.2 ; RH211.1 RH41.2 189.03,13.49 v2(188.8,13.71)
  BOTTOM w0.508: v2(188.8,13.71) CH34.1 188.8,15.14 189.32,15.65 189.32,17.43 189.44,17.55
+3VALW_EC: length 362.9
  TOP w0.254: UK1.9 140.44,7.21 139.86,6.63 CK2.1 ; UK1.22 145.64,7.32 144.84,6.52 v2(144.84,5) ; RK7.2 152.48,10.08 152.22,9.82 UK1.33 ; CK8.1 134.24,11.42 UK1.124 ; UK1.96 136.72,23.85 v2(136.68,23.89)
  TOP w0.381: v2(150.52,26.18) 150.81,26.47 LK1.1 152.39,26.47 152.48,26.55 RK2.2 ; v2(150,5.1) 150.18,5.28 150.18,6.11 149.94,6.35 CK1.1 ; v2(165.99,26.46) 168.07,24.38 168.07,19.8 172.81,15.06 v2(173.33,15.06) ; RK21.1 131.74,19.74 131.66,19.81 130.97,19.81 ; RG200.2 219.98,63.08 220.98,62.07 220.98,61.37 222.62,59.74 224.42,59.74 224.96,60.28 231.33,60.28 231.85,59.76 232.28,59.34 232.28,58.39 232.53,58.13 233.11,58.13 233.48,57.76 233.48,54.94 232.97,54.42 232.97,50.9 233.77,50.1 233.77,49.15 234.61,48.31 234.61,47.27 235.03,46.85 235.03,45.49 236.73,43.79 v3(238.22,43.79) 239.9,43.79 240.5,43.2 247.51,43.2 248.48,44.16 248.48,44.79 249.04,45.35 253.2,45.35 254.44,44.12 255.62,44.12 256.13,43.61 258.36,43.61 258.77,43.2 260.54,43.2 264.37,47.04 273.08,47.04 277.49,42.63 v2(277.49,42.16) ; v2(140.72,5) 140.72,5.81 140.2,6.34 CK2.1
  TOP w0.508: RK1.2 129,12.63 v2(129.94,13.57) ; v2(133.97,10.18) 133.51,10.18 CK8.1 ; v2(110.96,24.99) 110.96,25.7 110.41,26.25 RK32.1 ; CK1.1 149.7,6.59 153.05,9.93 RK7.2 ; PR9.1 131.62,17.93 130.85,18.7 v2(130.85,18.95) 130.85,19.69 130.97,19.81 130.66,20.12 126.39,20.12 125.69,20.82 125.04,20.82 123.53,22.34 123.53,23.98 v2(123.35,24.16)
  IN2 w0.381: v2(277.75,27.28) 273.6,27.28 273.48,27.16 255.93,27.16 252,31.09 246.85,31.09 246.16,31.78 240.36,31.78 239.18,30.61 228.88,30.61 222.46,24.19 222.46,18.97 221.76,18.27 221.76,17.99 216.89,13.12 211.14,13.12 210.82,13.43 209.83,13.43 209.34,12.94 201.02,12.94 200.4,12.32 197.58,12.32 197.31,12.05 191.12,12.05 190.6,11.53 188.01,11.53 187.3,10.82 185.88,10.82 184.41,12.29 182.21,12.29 180.92,13.58 176.17,13.58 175.47,14.29 175.47,15.02 175.07,15.42 173.69,15.42 v2(173.33,15.06)
  IN2 w0.508: 144.84,5.26 144.47,5.63 141.34,5.63 v2(140.72,5) ; 144.84,5.26 v2(144.84,5) ; 144.84,5.26 145.39,5.81 149.56,5.81 150,5.37 v2(150,5.1)
  BOTTOM w0.381: v2(277.75,27.28) 277.75,28.95 277.13,29.57 277.13,37.68 277.7,38.25 277.7,41.95 v2(277.49,42.16) ; v2(165.99,26.46) 165.5,26.95 164.01,26.95 163.68,26.61 163.68,25.86 163.22,25.4 151.56,25.4 150.78,26.18 v2(150.52,26.18)
  BOTTOM w0.508: v2(150.52,26.18) 150.04,26.18 148.81,24.95 147.7,24.95 146.98,24.23 137.02,24.23 v2(136.68,23.89) 135.48,23.89 135.31,24.06 125.84,24.06 125.74,24.16 v2(123.35,24.16) 123.28,24.09 118.11,24.09 116.92,25.29 114.89,25.29 114.59,24.99 v2(110.96,24.99) ; v2(130.85,18.95) 130.85,18.63 131.23,18.25 131.23,16.98 130.91,16.66 130.91,15.46 129.94,14.5 v2(129.94,13.57) 129.94,12.7 132.47,10.18 v2(133.97,10.18) 135.87,10.18 140.72,5.33 v2(140.72,5)
+3VALWP: length 12.8
  IN3 w0.381: v2(249.41,19.62) 250.4,20.61 250.4,27.24 v2(251.92,28.76)
  BOTTOM w0.254: PU301.14 251.72,29.64 251.92,29.45 v2(251.92,28.76) 252.49,28.76 PR304.2
  vias: v1(242.87,16.85) v2(241.66,20.43) v2(241.66,19.88) v2(241.66,19.32) v2(241.66,18.76) v2(241.66,18.2) v2(242.24,20.43) v2(242.24,19.88) v2(242.24,19.32) v2(242.24,18.76) v2(242.24,18.2)
+3VB_1.8V:
  vias: v2(268.43,19.9)
+3VDS_AUDIO: length 27.3
  TOP w0.203: UA1.18 298.76,21.03 299.13,20.67 299.36,20.67
  TOP w0.254: 300.17,20.6 300.1,20.67 299.36,20.67
  TOP w0.381: RA25.1 LA1.1 289.51,12.27 v2(289.59,12.35) ; v2(293.26,15) 293.25,15.01 RA26.1 ; 300.17,20.6 300.33,20.44 300.33,20.07 300.31,20.04 CA3.1 CA4.1 301.48,19.71 v1(302.18,19.01) v2(302.98,18.21)
  IN3 w0.381: v2(289.59,12.35) 290.91,13.67 291.29,13.67 292.62,15 v2(293.26,15) 293.26,14.65 293.57,14.34 300.67,14.34 303.23,16.9 303.23,17.96 v2(302.98,18.21)
+3VL: length 619.1
  TOP w0.305: 273.09,15.77 272.82,15.77 272.15,16.44
  TOP w0.381: v2(17.01,118.75) 17.01,119.77 16.73,120.05 16.73,121.42 Q80.2 ; 272.15,16.44 271.75,16.85 v3(271.75,18.72) v2(273.49,20.46) ; RK1.1 129,9.75 129.46,9.29 D510.2 131.02,9.68 131.02,11.09 131.58,11.64 R295.2 ; v2(205.94,133.75) 205.95,133.74 D508.2 ; v2(283.53,17.86) 284.18,17.21 PR16.1
  TOP w0.457: v2(141.19,26.18) 141.51,26.49 RH235.2 RH234.2
  TOP w0.508: v2(42.72,47.16) 42.72,47.53 42.38,47.87 RU52.2 ; v2(128.25,10.2) 128.67,10.62 RK1.1 ; v2(180.15,11.36) 180.15,11.02 179.91,10.78 178.71,10.78 177.93,11.55 DH1.3 177.05,11.55 175.4,13.2 174.01,13.2 173.26,13.94 173.11,13.94 166.32,20.73 166.32,24.28 165.38,25.23 165.38,26.94 166.43,27.99 v2(167.47,27.99) ; D511.2 182.38,46.31 v2(181.69,45.62) ; v2(105.88,22.82) 104.93,23.77 Q32.2
  IN1 w0.381: v2(168.37,110.81) 168.35,110.83 168.35,116.11 173.3,121.06 173.73,121.06 177.64,121.06 180.85,124.26 180.85,127.01 179.93,127.93 179.93,130.72 182.11,132.91 182.11,134.3 183.16,135.35 v2(183.16,135.4)
  IN2 w0.381: v2(17.01,118.75) 16.66,118.75 16.34,118.43 16.34,116.47 17.66,115.15 17.66,114.58 18.05,114.18 18.05,99.92 18.41,99.56 18.41,84.7 v2(17.81,84.1) 17.81,83.47 18.88,82.4 18.88,81.18 18.02,80.32 18.02,76.48 v2(18.62,75.88) ; v2(174.62,44.78) 175.05,44.78 175.55,45.28 175.55,48.37 175.86,48.67 175.86,60.04 175.21,60.69 175.21,67.31 175.34,67.43 175.34,68.95 179.52,73.13 179.52,77.02 175.23,81.31 175.23,83.38 175,83.61 175,84.79 172.25,87.54 172.25,97.24 171.53,97.97 171.53,101.81 171.28,102.06 171.28,106.17 169.78,107.67 169.78,109.4 v2(168.37,110.81)
  IN2 w0.508: 253.57,23.52 270.43,23.52 v2(273.49,20.46) ; v2(180.15,11.36) 180.15,10.92 182.29,8.79 188.78,8.79 189.74,9.76 192.28,9.76 192.29,9.77 197.31,9.77 197.99,10.44 203.46,10.44 203.75,10.15 206.35,10.15 206.58,10.39 207.42,10.39 207.91,9.9 210.36,9.9 211.24,10.78 215.15,10.78 216.1,11.73 221.08,11.73 222.97,13.62 222.97,14.13 v2(224.05,15.2) 224.05,16.62 225.32,17.89 225.32,19.88 225.05,20.15 225.05,25.18 229.34,29.48 240.13,29.48 241.33,28.28 249.88,28.28 252.03,26.13 v2(252.03,24.84) ; v2(18.62,75.88) 18.8,75.7 18.8,74.43 20.75,72.48 20.75,70.19 20.51,69.96 20.51,66.34 20.59,66.26 20.59,64.64 23.24,61.99 23.24,59.01 23.61,58.63 27.66,58.63 29.23,57.06 30.52,57.06 32.08,55.5 32.78,55.5 33.65,54.63 34.56,54.63 35.31,53.88 35.31,53.31 36.36,52.27 38,52.27 38.94,51.81 42.49,49.38 42.72,49.1 v2(42.72,47.16) 42.77,47.12 45.18,47.12 45.71,46.59 48.25,46.59 48.9,45.94 49.49,45.94 53.02,42.41 55.84,42.41 56.84,43.41 66.99,43.41 68.7,45.11 v2(77.01,45.11)
  IN3 w0.381: v2(273.49,20.46) 274.03,21.01 276.2,21.01 278.84,18.37 283.01,18.37 v2(283.53,17.86)
  IN3 w0.508: v2(181.69,45.62) 180.56,45.62 179.4,44.46 174.94,44.46 v2(174.62,44.78) ; v2(77.01,45.11) 77.65,45.74 80.1,45.74 81.12,46.76 82.33,46.76 82.93,47.36 90.27,47.36 96.66,40.96 96.66,28.75 100.12,25.3 100.12,24.65 101.95,22.82 v2(105.88,22.82) 107.57,22.82 108.25,23.5 112.26,23.5 112.73,23.97 114.18,23.97 115.28,25.06 118.99,25.06 v2(119.96,26.03)
  BOTTOM w0.381: v2(224.05,15.2) 224.25,15.2 226.83,12.62 PRB44.1 ; v2(183.16,135.4) 183.37,135.4 183.86,135.89 196.79,135.89 200.04,132.64 203.29,132.64 203.91,133.26 205.45,133.26 v2(205.94,133.75) ; RS43.1 17.61,83.84 17.85,84.09 17.85,84.1 v2(17.81,84.1)
  BOTTOM w0.508: v2(174.62,44.78) 174.62,43.73 172.39,41.5 172.39,40.38 172.02,40 172.02,37.01 172.72,36.31 172.72,34.45 173.83,33.34 173.83,32.75 172.28,31.19 171.93,31.19 169.81,29.07 169.81,28.36 169.45,27.99 v2(167.47,27.99) 162.65,27.99 162.02,27.35 156.87,27.35 156.86,27.34 143.34,27.34 142.17,26.18 v2(141.19,26.18) 140.44,26.18 139.8,26.82 136.73,26.82 136.09,26.18 132.42,26.18 131.64,26.95 123.65,26.95 123.43,26.73 120.66,26.73 v2(119.96,26.03) ; RS17.2 17.36,75.97 17.77,75.56 18.31,75.56 v2(18.62,75.88) ; v2(128.25,10.2) 127.07,11.37 120.49,11.37 119.21,12.66 119.21,17.72 116.97,19.96 108.58,19.96 105.88,22.66 v2(105.88,22.82)
  vias: v2(252.38,24.3)
+3VL_RTC: length 18.8
  TOP w0.356: RH32.1 186.8,19.61 187.68,19.61 188.09,19.2 CH84.1 CH26.1 189.69,19.07 190.15,19.07 v2(190.18,19.1)
  TOP w0.508: RH32.1 RH31.1 RH6.1 186.24,17.17 185.65,17.77 v1(182.34,17.77) 181.49,17.77 179.66,15.94 CH27.1 179.66,12.65 DH1.1
  BOTTOM w0.254: UH1.BC49 190.19,19.25 v2(190.18,19.1) 190.55,19.04 UH1.BD49
+3VL_TBTC: length 4.4
  TOP w0.203: UU4.5 42.52,44.46 42.14,44.83 42.14,45.97 CU70.1
  TOP w0.508: CU70.1 42,46.95 RU52.1 RU53.1
+3VLP: length 1.2
  BOTTOM w0.127: PC310.1 252.95,27.54 v1(253.38,27.98)
+3VS: length 810.6
  TOP w0.254: RC377.2 204.86,13.22 QC8.2 ; v2(202.52,16.23) 202.52,16.49 201.5,17.5 RH53.2 RH96.1
  TOP w0.305: RM6.1 56.96,17.2 56.96,16.42 v2(56.84,16.3) ; QC8.5 204.59,15.52 205.16,16.09 205.16,16.1
  TOP w0.381: RD2.1 149.67,37.38 149.67,32.17 v2(150.31,31.53) 150.4,31.44 150.4,30.55 149.61,29.77 146.79,29.77 RD21.1 ; v2(236.27,45.26) 236.23,45.26 235.73,45.76 235.73,47.3 236.17,47.74 236.81,47.74 237.89,48.81 237.89,49.33 237.36,49.86 v2(237.36,50) 237.32,50.04 236.34,50.04 235.78,50.6 235.78,50.93 235.66,51.05 RG113.1 235.66,51.41 RG111.1 ; RK14.1 144.02,5.09 v2(143.93,5) ; CD1.2 169.42,52.52 CD102.2 CD2.2 168.99,51.46 168.86,51.59 v2(168.84,51.59) ; PRZ18.1 175.17,130.26 175.38,130.05 177.48,130.05 178.06,129.47 178.06,126.87 178.76,126.17 ; RH82.1 RH81.2 RH79.2 204.93,17.56 v2(205.27,17.22) 205.16,17.11 RC376.2 205.16,16.1 ; QC9.2 228.52,12.52 226.82,12.52 QC9.5 226.44,12.42 225.81,11.79 v2(225.81,11.63) ; R5247.1 180.75,50.26 181.22,50.74 182.63,50.74 183.65,49.72 183.65,47.63 185.83,45.44 v2(185.83,40.77) ; R5220.1 v2(17.48,5.76) ; CH1.1 218.91,8.28 UH3.5
  TOP w0.508: 45.34,35.95 44.81,35.95 44.47,36.3 44.47,37.53 RU58.1 43.47,37.74 RU57.1 ; 45.34,35.95 45.97,35.33 47.64,35.33 48.16,35.84 48.91,35.84 49.93,34.83 49.93,25.54 49.1,24.71 49.1,22.18 48.45,21.53 46.74,21.53 45.86,20.64 45.86,17.63 v2(47.29,16.2) ; 45.34,35.95 45.74,36.35 v2(45.74,36.59) RU61.1 ; v2(278.7,5.34) 279.68,6.32 286.31,6.32 287.02,5.61 v2(287.57,5.61) 287.57,9.66 LA1.2 ; CD60.2 168.36,37.74 168.99,38.38 RD1.1 ; CD60.2 167.67,37.82 CD61.2 CD103.2 167.67,39.71 167.98,40.01 ; CD60.2 167.75,36.93 RD20.1 167.93,36.74 RD19.1 ; Q7.5 178.4,122.97 v2(178.06,122.63) 177.18,123.51 177.18,124.6 178.76,126.17 R5285.2 180.38,126.17 R5284.2 ; 66.83,42.77 v3(68.72,44.66) 71.17,47.11 72.01,47.11 v2(72.22,47.33) ; 66.83,42.77 65.35,42.77 64.83,42.24 64.83,40.98 C5251.1 C5254.1 64.64,39.27 64.6,39.23 U12.6 ; 66.83,42.77 67.96,41.64 67.96,37.91 67.77,37.72 R5807.1 ; v6(296.4,15.96) 296.61,16.17 RA54.1 ; v2(204.23,11.3) 204.23,11.72 204.86,12.35 RC377.2 ; RH207.1 RH205.1 RH208.1 RH206.1 200.49,13.79 v2(200.23,13.54) ; v2(177.87,67.77) 177.64,68 177.64,68.8 183.74,74.89 184.4,74.89 187.24,77.74 v2(188.1,77.74) 188.1,78.04 187.97,78.18 187.97,80.24 187.96,80.24 187.96,82.35 v2(188.22,82.6) ; CH1.1 v2(220.05,8.66) 220.35,8.66 220.68,8.99 220.68,10.61 222.03,11.96 222.03,15.98 221.57,16.44 218.98,16.44 218.13,17.3 RH209.1 ; RE1.1 274.08,43.15 v2(274.08,42.54) ; v2(214.08,7.77) 214.36,8.05 RH78.2 RH76.2 RH228.2 RH229.2 ; v2(181.34,122.5) 181.34,122.63 180.99,122.97 Q7.2 ; v2(235.89,54.88) 235.95,54.88 v2(237.93,56.85) ; v2(32.44,61.29) 31.63,60.48 RV35.1 RV34.1 ; v2(14,80.11) 14.64,79.47 14.64,78.84 22.26,71.21 22.26,68.65 23.61,67.3 25.23,67.3 25.34,67.42 25.98,67.42 26.47,66.93 26.47,66.19 ; v2(101.14,25.68) 100.75,25.29 100.12,25.29 99.76,25.65 99.24,25.65 98.87,25.29 98.87,23.28 100.56,21.59 100.56,17.44 103.94,14.06 103.94,13.2 105.08,12.06 112.77,12.06 114.43,10.4 116.46,10.4 116.66,10.59 121.28,10.59 v2(123.14,8.73) ; 26.47,66.19 23.86,66.19 RV21.1 22.13,64.3 20.12,62.3 20.12,57.86 CV33.1 21.09,57.76 v2(22,57.76) ; 26.47,66.19 CV31.1 28.43,66.19 28.79,65.83 v2(29.02,65.83) ; v2(300.23,12.49) 300.92,13.18 QWL1.2 ; R5247.1 180.57,50.49 179.7,51.35 178.82,51.35 v2(178.68,51.21) 178.54,51.36 175.03,51.36 171.14,55.24 169.35,55.24 168.59,54.48 168.59,53.36 CD1.2 168.51,52.86 168.13,52.47 168.13,50.98 167.27,50.12 167.27,42.57 167.34,42.51 RD4.1 167.34,40.46 167.78,40.01 167.98,40.01 ; 167.98,40.01 v2(168.01,40.01)
  IN1 w0.508: v2(206.14,7.8) 204.23,9.71 v2(204.23,11.3) ; v2(197.53,8.89) 197.53,9.22 200.23,11.92 v2(200.23,13.54)
  IN2 w0.508: v2(178.06,122.63) 178.19,122.5 v2(181.34,122.5) ; v2(205.27,17.22) 204.53,17.96 203.76,17.96 203.15,17.34 203.15,17.07 202.52,16.44 v2(202.52,16.23)
  IN3 w0.381: v2(150.31,31.53) 150.31,35.74 151.52,36.95 166.62,36.95 167.59,37.92 167.59,39.59 v2(168.01,40.01) ; v2(124.12,90.39) 124.2,90.48 125.65,90.48 125.75,90.58 126.98,90.58 127.56,89.99 130.03,89.99 130.76,90.73 131.88,90.73 132.6,91.44 133.48,91.44 134.09,90.83 141.08,90.83 141.69,91.44 142.14,91.44 143.62,89.96 145.39,89.96 146.16,90.73 150.17,90.73 150.83,90.07 159.03,90.07 160,91.03 160,92.28 161.96,94.23 166.35,94.23 167.85,95.74 168.78,95.74 169.23,96.19 v2(170.09,96.19)
  IN3 w0.457: v2(200.23,13.54) 202.52,15.82 v2(202.52,16.23)
  IN3 w0.508: v2(14,80.11) 16.36,82.47 16.36,105.96 15.33,107 15.33,116.35 14.56,117.11 14.56,118.92 v2(14.49,118.98) ; 262.52,39.62 259.99,39.62 257.1,36.73 255.86,36.73 254.29,38.3 251.96,38.3 250.33,39.93 245.24,39.93 244.23,38.93 239.97,38.93 238.37,40.53 238.37,43.38 237.28,44.47 237.28,45.88 237.58,46.18 237.58,47.19 237.36,47.4 v2(237.36,50) 236.27,51.09 236.27,51.92 236.64,52.29 236.64,53.6 235.89,54.35 v2(235.89,54.88) ; v2(188.22,82.6) 187.96,82.86 187.96,85.25 187.21,86 185.68,86 v2(175.86,95.83) 175.86,97.3 174.82,98.33 174.82,103.62 173.69,104.76 v2(173.69,105.11) 173.69,105.11 173.69,105.66 174.57,106.54 174.57,109.42 179.82,114.66 179.82,117.91 178.06,119.67 v2(178.06,122.63) ; v2(305.12,43.11) 305.12,43.38 302.73,45.77 281.6,45.77 278.98,43.15 274.64,43.15 274.08,42.59 v2(274.08,42.54) 274.08,41.65 272.14,39.71 265.47,39.71
  BOTTOM w0.203: 22,58.57 22.51,59.08 UV2.1 ; 28.06,65.22 UV2.24
  BOTTOM w0.254: v2(305.12,43.11) 305.26,43.25 JIO1.6
  BOTTOM w0.305: v2(200.23,13.54) 200.18,13.59 RH154.1 ; v2(168.01,40.01) 167.54,39.54 167.54,38.94 168.03,38.45 JDIMM2.255 ; v2(168.84,51.59) 169.19,51.59 169.52,51.25 JDIMM1.255 ; UC3.1 180.68,122.14 CV274.1
  BOTTOM w0.356: RH154.1 RH94.1
  BOTTOM w0.381: RG108.1 235,46.73 235,45.63 235.37,45.26 v2(236.27,45.26) 235.67,44.65 UG10.5 234.61,44.1 234.14,43.63 RG106.1 ; R1.1 36.66,14.37 v2(36.15,14.37) ; v2(237.93,56.85) 237.97,56.81 PRW1.1 ; RH164.1 RH170.2 187,28.97 185.98,29.99 185.98,33.82 185.61,34.18 185.61,36.13 185.8,36.33 185.8,40.74 v2(185.83,40.77) ; UG2.5 v2(235.89,54.88)
  BOTTOM w0.508: RG392.2 185.91,82.19 186.45,82.73 188.1,82.73 v2(188.22,82.6) ; v2(178.06,122.63) 177.93,122.5 177.93,120.8 178.14,120.6 RV135.2 ; v2(101.14,25.68) 101.58,26.12 101.58,29.17 99.98,30.78 99.98,35.24 101.42,36.68 101.42,50.57 102.78,51.92 106.44,51.92 108.48,53.97 109.66,53.97 112.2,56.51 164.57,56.51 165.73,55.34 170.81,55.34 174.78,51.37 178.52,51.37 v2(178.68,51.21) 178.68,57.31 176.51,59.48 176.51,65.63 177.87,66.99 v2(177.87,67.77) ; RV16.1 29.02,64.97 v2(29.02,65.83) 28.79,65.83 28.33,66.29 CV32.1 28.06,66.21 28.06,65.22 ; RE3.1 45.74,38.72 v2(45.74,36.59) ; RV23.1 31.63,61.09 32.24,61.09 v2(32.44,61.29) ; RV23.1 RV14.1 ; RV23.1 RV26.1 ; PRF2.1 173.69,104.68 v2(173.69,105.11) ; RV38.1 15.31,120.04 QV1.2 14.97,119.46 v2(14.49,118.98) ; RV136.1 180.48,129.64 181.34,128.79 v2(181.34,122.5) 181.34,121.54 CV274.1 ; v2(287.57,5.61) 288.87,5.61 290.36,7.1 290.36,10.43 292.17,12.25 299.98,12.25 v2(300.23,12.49) 297.32,15.41 297.32,15.53 296.89,15.96 v6(296.4,15.96) 296.18,16.18 RA3.1 ; QR2.2 v2(49.81,15.42) ; UG11.5 186.04,77.76 186.07,77.74 v2(188.1,77.74) ; RR15.2 45.36,14.63 v2(44.75,14.02) ; v2(124.12,90.39) 123.33,89.6 123.33,86.36 RC43.1 ; v2(175.86,95.83) 170.45,95.83 v2(170.09,96.19) ; 22,58.57 v2(22,57.76)
  vias: v2(29.21,58.07) v2(29.6,57.67) v2(35.64,16.03) v2(35.64,15.39) v2(35.64,14.76) v2(35.94,57.5) v2(36.15,15.64) v2(36.15,15.01) v2(36.34,57.12) v2(72.85,47.47) v2(76.98,20.54) v2(77.58,20.55) v2(246.02,8.46) v2(246.02,7.87) v2(246.02,7.29) v2(262.56,40.48) v2(263.05,40.75) v2(263.51,40.44) v2(263.85,40.91) v2(264.14,40.44) v2(264.46,41.24) v2(264.63,40.71) v2(265.02,41.27) v2(265.57,41.25) v2(276.79,24.46) v2(277.4,25.04) v2(277.35,24.46) v2(277.91,24.46) v2(277.96,25.58) v2(277.96,25.02) v2(278.57,7.8) v2(278.57,7.21) v2(278.57,6.63) v2(278.97,23.75) v2(279.18,24.45) v2(279.51,23.99)
+3VS_CAMERA: length 20.2
  TOP w0.254: R5806.2 66.5,41.56 v2(66.64,41.7)
  TOP w0.508: U12.1 64.6,34.9 64.65,34.85 C5253.1 C5255.1 64.65,33.12 64.62,33.1 C5274.2 64.62,32.08 65.26,31.44 v3(65.56,31.44) 66.06,31.44 v2(66.24,31.62)
  IN3 w0.254: v2(66.24,31.62) 65.5,31.62 63.94,33.18 63.94,38.67 66.64,41.37 v2(66.64,41.7)
  BOTTOM w0.254: v2(66.24,31.62) 66.05,31.43 JEDP1.11
+3VS_CR: length 17.5
  TOP w0.127: v2(46.92,19.71) 46.52,19.31 v1(46.52,19.28)
  IN1 w0.508: v2(46.92,19.71) 46.77,19.56 44.56,19.56 43.91,18.91 40.14,18.91 39.63,18.4 39.63,15.78 38.98,15.14 v2(38.54,15.14)
  BOTTOM w0.203: CR2.1 38.28,16.41 38.43,16.26 UR1.11
  BOTTOM w0.508: RR2.1 46.31,19.71 v2(46.92,19.71) ; CR2.1 CR7.1 37.8,14.65 R1.2 38.03,14.63 v2(38.54,15.14)
+3VS_MUX: length 31.1
  TOP w0.127: v1(37.46,55.17) 37.37,55.08 RT6.2
  TOP w0.203: 29.64,54.47 30.08,54.03 UT11.28 ; v2(29.85,47.19) 30.15,47.5 UT11.1 ; UT11.6 32.15,46.44 32.33,46.26 32.33,45.31 v2(32.47,45.17)
  TOP w0.305: RT807.2 30.76,56.47 30.52,56.72 29.64,56.72 v2(29.38,56.45)
  TOP w0.381: v2(28.52,54.13) 27.92,54.13 RT859.2 27.86,54.42 27.72,54.56 CT271.1 29.35,54.76 29.64,54.47 ; v2(29.85,47.19) 29.85,47.33 29.44,47.74 28.2,47.74 27.12,46.66 27.12,45.55 27.39,45.29 RT814.1 27.65,44.59 28.02,44.22 28.64,44.22 29.44,45.03 RT847.1
  IN3 w0.457: v2(32.47,45.17) 30.44,47.19 v2(29.85,47.19)
  BOTTOM w0.381: v2(26.18,50.82) 26.46,51.1 RT853.1 RT850.1 26.79,50.47 26.57,50.25 RT841.1 26.88,49.73 27.06,49.91 27.49,49.91 29,48.4 CT272.1 CT273.1 RT856.1 29.95,47.3 v2(29.85,47.19) 29.95,47.09 RT813.1
  vias: v2(34.08,53.63) v2(34.68,53.61)
+3VS_SSD:
  vias: v2(18.67,2.92) v2(19.23,2.94) v2(19.79,2.96) v2(20.41,2.96) v2(30.14,2.93) v2(30.71,2.89) v2(31.27,2.92) v2(31.83,2.94) v2(35.99,2.72) v2(36.55,2.75) v2(36.74,12.26) v2(36.74,11.68) v2(37.11,2.77) v2(37.32,12.26) v2(37.32,11.68) v2(37.89,12.16) v2(37.89,11.57) v3(21.12,2.28) v3(24.11,2.21) v3(26.79,2.26)
+3VS_TPM: length 24.6
  TOP w0.203: CTT2.1 127.55,17.93 127.15,17.93 126.88,17.66 UT1.22
  TOP w0.254: 119.73,14.86 120.04,15.16 UT1.8 ; UT1.14 124.02,13 CTT323.1 ; CTT4.1 119.11,19.16 119.58,19.16 120.08,18.66 UT1.1
  TOP w0.381: CTT2.1 127.55,18.43 v2(127.19,18.43)
  TOP w0.508: 119.52,12.88 123.31,12.88 123.41,12.98 CTT323.1 ; 119.73,14.86 119.73,14.35 119.38,13.99 CTT1.1
  IN3 w0.508: v2(127.19,18.43) 127.19,18.76 126.73,19.21 120.45,19.21 118.71,17.46 117.29,17.46 v2(117.11,17.64)
  vias: v1(116.82,16.53)
+3VS_WLAN: length 6
  TOP w0.508: v2(307.8,12.59) 306.92,13.47 v3(306.85,13.47) 305.76,13.47 RWL4.1 306.07,12.67 306.09,12.67 307.55,11.21 QWL2.1
  vias: v2(308.67,23.77) v2(308.74,23.14) v2(308.68,7.18) v2(308.7,6.62) v2(309.23,23.69) v2(309.17,7.45) v2(309.2,6.89) v2(309.18,6.29) v2(309.25,24.25) v3(308.54,8.27) v3(310.1,7.61)
+5V_HDMI: length 4.5
  TOP w0.508: v2(19.24,114.7) 18.52,114.7 17.2,116.03 UV4.3
  BOTTOM w0.508: RV27.2 RV28.2 v2(19.24,114.7)
  vias: v3(17.16,117.38)
+5V_TYPEC: length 6.9
  TOP w0.127: DU13.2 13.19,46.94 v3(13.77,46.35)
  TOP w0.254: v2(8.77,53.87) 8.67,53.97 7.98,53.97 7.7,53.69 JUSBC1.A4 6.44,53.69 JUSBC1.B9 ; JUSBC1.B4 6.44,51.19 JUSBC1.A9 7.74,51.19 7.98,50.95 8.64,50.95 v2(8.67,50.98)
  vias: v2(9.42,53.85) v2(9.4,50.97) v2(10.02,45.74) v2(10.75,46.02) v2(11.1,47.4) v2(11.1,46.68) v2(11.41,46.02) v2(12.12,45.72) v2(36.32,42.11) v2(36.32,41.53) v2(36.32,40.94) v2(36.32,40.36) v2(36.32,39.78) v2(36.32,39.19)
+5V_TYPEC_L:
  vias: v1(42.18,39.99)
+5VALW: length 166.7
  TOP w0.127: v2(260.81,38.38) v3(260.81,37.74)
  TOP w0.203: UU4.25 48.34,39.36 48.52,39.19 48.52,38.33 48.81,38.03 49.58,38.03 CU73.1 ; v2(254.09,37.58) 254.21,37.46 254.21,37.02 CC389.1 254.56,37.04 254.56,37.75 254.31,38.01 UC4.4
  TOP w0.254: v2(48.97,38.51) 49.33,38.51 CU73.1 ; PCG6.1 119.97,96.19 119.97,95.53 119.84,95.4 PUG1.4
  TOP w0.305: v2(109.8,87.9) 109.8,87.64 v3(110.04,87.4) 110.3,87.13 110.98,87.13 CC407.1 CC402.1 111.75,87.2 UC6.3
  TOP w0.381: RV51.1 v2(75.47,31.71) ; PRV32.1 231.48,54.68 v2(231.48,54.68) 231.48,54.62 231.93,54.17 231.93,52.94 231.42,52.43 230.43,52.43 PRV34.2
  TOP w0.508: PRZ56.1 v2(165.24,124.93) ; v2(117.66,96.55) 118.27,97.15 119.54,97.15 119.79,96.9 PCG6.1
  IN1 w0.508: v2(109.8,87.9) 108.07,87.9 107.13,88.85 107.13,92.57 ; v2(132.24,136.19) 131.82,135.78 124.76,135.78 122.3,133.32 122.3,124.52 125.83,120.99 125.83,117.46 122.31,113.94 121.81,113.43 119.72,113.43 113.51,107.23 110.45,107.23 107.13,103.91 107.13,92.57 ; 107.13,92.57 114.14,92.57 115.11,93.54 115.11,95.59 115.44,95.91 117.03,95.91 v2(117.66,96.55)
  IN2 w0.508: v2(222.44,61.22) 222.69,61.22 222.77,61.3 223.79,61.3 224.95,60.14 228.46,60.14 230.49,58.1 230.83,58.1 231.86,57.07 231.86,55.06 v2(231.48,54.68)
  IN3 w0.508: v2(260.81,38.38) 260.81,38.12 260.33,37.64 258.93,37.64 257.37,36.08 255.59,36.08 v2(254.09,37.58)
  BOTTOM w0.254: 153.37,135.98 153.23,135.84 PUZ2.4 ; 145.75,135.98 145.61,135.84 PUZ3.4 ; PUZ5.4 130.63,135.84 130.76,135.98 ; 160.86,134.14 160.85,134.12 PUA1.4 ; PUZ4.4 137.99,135.84 138.13,135.98 ; PCW3.1 241.95,51.04 PUW1.7
  BOTTOM w0.356: PCW14.1 PCW13.1 243.09,49.34 PCW12.1
  BOTTOM w0.381: 243.74,51.7 243.74,51.38 243.09,50.73 PCW14.1 242.51,50.49 PCW3.1
  BOTTOM w0.508: v2(147.17,136.17) 146.56,136.17 PCZ53.1 145.89,136.12 145.75,135.98 ; v2(260.81,38.38) 260.81,39.6 262.53,41.32 262.82,41.32 265.23,43.73 267.66,43.73 v2(268.47,42.92) ; 138.13,135.98 138.27,136.12 PCZ67.1 138.92,136.14 v2(139.55,136.14) ; 162.21,134.82 163.05,135.66 163.86,135.66 PRZ47.1 ; 162.21,134.82 v2(161.63,134.82) PCA6.1 160.86,134.14 ; 162.21,134.82 162.21,134.57 162.56,134.21 PRZ72.1 ; v2(154.77,136.12) PCZ39.1 153.51,136.12 153.37,135.98 ; PRM4.1 85.58,24.95 PRM5.1 84.06,26.46 v2(83.29,26.46) ; 243.74,51.7 243.74,53.24 243.74,53.25 243.74,53.67 v2(244.38,54.3) ; PRV27.1 221.79,61.22 v2(222.44,61.22) ; v2(132.24,136.19) 132.16,136.12 PCZ60.1 130.9,136.12 130.76,135.98
  vias: v2(23.26,82.18) v2(23.27,81.56) v2(23.82,82.19) v2(23.83,81.56) v2(40.12,40.74) v2(40.71,41.34) v2(40.71,40.74) v2(41.29,41.34) v2(41.29,40.74) v2(41.88,40.74) v2(68.58,12.54) v2(68.58,11.9) v2(69.09,12.79) v2(69.09,12.16) v2(69.09,11.52) v2(69.59,12.54) v2(69.59,11.9) v2(70.1,12.79) v2(70.1,12.16) v2(70.1,11.52) v2(70.61,12.54) v2(70.61,11.9) v2(71.12,12.79) v2(71.12,12.16) v2(71.11,11.58) v2(71.63,12.54) v2(71.63,11.9) v2(72.13,12.79) v2(72.13,12.16) v2(72.12,11.58) v2(73.16,36.02) v2(73.18,35.43) v2(77.31,37.41) v2(77.33,36.82) v2(77.34,36.17) v2(77.9,37.41) v2(77.93,36.82) v2(77.93,36.17) v2(78.51,37.41) v2(78.54,36.82) v2(78.55,36.25) v2(180.02,106.88) v2(304.6,45.5) v2(304.62,44.81) v2(305.26,45.49) v2(305.27,44.8) v2(305.9,45.49) v2(305.91,44.8) v3(270.85,45.45) v6(268.34,44.79) v6(268.37,45.4) v6(268.68,45.93) v6(268.95,44.79) v6(268.98,45.4) v6(269.3,45.92) v6(269.61,45.4) v6(269.58,44.79) v6(269.91,45.93) v6(270.22,45.4) v6(270.19,44.79) v6(270.8,44.79)
