# Allegro board LA-H461P Rev02.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART_2_CTXD_DRXD: length 126.3
  TOP w0.127: v2(213.78,10.15) 214.06,10.15 214.36,9.85 RH78.1 ; RWL33.1 v1(310.98,14.32) 310.98,13.88 310.41,13.31 308.1,13.31 307.2,14.22 307.03,14.22 305.37,15.88 v2(305.37,16.3)
  IN3 w0.127: v2(221.62,9.77) 221.62,10.27 224.41,13.06 224.41,13.52 226.61,15.71 234.85,15.71 234.97,15.83 236.91,15.83 238.05,16.98 257.58,16.98 257.93,16.62 263.6,16.62 264.42,17.44 270.68,17.44 272.73,19.49 275.89,19.49 277.38,18 277.38,17.41 278.53,16.26 281.65,16.26 285.98,11.93 290.72,11.93 292.35,13.56 302.06,13.56 303.9,15.4 304.48,15.4 v2(305.37,16.3)
  BOTTOM w0.102: UH1.BE20 205.08,18.77 205.36,18.77 205.55,18.58 205.55,18.44
  BOTTOM w0.127: 205.55,18.44 205.55,17.8 205.87,17.47 205.87,17.18 ; 212.42,11.5 v2(213.78,10.15) 214.24,9.69 218.19,9.69 218.91,10.4 220.99,10.4 v2(221.62,9.77)
  BOTTOM w0.135: 212.42,11.5 210.98,11.5 209.4,13.09 209.4,13.66 205.87,17.18
UG_DDR: length 5.8
  TOP w0.127: PQM1.1 94.37,33.19 v1(94.59,33.42)
  IN1 w0.508: v2(93.58,32.48) 93.58,31.39 92.97,30.78 92.05,30.78 91.25,29.98 v2(91.25,29.36)
UG_GT: length 7
  TOP w0.254: PUG1.8 116.95,93.9 116.79,93.75 v2(116.67,93.75)
  IN3 w0.508: v2(116.67,93.75) 116.67,91.67 115.11,90.11 v2(113.87,90.11)
  BOTTOM w0.508: v2(113.87,90.11) PQG1.1
UG_PH1: length 3
  IN3 w0.508: v2(151.27,133.25) 151.15,133.25 v2(150,132.1)
  BOTTOM w0.254: PUZ2.8 151.32,133.29 v2(151.27,133.25)
  BOTTOM w0.508: v2(150,132.1) 150.2,131.91 PQZ1.1
UG_PH2: length 3
  IN3 w0.508: v2(142.38,132.1) 143.53,133.25 v2(143.65,133.25)
  BOTTOM w0.254: PUZ3.8 143.7,133.29 v2(143.65,133.25)
  BOTTOM w0.508: PQZ2.1 142.58,131.91 v2(142.38,132.1)
UG_PH3: length 3
  IN3 w0.508: v2(136.03,133.25) 135.84,133.25 v2(134.73,132.13)
  BOTTOM w0.254: PUZ4.8 136.08,133.29 v2(136.03,133.25)
  BOTTOM w0.508: v2(134.73,132.13) 134.96,131.91 PQZ3.1
UG_PH4: length 3
  IN3 w0.508: v2(127.4,132.1) 128.54,133.25 v2(128.67,133.25)
  BOTTOM w0.254: PUZ5.8 128.71,133.29 v2(128.67,133.25)
  BOTTOM w0.508: PQZ4.1 127.59,131.91 v2(127.4,132.1)
UG_VCCSA: length 2.8
  TOP w0.127: v1(159.4,132.18) 159.59,131.99 PRA2.2
  TOP w0.508: v2(159.06,130.45) 159.09,130.45 159.59,130.96 PRA2.2
  BOTTOM w0.254: v2(159.06,130.45) 159.35,130.74 PUA1.8
UG_VCCSA_R: length 8.5
  TOP w0.508: v2(158.58,128.67) 159.59,129.69 PRA2.1
  IN3 w0.508: v2(156.73,123.72) 158.07,125.06 158.07,127.39 158.58,127.9 v2(158.58,128.67)
  BOTTOM w0.127: v1(159.06,129.03) 158.7,128.67 v2(158.58,128.67)
  BOTTOM w0.508: PQA1.1 v2(156.73,123.72)
USB2_RCOMP: length 2.9
  TOP w0.203: v1(214.34,38.99) 214.34,38.67 213.54,37.87 RH8.1
  TOP w0.508: v2(212.78,38.05) 212.96,37.87 RH8.1
  BOTTOM w0.254: UH1.F4 v2(212.78,38.05)
USB3_DPE_MRX_C_DTX_N1: length 22.1
  TOP w0.127: CT320.1 26.09,52.54 25.59,52.54 RT1112.1 25.3,52.52 23.61,52.52 v2(23.43,52.33)
  BOTTOM w0.127: v2(23.43,52.33) 23.25,52.51 18.42,52.51 18.21,52.72 15.7,52.72 15.6,52.63 DU2.7 DU2.4 13.71,52.63 13.62,52.72 13.36,52.72 12.54,53.55 11.12,53.55 10.29,54.37 5.72,54.37 JUSBC1.B10
USB3_DPE_MRX_C_DTX_N2: length 22.5
  TOP w0.127: JUSBC1.A10 7.78,50.69 7.9,50.57 9.13,50.57 9.39,50.31 12.57,50.31 12.88,50.61 12.88,51.18 13.27,51.57 13.59,51.57 13.68,51.66 DU1.4 DU1.7 15.56,51.66 15.65,51.57 15.98,51.57 16.59,50.96 19.52,50.96 19.93,51.37 v4(20.44,51.37) 21.28,51.37 24.09,48.56 26.3,48.56 RT1114.1 26.66,48.56 26.89,48.56 CT322.1
USB3_DPE_MRX_C_DTX_P1: length 22.1
  TOP w0.127: CT319.1 26.13,52.86 25.55,52.86 RT1111.1 25.3,52.83 23.64,52.83 v2(23.43,53.04)
  BOTTOM w0.127: v2(23.43,53.04) 23.21,52.83 18.55,52.83 18.34,53.04 15.65,53.04 15.55,53.13 DU2.6 DU2.5 13.74,53.13 13.64,53.04 13.5,53.04 12.67,53.87 11.25,53.87 10.42,54.69 5.74,54.69 JUSBC1.B11
USB3_DPE_MRX_C_DTX_P2: length 22.4
  TOP w0.127: JUSBC1.A11 7.83,50.19 7.89,50.25 9,50.25 9.26,49.99 12.71,49.99 13.2,50.48 13.2,51.05 13.4,51.25 13.58,51.25 13.67,51.16 DU1.5 DU1.6 15.59,51.16 15.68,51.25 15.85,51.25 16.46,50.65 v4(17.09,50.65) 19.65,50.65 20.06,51.05 21.15,51.05 23.95,48.25 26.34,48.25 RT1113.1 26.62,48.25 26.92,48.25 CT321.1
USB3_DPE_MRX_DTX_N1: length 2.8
  TOP w0.127: CT320.2 27.03,52.54 v4(27.88,52.54) 28.24,52.54 28.36,52.42 28.81,52.42 28.85,52.38 UT11.31
USB3_DPE_MRX_DTX_N2: length 2.2
  TOP w0.127: UT11.39 29.04,49.18 29,49.14 28.58,49.14 28.04,48.6 27.79,48.6 CT322.2
USB3_DPE_MRX_DTX_P1: length 2.8
  TOP w0.127: UT11.30 28.85,52.78 28.81,52.74 28.5,52.74 28.37,52.86 26.99,52.86 CT319.2
USB3_DPE_MRX_DTX_P2: length 2.2
  TOP w0.127: CT321.2 27.83,48.28 28.17,48.28 28.71,48.82 28.97,48.82 29.01,48.78 UT11.40
USB3_DPE_MTX_C_DRX_N1: length 21.2
  TOP w0.127: JUSBC1.A3 7.74,54.19 7.82,54.26 8.21,54.26 8.38,54.43 v4(9.5,54.43) 11.59,54.43 13.29,52.73 13.59,52.73 13.66,52.66 DU1.2 DU1.9 15.57,52.66 15.66,52.75 21.82,52.75 23.8,50.77 25.52,50.77 26.07,51.32 26.56,51.32 CT280.1
USB3_DPE_MTX_C_DRX_N2: length 23.3
  TOP w0.127: CT282.1 26.56,50.38 26.14,50.38 25.99,50.23 23.6,50.23 21.61,52.22 19.4,52.22 19.12,51.94 17.75,51.94 v2(17.56,52.14)
  BOTTOM w0.127: JUSBC1.B3 5.74,50.49 12.1,50.49 13.13,51.53 13.54,51.53 13.65,51.63 DU2.2 DU2.9 15.53,51.63 15.62,51.54 16.07,51.54 16.47,51.94 17.36,51.94 v2(17.56,52.14)
USB3_DPE_MTX_C_DRX_P1: length 21.2
  TOP w0.127: JUSBC1.A2 7.75,54.69 7.85,54.58 8.08,54.58 8.25,54.75 v4(11.1,54.75) 11.72,54.75 13.43,53.05 13.59,53.05 13.71,53.16 DU1.1 DU1.10 15.61,53.16 15.7,53.07 21.95,53.07 23.93,51.09 25.39,51.09 25.94,51.64 26.59,51.64 CT279.1
USB3_DPE_MTX_C_DRX_P2: length 23.2
  TOP w0.127: CT281.1 26.59,50.06 26.27,50.06 26.12,49.91 23.47,49.91 21.48,51.9 19.53,51.9 19.25,51.62 17.75,51.62 v2(17.56,51.43)
  BOTTOM w0.127: JUSBC1.B2 5.73,50.18 12.23,50.18 13.26,51.21 13.54,51.21 13.62,51.13 DU2.1 DU2.10 15.63,51.13 15.72,51.22 16.2,51.22 16.6,51.62 17.36,51.62 v2(17.56,51.43)
USB3_DPE_MTX_DRX_N1: length 2.3
  TOP w0.127: UT11.34 28.85,51.18 28.81,51.22 v4(28.28,51.22) 27.87,51.22 27.77,51.32 27.49,51.32 CT280.2
USB3_DPE_MTX_DRX_N2: length 2.3
  TOP w0.127: CT282.2 27.47,50.4 28.12,50.4 28.23,50.3 28.84,50.3 28.92,50.38 UT11.36
USB3_DPE_MTX_DRX_P1: length 2.3
  TOP w0.127: CT279.2 27.46,51.64 27.9,51.64 28,51.54 28.81,51.54 28.85,51.58 UT11.33
USB3_DPE_MTX_DRX_P2: length 2.3
  TOP w0.127: CT281.2 27.48,50.09 27.99,50.09 28.1,49.98 UT11.37
USB3_PRX_C_MTX_N4: length 2.3
  TOP w0.127: CT286.1 31.43,45.83 31.43,47.28 31.35,47.35 UT11.4
USB3_PRX_C_MTX_P4: length 2.3
  TOP w0.127: CT285.1 31.68,45.95 v4(31.68,46.66) 31.68,47.28 31.75,47.35 UT11.5
USB3_PRX_DTX_N1: length 313.8
  IN3 w0.127: v2(21.74,87.36) 21.74,87.51 21.57,87.68 21.42,87.68 21.22,87.48 21.22,79.96 20.4,79.15 20.4,74.13 21.2,73.34 21.2,69.96 20.54,69.31 20.54,68.43 21.22,67.76 21.66,67.76 24.01,65.41 24.01,64.96 24.29,64.68 27.49,64.68 28.59,63.58 28.59,57.9 29.28,57.21 30.05,57.21 32.06,55.2 36.32,55.2 38,53.52 38.59,53.52 39.63,52.48 39.78,52.48 43.15,49.11 43.15,48.44 44.88,46.71 48.46,46.71 51.26,43.92 51.26,41.47 53.17,39.57 53.17,38.04 53.46,37.75 53.46,36.48 54.69,35.25 54.69,30.94 54.43,30.68 54.43,29.66 57.75,26.34 60.47,26.34 61.83,24.98 61.83,21.6 63.16,20.27 63.16,20.06 66.8,16.42 72.84,16.42 74.37,14.89 80.54,14.89 83.61,11.82 84.72,11.82 85.31,11.22 87.29,11.22 88.64,9.87 90.39,9.87 93.14,7.13 122.7,7.13 123.19,7.62 128.67,7.62 130.01,6.27 134.9,6.27 135.87,7.25 152.6,7.25 153.77,8.42 153.77,9.14 156.33,11.69 168.11,11.69 170.19,9.61 176.18,9.61 177.69,8.1 188.71,8.1 189.85,6.96 199,6.96 199.37,7.33 206.52,7.33 206.67,7.17 208.37,7.17 210.63,9.43 213.9,9.43 214.28,9.81 214.28,10.39 214.75,10.86 215.06,10.86 218.35,14.15 219.53,14.15 219.96,14.57 219.96,15.57 220.29,15.9 220.29,30.32 222.47,32.5 222.47,37.79 222.25,38 222.05,38 221.76,38.29 221.76,38.49 221.48,38.78 221.27,38.78 220.99,39.06 220.99,39.27 220.7,39.55 220.5,39.55 220.21,39.84 220.21,40.04 219.92,40.33 219.72,40.33 219.43,40.62 219.43,40.82 219.15,41.11 218.94,41.11 218.66,41.39 218.66,41.6 218.37,41.88 217.52,41.88 217.37,41.74 216.97,41.74 216.82,41.88 216.42,41.88 216.28,41.74 215.87,41.74 215.73,41.88 215.32,41.88 215.18,41.74 214.77,41.74 214.63,41.88 214.23,41.88 214.08,41.74 213.68,41.74 213.53,41.88 213.13,41.88 212.98,41.73 212.49,41.73 212.35,41.59 211.94,41.59 211.8,41.73 211.4,41.73 211.25,41.59 210.85,41.59 210.7,41.73 210.3,41.73 210.17,41.86 209.52,41.86 209.44,41.78 209.44,41.65 v2(209.36,41.57)
  BOTTOM w0.089: UH1.D11 209.51,39.04 209.51,39.06 209.51,39.43 209.34,39.6 209.34,40.95 208.97,41.32 208.97,41.62 209.09,41.74 209.19,41.74 v2(209.36,41.57)
  BOTTOM w0.127: RS34.1 20.44,88.08 20.86,88.08 21.33,87.61 21.49,87.61 v2(21.74,87.36)
USB3_PRX_DTX_N2: length 105
  IN1 w0.135: v2(305.54,39.8) 305.54,39.74 305.42,39.62 305.09,39.62 304.45,40.26 288.23,40.26 287.67,39.7 277.29,39.7 276.26,38.66 272.18,38.66 271.55,39.29 257.59,39.29 257.36,39.52 255.35,39.52 254.58,40.28 254.14,40.28 253.41,41.01 252.83,41.01 252.43,41.41 248.42,41.41 248.29,41.55 244.69,41.55 244.13,40.99 243.16,40.99 242.02,39.84 239.21,39.84 238.88,40.17 236.32,40.17 236.15,40.34 234.8,40.34 234.32,39.86 232.59,39.86 231.69,38.97 221.39,38.97 218.54,41.81 217.74,41.81 217.59,41.95 217.19,41.95 217.04,41.81 216.64,41.81 216.5,41.95 216.09,41.95 215.95,41.81 213.84,41.81 213.75,41.9 212.57,41.9 212.42,42.04 212.02,42.04 211.87,41.9 211.47,41.9 211.28,42.08 211.28,42.29 211.41,42.42 v2(211.47,42.42)
  BOTTOM w0.089: UH1.B9 210.28,39.65 210.35,39.59 210.45,39.59 210.5,39.64 210.5,39.95 210.39,40.05 210.39,40.12 210.56,40.29 210.56,40.54 210.78,40.76 210.78,41.38 211.23,41.83 211.23,42.18 v2(211.47,42.42)
  BOTTOM w0.127: JIO1.13 306.15,39.75 306.03,39.63 305.71,39.63 v2(305.54,39.8)
USB3_PRX_DTX_N3: length 113.5
  IN1 w0.135: v2(305.61,36.89) 305.48,36.76 305.25,36.76 305.17,36.84 305.17,37.25 305.72,37.8 305.94,37.8 306.76,38.62 306.76,40.74 306.2,41.3 293.53,41.3 292.95,41.87 288.42,41.87 287.19,40.64 274.54,40.64 273.91,40.01 257.89,40.01 257.24,40.66 255.22,40.66 254.88,41 254.43,41 253.3,42.13 248.72,42.13 247.95,42.9 245.03,42.9 243.91,41.79 242.25,41.79 241.66,41.2 239.6,41.2 239.42,41.01 236.64,41.01 236.46,41.2 234.4,41.2 233.78,40.58 232.28,40.58 231.38,39.69 221.84,39.69 218.71,42.81 215.91,42.81 215.62,42.53 214.51,42.53 213.92,43.11 212.44,43.11 212.03,43.52 211.83,43.52 211.62,43.73 210.71,43.73 210,43.02 210,42.93 v2(209.77,42.7)
  BOTTOM w0.089: v2(209.77,42.7) 210.11,42.36 210.11,41.7 210.06,41.65 209.9,41.65 209.81,41.56 209.81,41.46 209.9,41.37 210.05,41.37 210.11,41.31 210.11,40.91 209.99,40.78 209.99,40.53 209.67,40.21 209.67,39.75 UH1.B10
  BOTTOM w0.127: v2(305.61,36.89) 305.85,36.65 306.23,36.65 306.33,36.75 JIO1.19
USB3_PRX_DTX_P1: length 313.8
  IN3 w0.127: v2(21.74,88.07) 21.6,87.94 21.31,87.94 20.96,87.59 20.96,80.07 20.14,79.25 20.14,74.03 20.94,73.23 20.94,70.07 20.28,69.41 20.28,68.33 21.11,67.5 21.56,67.5 23.76,65.3 23.76,64.85 24.18,64.43 27.38,64.43 28.33,63.47 28.33,57.8 29.17,56.95 29.94,56.95 31.95,54.95 36.21,54.95 37.9,53.26 38.48,53.26 39.52,52.22 39.67,52.22 42.89,49 42.89,48.34 44.77,46.46 48.36,46.46 51.01,43.81 51.01,41.37 52.91,39.46 52.91,37.94 53.21,37.64 53.21,36.37 54.44,35.14 54.44,31.05 54.17,30.78 54.17,29.55 57.65,26.08 60.36,26.08 61.57,24.87 61.57,21.49 62.9,20.16 62.9,19.95 66.69,16.16 72.73,16.16 74.26,14.63 80.43,14.63 83.5,11.56 84.61,11.56 85.21,10.96 87.19,10.96 88.53,9.62 90.29,9.62 93.03,6.87 122.81,6.87 123.3,7.36 128.56,7.36 129.91,6.02 135,6.02 135.98,6.99 152.71,6.99 154.03,8.32 154.03,9.03 156.43,11.44 168,11.44 170.08,9.36 176.07,9.36 177.59,7.84 188.6,7.84 189.74,6.7 199.11,6.7 199.48,7.07 206.41,7.07 206.57,6.92 208.48,6.92 210.73,9.17 214,9.17 214.54,9.71 214.54,10.28 214.86,10.6 215.16,10.6 218.45,13.89 219.64,13.89 220.21,14.47 220.21,15.46 220.55,15.79 220.55,30.22 222.72,32.39 222.72,37.89 218.48,42.14 213.02,42.14 212.88,41.99 210.41,41.99 210.28,42.12 209.6,42.12 209.44,42.28 v2(209.36,42.28)
  BOTTOM w0.089: UH1.C11 209.26,39.41 209.15,39.52 209.15,40.88 208.78,41.25 208.78,41.7 209.01,41.93 209.32,41.93 209.42,42.03 209.42,42.22 v2(209.36,42.28)
  BOTTOM w0.127: RS32.1 20.47,88.34 20.97,88.34 21.44,87.87 21.53,87.87 v2(21.74,88.07)
USB3_PRX_DTX_P2: length 105
  IN1 w0.135: v2(210.88,42.42) 211.01,42.29 211.01,41.96 211.35,41.62 213.63,41.62 213.72,41.53 218.43,41.53 221.27,38.69 231.81,38.69 232.7,39.58 234.43,39.58 234.91,40.06 236.04,40.06 236.21,39.89 238.76,39.89 239.09,39.56 242.13,39.56 243.28,40.71 244.24,40.71 244.81,41.27 248.17,41.27 248.31,41.14 252.31,41.14 252.72,40.73 253.29,40.73 254.02,40 254.47,40 255.23,39.24 257.25,39.24 257.47,39.01 271.44,39.01 272.07,38.38 276.37,38.38 277.41,39.42 287.79,39.42 288.35,39.98 304.34,39.98 304.97,39.34 305.42,39.34 v2(305.54,39.22)
  BOTTOM w0.089: v2(210.88,42.42) 211.04,42.26 211.04,41.91 210.59,41.46 210.59,40.84 210.37,40.62 210.37,40.37 210.06,40.06 210.06,39.64 UH1.C9
  BOTTOM w0.127: v2(305.54,39.22) 305.69,39.37 306.03,39.37 306.15,39.25 JIO1.14
USB3_PRX_DTX_P3: length 113.5
  IN1 w0.135: v2(305.62,36.19) 305.62,36.35 305.49,36.48 305.13,36.48 304.89,36.72 304.89,37.36 305.61,38.08 305.82,38.08 306.48,38.73 306.48,40.62 306.09,41.02 293.41,41.02 292.84,41.59 288.54,41.59 287.31,40.36 274.66,40.36 274.03,39.73 257.77,39.73 257.12,40.38 255.11,40.38 254.76,40.72 254.32,40.72 253.18,41.85 248.6,41.85 247.84,42.62 245.14,42.62 244.03,41.51 242.37,41.51 241.78,40.92 239.72,40.92 239.53,40.73 236.53,40.73 236.35,40.92 234.51,40.92 233.9,40.3 232.39,40.3 231.5,39.41 221.72,39.41 218.59,42.53 218.24,42.53 218.09,42.39 217.71,42.39 217.57,42.53 217.07,42.53 216.92,42.38 216.58,42.38 216.43,42.53 216.02,42.53 215.74,42.25 214.39,42.25 213.8,42.83 213.42,42.83 213.28,42.69 212.87,42.69 212.73,42.83 212.32,42.83 211.92,43.24 211.71,43.24 211.51,43.45 210.82,43.45 210.28,42.9 210.28,42.78 v2(210.36,42.7)
  BOTTOM w0.089: UH1.C10 209.86,39.24 209.86,40.13 210.18,40.45 210.18,40.7 210.3,40.83 210.3,42.65 v2(210.36,42.7)
  BOTTOM w0.127: v2(305.62,36.19) 305.82,36.39 306.17,36.39 306.31,36.25 JIO1.20
USB3_PRX_MTX_N4: length 288.1
  TOP w0.127: CT286.2 31.43,45.04 31.43,44.61 v4(31.74,44.3) 32.09,43.95 35.15,43.95 35.87,44.67 35.87,46.35 36.22,46.7 36.35,46.82 v2(36.43,46.82)
  IN3 w0.127: v2(36.43,46.82) 36.43,46.99 36.56,47.11 36.7,47.11 37.09,46.72 37.09,46.14 39.32,43.9 39.32,40.21 40.9,38.63 42.17,38.63 42.96,37.84 49.86,37.84 50.55,37.14 50.55,36.09 50.89,35.75 50.89,35.53 52.21,34.22 52.21,31.97 51.92,31.69 51.92,28.39 55.53,24.78 55.53,22.88 56.15,22.27 57.66,22.27 58.12,21.8 58.12,20.88 65.46,13.54 72.14,13.54 73.35,12.33 76.92,12.33 78.58,10.67 80.99,10.67 84.69,6.97 88.23,6.97 90.56,4.64 138.87,4.64 139.84,5.61 153.48,5.61 155.56,7.7 155.56,8.61 156.99,10.04 167.03,10.04 168.35,8.72 168.35,7.67 169.67,6.35 169.67,5.92 170.45,5.14 214.34,5.14 215.72,6.52 215.72,8.26 216.2,8.73 217.41,8.73 218.81,10.13 219.14,10.13 221.06,12.04 221.74,12.04 222.79,13.1 222.79,16.32 221.92,17.18 221.92,29.64 224.51,32.23 224.51,35.22 224.1,35.63 224.1,39.26 218.11,45.25 209.24,45.25 206.17,42.17 206.17,41.65 205.69,41.18 205.69,39.96 206.4,39.25 206.4,37.65 206.12,37.37 206.12,36.35 206.65,35.83 v2(206.65,35.75)
  BOTTOM w0.089: UH1.K16 207.09,35.75 v2(206.65,35.75)
USB3_PRX_MTX_P4: length 288.1
  TOP w0.127: CT285.2 31.69,44.93 31.69,44.72 31.93,44.48 32.02,44.39 32.2,44.2 v4(33.18,44.2) 35.04,44.2 35.61,44.77 35.61,46.45 35.97,46.8 v2(35.97,47.23)
  IN3 w0.127: v2(206.89,36.55) 207.01,36.51 207.07,36.38 207.01,36.21 206.86,36.14 206.62,36.22 206.61,36.23 206.38,36.46 206.38,37.27 206.66,37.54 206.66,39.35 205.95,40.06 205.95,41.07 206.42,41.54 206.42,42.07 206.8,42.44 207,42.44 207.29,42.73 207.29,42.93 207.57,43.22 207.78,43.22 208.06,43.5 208.06,43.71 208.35,43.99 208.55,43.99 208.84,44.28 208.84,44.48 209.35,44.99 209.75,44.99 209.9,44.85 210.3,44.85 210.45,44.99 210.85,44.99 210.99,44.85 211.4,44.85 211.54,44.99 211.95,44.99 212.09,44.85 212.5,44.85 212.64,44.99 213.04,44.99 213.19,44.85 213.59,44.85 213.74,44.99 214.14,44.99 214.29,44.85 214.69,44.85 214.84,44.99 215.24,44.99 215.38,44.85 215.79,44.85 215.93,44.99 216.24,44.99 216.39,44.84 216.88,44.84 217.03,44.99 218.01,44.99 223.84,39.16 223.84,35.52 224.25,35.11 224.25,32.33 221.67,29.75 221.67,17.08 222.53,16.21 222.53,13.2 221.63,12.3 220.95,12.3 219.04,10.39 218.7,10.39 217.31,8.99 216.09,8.99 215.54,8.44 215.47,8.36 215.47,6.63 214.24,5.4 170.56,5.4 169.92,6.03 169.92,6.46 168.61,7.77 168.61,8.83 167.14,10.3 156.88,10.3 155.3,8.72 155.3,7.8 153.37,5.87 139.74,5.87 138.76,4.9 90.67,4.9 88.34,7.23 84.79,7.23 81.1,10.92 78.68,10.92 77.02,12.58 73.46,12.58 72.24,13.8 65.56,13.8 58.38,20.98 58.38,21.91 57.76,22.53 56.25,22.53 55.79,22.99 55.79,24.88 52.18,28.49 52.18,31.58 52.46,31.87 52.46,34.32 51.15,35.64 51.15,35.86 50.81,36.2 50.81,37.25 49.96,38.1 43.07,38.1 42.27,38.89 41.01,38.89 39.58,40.31 39.58,44 37.34,46.24 37.34,46.83 36.8,47.37 36.45,47.37 36.3,47.23 35.97,47.23 v2(35.97,47.23)
  BOTTOM w0.089: UH1.J15 v2(206.89,36.55)
USB3_PRX_R_DTX_N1: length 9.9
  BOTTOM w0.127: JUSB3.5 13.2,85.56 13.33,85.69 13.77,85.69 14.29,86.21 16.23,86.21 16.53,86.51 v4(16.53,86.85) 16.53,87.3 16.13,87.69 16.13,88.05 16.24,88.16 17.27,88.16 17.39,88.03 DS6.1 DS6.9 18.94,88.03 19.06,88.15 19.44,88.15 RS34.2
USB3_PRX_R_DTX_P1: length 9.9
  BOTTOM w0.127: JUSB3.6 13.2,86.09 13.34,85.95 13.67,85.95 14.19,86.47 16.07,86.47 16.27,86.67 16.27,87.19 15.88,87.59 15.88,88.16 16.13,88.41 v4(16.57,88.41) 17.27,88.41 17.39,88.53 DS6.2 DS6.8 18.87,88.53 19,88.41 19.55,88.41 RS32.2
USB3_PTX_C_DRX_N1: length 1
  BOTTOM w0.127: CS34.1 20.71,89.75 20.46,89.75 RS27.1
USB3_PTX_C_DRX_P1: length 1
  BOTTOM w0.127: CS29.1 20.71,90 20.46,90 RS28.1
USB3_PTX_C_MRX_N4: length 2.5
  TOP w0.127: UT11.7 32.55,47.46 32.63,47.38 32.63,47.15 v4(33.02,46.77) 33.48,46.3 33.48,46.07 CT288.1
USB3_PTX_C_MRX_P4: length 2.5
  TOP w0.127: CT287.1 33.74,46.03 33.74,46.41 33.2,46.95 32.89,47.26 32.89,47.38 32.95,47.45 UT11.8
USB3_PTX_DRX_N1: length 307.4
  IN3 w0.127: v2(210.37,37.38) 210.32,37.33 210.32,36.98 210.44,36.86 211.09,36.86 211.44,37.21 211.44,37.68 211.19,37.93 211.19,38.26 211.03,38.43 211.03,39.68 211.71,40.36 216.86,40.36 219.74,37.49 221.37,37.49 221.78,37.07 221.78,32.78 218.15,29.15 218.15,21.45 218.39,21.2 218.39,17.99 218.79,17.59 219.29,17.59 219.6,17.28 219.6,16.41 214.85,11.66 211.13,11.66 208.07,8.59 205.32,8.59 205.11,8.8 203.17,8.8 202.39,8.02 198.34,8.02 198.01,7.69 190.09,7.69 188.99,8.79 178.26,8.79 176.7,10.35 171.01,10.35 168.98,12.38 156.04,12.38 151.6,7.94 134.5,7.94 133.63,7.06 130.2,7.06 128.96,8.31 122.88,8.31 122.39,7.82 94.13,7.82 91.72,10.22 91.72,10.22 91.33,10.61 89.04,10.61 87.47,12.18 87.47,12.55 85.57,14.45 82.26,14.45 79.57,17.14 67.09,17.14 64.41,19.83 64.41,20.13 62.92,21.62 62.92,24.86 60.71,27.06 60.04,27.06 59.02,28.09 57.01,28.09 55.82,29.28 55.82,30.85 55.38,31.29 55.38,35.53 54.17,36.75 54.17,38.02 53.86,38.33 53.86,39.99 53.43,40.41 53.43,42.72 48.72,47.44 45.17,47.44 43.9,48.7 43.9,49.33 40.04,53.18 39.91,53.18 38.88,54.21 38.28,54.21 36.6,55.89 32.34,55.89 29.28,58.95 29.28,63.87 26.76,66.39 24.02,66.39 22.73,67.68 22.73,75.67 21.72,76.68 21.72,79.23 21.96,79.47 21.96,84.3 22.43,84.77 22.43,88.92 22.01,89.34 22.01,89.64 22.14,89.77 22.45,89.77 v2(22.7,89.52)
  BOTTOM w0.089: UH1.F9 210.59,37.75 210.49,37.45 v2(210.37,37.38)
  BOTTOM w0.127: v2(22.7,89.52) 22.48,89.74 22.25,89.74 CS34.2
USB3_PTX_DRX_N2: length 105.4
  IN1 w0.135: v2(302.99,36.73) 303.18,36.91 303.18,37.2 302.08,38.3 293.25,38.3 292.72,37.77 288.88,37.77 288.2,37.09 279.46,37.09 278.9,36.53 274.13,36.53 273.72,36.95 267.98,36.95 267.64,36.61 259.64,36.61 259.05,37.21 255.8,37.21 255.21,37.8 254.62,37.8 254.33,38.09 253.72,38.09 253,38.8 251.85,38.8 250.95,39.7 248.6,39.7 248.16,39.26 244.93,39.26 243.79,38.12 238.45,38.12 238.12,38.45 237.77,38.45 237.42,38.1 233.94,38.1 233.09,37.25 229.3,37.25 229.16,37.1 225.62,37.1 225.47,36.96 225.07,36.96 224.92,37.1 224.52,37.1 224.38,36.96 223.97,36.96 223.83,37.1 223.42,37.1 223.28,36.96 222.87,36.96 222.73,37.1 222.33,37.1 222.18,36.96 221.78,36.96 221.63,37.1 221.23,37.1 221.08,36.96 220.68,36.96 220.54,37.1 220.13,37.1 219.61,37.62 219.41,37.62 219.12,37.91 219.12,38.11 218.83,38.4 218.63,38.4 218.34,38.69 218.34,38.89 218.06,39.18 216.2,39.18 215.91,38.89 214.38,38.89 213.99,39.28 213.21,39.28 212.98,39.05 212.93,38.8 v2(213.06,38.61)
  BOTTOM w0.089: v2(213.06,38.61) 213.25,38.94 213.28,39.09 UH1.C3
  BOTTOM w0.127: JIO1.10 305.47,41.25 304.86,40.64 304.86,39.99 303.67,38.8 303.28,38.8 302.86,38.37 302.86,37.76 302.99,37.63 v2(302.99,36.73)
USB3_PTX_DRX_N3: length 109.8
  IN1 w0.135: v2(209.89,37.71) 209.82,37.71 209.58,37.47 209.32,37.47 209.07,37.71 209.07,38.59 209.36,38.88 209.56,38.88 209.85,39.16 209.85,39.37 210.14,39.65 210.34,39.65 210.63,39.94 210.63,40.14 210.98,40.5 211.39,40.5 211.53,40.35 211.93,40.35 212.08,40.5 212.52,40.5 212.71,40.31 213.11,40.31 213.25,40.17 213.66,40.17 213.8,40.31 214.21,40.31 214.35,40.17 214.76,40.17 214.9,40.31 215.3,40.31 215.45,40.17 215.85,40.17 216,40.31 216.4,40.31 216.55,40.17 216.95,40.17 217.09,40.31 217.5,40.31 217.64,40.17 218.05,40.17 218.19,40.31 218.6,40.31 219.18,39.73 219.18,39.53 219.47,39.24 219.68,39.24 219.96,38.95 219.96,38.75 220.25,38.46 220.45,38.46 220.95,37.97 221.35,37.97 221.5,37.82 221.9,37.82 222.04,37.97 222.45,37.97 222.59,37.82 223,37.82 223.14,37.97 223.55,37.97 223.69,37.82 224.09,37.82 224.24,37.97 224.64,37.97 224.79,37.82 225.19,37.82 225.34,37.97 232.79,37.97 233.64,38.82 236.81,38.82 237.16,39.17 238.41,39.17 238.75,38.84 243,38.84 243.46,39.29 243.46,39.64 243.8,39.99 247.77,39.99 248.2,40.42 251.93,40.42 252.36,39.99 252.84,39.99 254.01,38.81 254.63,38.81 254.92,38.52 256.95,38.52 257.17,38.3 259.02,38.3 259.99,37.33 267.35,37.33 267.68,37.66 274.13,37.66 274.55,37.25 278.6,37.25 279.26,37.9 288,37.9 288.65,38.55 292.23,38.55 292.94,39.26 303.93,39.26 304.7,38.49 304.7,38.19 304.58,38.07 304.37,38.07 v2(304.14,38.29)
  BOTTOM w0.127: UH1.F11 209.37,37.65 209.47,37.54 209.72,37.54 v2(209.89,37.71) ; JIO1.16 306.15,38.25 306.02,38.12 304.31,38.12 v2(304.14,38.29)
USB3_PTX_DRX_P1: length 307.4
  IN3 w0.127: v2(22.7,90.23) 22.5,90.03 22.03,90.03 21.75,89.75 21.75,89.23 22.17,88.81 22.17,84.88 21.7,84.41 21.7,79.57 21.46,79.34 21.46,76.58 22.47,75.57 22.47,67.57 23.92,66.13 26.65,66.13 29.02,63.76 29.02,58.85 32.24,55.63 36.49,55.63 38.18,53.95 38.78,53.95 39.8,52.93 39.94,52.93 43.64,49.22 43.64,48.6 45.06,47.18 48.61,47.18 53.18,42.61 53.18,40.31 53.6,39.88 53.6,38.22 53.91,37.91 53.91,36.64 55.13,35.43 55.13,31.18 55.56,30.75 55.56,29.17 56.9,27.83 58.91,27.83 59.94,26.81 60.61,26.81 62.67,24.75 62.67,21.51 64.15,20.02 64.15,19.72 66.99,16.89 79.47,16.89 82.16,14.2 85.46,14.2 87.22,12.44 87.22,12.08 88.94,10.36 91.22,10.36 91.61,9.97 94.02,7.56 122.5,7.56 122.99,8.05 128.85,8.05 130.1,6.8 133.73,6.8 134.61,7.68 151.7,7.68 156.15,12.13 168.87,12.13 170.9,10.1 176.59,10.1 178.16,8.53 188.88,8.53 189.98,7.43 198.11,7.43 198.44,7.76 202.5,7.76 203.28,8.54 205,8.54 205.21,8.34 208.18,8.34 211.24,11.4 214.96,11.4 219.86,16.3 219.86,17.39 219.39,17.85 218.9,17.85 218.65,18.1 218.65,21.31 218.41,21.55 218.41,29.05 222.04,32.68 222.04,37.18 221.47,37.74 219.84,37.74 216.97,40.62 211.61,40.62 210.77,39.79 210.77,38.32 210.94,38.16 210.94,37.82 211,37.76 211,37.54 v2(210.98,37.52)
  BOTTOM w0.089: v2(210.98,37.52) UH1.F7
  BOTTOM w0.127: v2(22.7,90.23) 22.47,90 22.27,90 CS29.2
USB3_PTX_DRX_P2: length 105.4
  IN1 w0.135: v2(303.57,36.73) 303.46,36.84 303.46,37.32 302.19,38.58 293.13,38.58 292.6,38.05 288.77,38.05 288.09,37.37 279.35,37.37 278.79,36.81 274.25,36.81 273.83,37.22 267.86,37.22 267.53,36.89 259.76,36.89 259.16,37.49 255.92,37.49 255.33,38.08 254.74,38.08 254.45,38.37 253.83,38.37 253.12,39.08 251.96,39.08 251.06,39.98 248.49,39.98 248.05,39.54 244.82,39.54 243.68,38.4 238.57,38.4 238.23,38.73 237.65,38.73 237.3,38.38 233.82,38.38 232.97,37.53 229.19,37.53 229.04,37.38 220.25,37.38 218.17,39.45 216.09,39.45 215.8,39.16 214.5,39.16 214.1,39.56 213.09,39.56 212.72,39.19 212.65,38.84 v2(212.48,38.73)
  BOTTOM w0.089: UH1.D4 212.92,39.14 212.71,39.14 212.65,39.09 212.58,39.02 212.52,39.02 212.44,38.94 212.44,38.77 v2(212.48,38.73)
  BOTTOM w0.127: v2(303.57,36.73) 303.61,36.77 303.61,37.03 303.51,37.13 303.32,37.13 303.25,37.2 303.25,37.74 303.11,37.87 303.11,38.26 303.39,38.54 303.78,38.54 305.12,39.88 305.12,40.53 305.58,40.99 305.9,40.99 305.97,40.92 305.97,40.82 306.05,40.75 JIO1.11
USB3_PTX_DRX_P3: length 109.8
  IN1 w0.135: v2(304.14,37.71) 304.22,37.79 304.69,37.79 304.98,38.07 304.98,38.6 304.04,39.54 292.82,39.54 292.12,38.83 288.54,38.83 287.89,38.18 279.14,38.18 278.49,37.52 274.67,37.52 274.25,37.94 267.56,37.94 267.23,37.61 260.1,37.61 259.14,38.58 257.29,38.58 257.06,38.8 255.04,38.8 254.75,39.09 254.13,39.09 252.95,40.27 252.47,40.27 252.04,40.7 248.09,40.7 247.66,40.27 243.69,40.27 243.18,39.76 243.18,39.41 242.88,39.11 238.86,39.11 238.53,39.45 237.04,39.45 236.69,39.1 233.53,39.1 232.67,38.25 221.06,38.25 218.72,40.59 212.82,40.59 212.64,40.78 210.87,40.78 208.8,38.71 208.8,37.59 209.2,37.19 209.79,37.19 v2(209.85,37.13)
  BOTTOM w0.127: UH1.G12 209.09,37.13 v2(209.85,37.13) ; JIO1.17 306.11,37.75 306,37.87 v4(305.03,37.87) 304.3,37.87 v2(304.14,37.71)
USB3_PTX_MRX_N4: length 277.3
  TOP w0.127: CT288.2 33.44,45.15 33.44,44.86 33.66,44.64 34.54,44.64 v4(34.82,44.92) 35.08,45.19 35.08,46.41 34.54,46.95 34.54,47.97 v2(34.66,48.09)
  IN3 w0.127: v2(34.66,48.09) 34.5,48.26 34.5,48.59 34.62,48.71 36.08,48.71 39.16,45.63 39.48,45.63 40.48,44.63 40.48,43.84 42.64,41.69 42.64,40.87 44.48,39.03 49.64,39.03 51.67,37 51.67,35.73 52.9,34.5 52.9,31.69 52.61,31.4 52.61,28.86 56.32,25.15 56.32,24.7 56.84,24.18 57.21,24.18 58.58,22.81 59.31,22.81 60.02,22.11 60.02,20.87 61.36,19.52 61.36,18.62 65.74,14.24 72.47,14.24 73.65,13.06 78.15,13.06 79.66,11.55 81.33,11.55 83.61,9.27 86.59,9.27 88.01,7.85 88.44,7.85 90.96,5.33 135.53,5.33 136.51,6.3 153.06,6.3 154.83,8.08 154.83,8.86 156.72,10.75 167.53,10.75 170.47,7.82 176.52,7.82 178.51,5.83 213.72,5.83 214.92,7.03 214.92,8.42 215.91,9.42 217.08,9.42 218.39,10.73 218.39,11.14 219.99,12.73 221.45,12.73 222.1,13.38 222.1,16.03 221.24,16.9 221.24,29.93 223.82,32.51 223.82,34.94 223.41,35.34 223.41,38.7 217.9,44.21 209.51,44.21 207.57,42.27 207.57,41.18 207.46,41.07 v2(207.02,41.07)
  BOTTOM w0.102: v2(207.02,41.07) 207.02,41 207.18,40.83 207.5,40.83 207.75,40.58 207.75,40.09 207.87,39.97 207.87,39.79 207.94,39.72 208.02,39.72 UH1.B14
USB3_PTX_MRX_P4: length 276.6
  TOP w0.127: CT287.2 33.69,45.1 33.69,44.97 33.77,44.89 34.43,44.89 34.83,45.29 34.83,46.3 v4(34.56,46.57) 34.28,46.85 34.28,47.91 34.1,48.09 v2(33.95,48.09)
  IN3 w0.127: v2(33.95,48.09) 34.18,48.09 34.24,48.16 34.24,48.7 34.51,48.96 36.18,48.96 39.26,45.88 39.59,45.88 40.74,44.73 40.74,43.95 42.89,41.79 42.89,40.98 44.59,39.28 49.75,39.28 51.92,37.11 51.92,35.84 53.15,34.61 53.15,31.58 52.87,31.3 52.87,28.97 56.58,25.26 56.58,24.8 56.94,24.44 57.32,24.44 58.69,23.07 59.42,23.07 60.27,22.21 60.27,20.97 61.62,19.63 61.62,18.73 65.84,14.5 72.57,14.5 73.75,13.32 78.25,13.32 79.76,11.81 81.44,11.81 83.71,9.53 86.69,9.53 88.12,8.11 88.54,8.11 91.06,5.59 135.43,5.59 136.4,6.56 152.95,6.56 154.58,8.18 154.58,8.97 156.61,11.01 167.64,11.01 170.57,8.07 176.62,8.07 178.61,6.08 213.61,6.08 214.66,7.14 214.66,8.53 215.81,9.68 216.97,9.68 218.14,10.84 218.14,11.24 219.88,12.99 221.34,12.99 221.84,13.49 221.84,15.93 220.98,16.79 220.98,30.04 223.56,32.62 223.56,34.83 223.16,35.24 223.16,38.59 217.8,43.95 210.89,43.95 210.74,43.8 210.26,43.8 210.1,43.95 209.62,43.95 207.83,42.17 207.83,41.07 207.57,40.81 207.39,40.81 207.06,40.48 v2(207.02,40.48)
  BOTTOM w0.102: UH1.C14 207.67,39.7 207.67,39.89 207.55,40.01 207.55,40.5 207.41,40.63 207.16,40.63 v2(207.02,40.48)
USB3_PTX_R_DRX_N1: length 9
  BOTTOM w0.127: JUSB3.8 13.2,91.41 13.49,91.7 13.82,91.7 14.24,91.27 15.17,91.27 15.33,91.42 16.09,91.42 16.46,91.05 16.46,90.82 16.3,90.66 16.3,90.19 v4(16.56,89.93) 16.84,89.66 17.36,89.66 17.48,89.53 DS6.4 DS6.7 18.9,89.53 19.05,89.69 19.55,89.69 RS27.2
USB3_PTX_R_DRX_P1: length 9.1
  BOTTOM w0.127: RS28.2 19.44,89.95 19.03,89.95 18.94,90.03 DS6.6 DS6.5 17.46,90.03 17.34,89.91 16.94,89.91 16.55,90.3 16.55,90.55 16.72,90.71 16.72,91.16 v4(16.46,91.41) 16.2,91.68 15.22,91.68 15.07,91.53 14.35,91.53 13.92,91.95 13.55,91.95 13.2,92.31 JUSB3.9
USB20_N1: length 269.9
  IN3 w0.127: v2(214.78,37.67) 214.99,37.47 214.99,34.58 215.37,34.2 215.37,32.16 216,31.52 216,27.86 215.63,27.48 214.57,27.48 213.8,26.72 213.8,23.16 213.55,22.91 213.55,20.73 214.04,20.24 214.04,19.11 212.44,17.51 212.14,17.51 210.73,16.1 210.73,15.25 208.79,13.31 205.28,13.31 203.58,11.61 202.95,11.61 201.94,10.6 191.46,10.6 191.14,10.93 179.15,10.93 177.48,12.6 173.9,12.6 171.93,14.57 155.2,14.57 153.42,12.79 152.4,12.79 150.14,10.53 135.33,10.53 134.98,10.88 117.66,10.88 117.37,10.59 114.73,10.59 114.61,10.71 109.19,10.71 108.44,9.96 99.96,9.96 99.09,10.82 95.13,10.82 89.32,16.64 83.16,16.64 80.47,19.34 73.19,19.34 70.08,22.45 67.74,22.45 66.95,23.24 66.95,24.89 64.31,27.53 63.65,27.53 61.2,29.98 58.56,29.98 57.37,31.17 57.37,35.67 56.18,36.87 56.18,41.31 55.9,41.59 55.9,43.51 54.43,44.98 53.23,44.98 48.99,49.22 48.06,49.22 47.19,50.09 44.22,50.09 40.36,53.95 40.23,53.95 39.2,54.97 38.6,54.97 36.92,56.65 33.82,56.65 32.9,57.57 32.9,58.72 30.55,61.07 30.55,63.68 28.24,65.99 28.24,68.01 25.38,70.87 25.38,73.41 24.91,73.87 24.91,74.22 24.81,74.32 v2(24.52,74.32)
  BOTTOM w0.089: UH1.J3 213.31,36.38 213.57,36.63 214.27,36.63 214.86,37.22 214.86,37.59 v2(214.78,37.67)
  BOTTOM w0.127: US2.2 20.03,78.16 19.78,77.92 19.78,74.58 20.31,74.06 20.33,74.04 20.89,73.48 23.46,73.48 23.85,73.86 24.16,73.86 24.25,73.95 24.25,74.19 24.37,74.32 v2(24.52,74.32)
USB20_N1_C: length 11.8
  TOP w0.127: LS9.3 20.39,86.5 20.39,87.31 20.02,87.68 20.02,88 18.92,89.1 18.61,89.1 18.44,89.27 DS5.2 17.61,88.93 17.43,88.93 17.36,89.01 17.36,89.72 17.07,90.01 16.7,90.01 v4(16.44,89.75) 16.13,89.44 16.13,89.09 16.38,88.84 16.38,88.57 16.28,88.47 15.65,88.47 15.18,88.93 14.92,88.93 14.7,89.15 JUSB3.2
USB20_N2: length 111.3
  IN1 w0.076: v2(207.83,35.09) 207.6,35.09 207.47,34.96 207.47,34.75 207.58,34.64 210.23,34.64 210.33,34.54 210.57,34.54 210.63,34.59 210.65,34.59
  IN1 w0.135: 210.65,34.59 212.03,34.59 212.69,33.93 213.05,33.93 214.27,32.71 215.7,32.71 217.32,31.09 220.38,31.09 221.8,32.51 221.8,33.52 222.94,34.66 229.48,34.66 230.11,35.3 233.9,35.3 234.75,36.15 251.21,36.15 251.64,35.72 253.77,35.72 254.17,35.31 254.92,35.31 258.49,31.74 265.09,31.74 267.02,29.81 276.3,29.81 276.58,29.53 291,29.53 294.54,33.07 301.12,33.07 301.3,33.25 301.3,33.66 301.14,33.81 300.85,33.81 v2(300.7,33.66)
  BOTTOM w0.089: UH1.N13 v2(207.83,35.09)
  BOTTOM w0.127: v2(300.7,33.66) 300.85,33.81 302.31,33.81 303.4,34.89 306.01,34.89 306.15,34.75 JIO1.23
USB20_N3: length 103.3
  IN1 w0.135: v2(215.92,37.9) 216.06,38.03 216.06,38.3 216.42,38.66 217.61,38.66 219.82,36.44 229.23,36.44 229.52,36.73 233.3,36.73 234.15,37.59 244.06,37.59 244.64,38.17 245.66,38.17 246.14,37.69 251.71,37.69 252.24,37.16 255.13,37.16 255.59,36.69 257.61,36.69 258.21,36.09 267.86,36.09 268.19,36.43 273.39,36.43 273.81,36.01 279.12,36.01 279.6,36.49 288.43,36.49 289.14,37.21 300.87,37.21 303.22,34.86 304.93,34.86 305.29,34.49 305.29,33.65 305,33.36 304.61,33.36 v2(304.46,33.21)
  BOTTOM w0.089: UH1.K4 212.6,35.8 212.9,36.09 213.3,36.09 213.41,35.98 214.18,35.98 215,36.8 215.33,36.8 216.07,37.55 216.07,37.75 v2(215.92,37.9)
  BOTTOM w0.127: JIO1.26 306.31,33.25 306.07,33.49 304.75,33.49 v2(304.46,33.21)
USB20_N4: length 279.7
  TOP w0.127: ML11.4 18.14,49.46 18.26,49.34 19.97,49.34 20.41,49.78 20.76,49.78 v2(20.98,50) ; v2(44.98,48.39) 44.91,48.39 44.82,48.29 44.82,48.15 45.12,47.85 45.27,47.85 45.37,47.96 45.61,47.96 45.69,47.87 45.69,47.65 45.54,47.5 UU4.53
  IN1 w0.135: v2(20.98,50) 20.98,49.85 21.05,49.79 21.37,49.79 21.51,49.92 21.51,52.34 23.36,54.19 24.07,54.19 25.02,55.14 34.37,55.14 36.67,52.84 37.29,52.84 38.66,52.38 38.84,52.47 39.23,52.34 39.32,52.15 39.72,52.02 42.37,50.21 42.76,49.82 42.96,49.82 43.25,49.54 43.25,49.33 43.54,49.05 43.74,49.05 44.03,48.76 44.03,48.56 44.66,47.92 45.03,47.92 45.15,48.04 45.15,48.22 v2(44.98,48.39)
  IN3 w0.127: v2(209.68,35.42) 209.81,35.55 210.36,35.55 210.38,35.57 211.23,35.57 211.43,35.77 212.84,35.77 214.03,36.96 214.03,37.75 214.92,38.64 217.42,38.64 218.1,37.96 218.1,32.26 217.38,31.54 217.38,23.15 216.23,22 216.23,20.81 217.43,19.61 217.43,17.87 218.05,17.25 218.05,15.94 215.38,13.27 211.66,13.27 207.75,9.36 205.91,9.36 205.64,9.62 202.91,9.62 202.07,8.79 198.02,8.79 197.69,8.45 193.06,8.45 192.33,9.18 190.93,9.18 190.56,9.55 178.58,9.55 177.01,11.12 171.63,11.12 169.55,13.2 155.77,13.2 151.28,8.7 133.84,8.7 133.47,9.07 124.97,9.07 124.62,9.42 122.84,9.42 122,8.58 95.27,8.58 92.96,10.9 92.89,10.97 92.12,11.74 89.27,11.74 88.83,12.18 88.83,12.97 86.59,15.22 82.59,15.22 79.88,17.93 67.4,17.93 65.67,19.66 65.67,19.95 63.96,21.66 63.96,22.59 64.22,22.85 64.22,25.86 61.19,28.89 57.68,28.89 56.67,29.9 56.67,31.11 56.27,31.52 56.27,34.44 56.17,34.54 56.17,35.91 54.94,37.13 54.94,38.37 54.69,38.62 54.69,42.54 49.03,48.2 47.29,48.2 46.35,49.14 45.41,49.14 45.14,48.87 45.14,48.54 v2(44.98,48.39)
  BOTTOM w0.089: UH1.M10 v2(209.68,35.42)
USB20_N4_L: length 20.6
  TOP w0.127: v2(9.84,51.87) 9.93,51.78 10.04,51.78 10.16,51.91 10.16,52.13 9.96,52.33 7.94,52.33 7.8,52.19 JUSBC1.A7 ; ML11.3 17.12,49.33 16.28,49.33 16.17,49.44 DU3.5 DU3.6 14.36,49.44 14.22,49.3 13.6,49.3 v2(13.36,49.54)
  IN1 w0.135: JUSBC1.B7 6.8,52.84 6.87,52.77 6.87,52.52 6.97,52.43 7.4,52.43 7.96,51.87 7.96,51.09 8.5,50.54 9.65,50.54 10.27,51.16 10.27,51.44 v2(9.84,51.87) 9.98,52.01 9.98,52.3 10.32,52.65 11.23,52.65 12.02,51.86 12.02,50.19 12.81,49.4 13.22,49.4 v2(13.36,49.54)
USB20_N5: length 191.1
  IN3 w0.127: v2(216.54,37.13) 216.75,37.34 216.85,37.34 216.97,37.22 216.97,35.37 217.1,35.24 217.1,32.25 216.69,31.84 216.69,25.73 215.5,24.53 215.5,17.98 216.74,16.73 216.74,16.25 214.86,14.36 210.82,14.36 209.07,12.62 208.09,12.62 206.35,10.88 203.2,10.88 202.19,9.88 191.21,9.88 190.85,10.24 178.87,10.24 177.25,11.85 173.68,11.85 171.64,13.89 155.49,13.89 153.69,12.09 152.79,12.09 150.09,9.39 134.17,9.39 133.8,9.76 125.8,9.76 125.38,10.19 118.31,10.19 117.96,9.83 114.9,9.83 114.33,9.27 112.23,9.27 111.48,10.02 109.47,10.02 108.72,9.27 99.48,9.27 98.67,10.08 94.88,10.08 89.01,15.95 82.87,15.95 80.17,18.64 71.02,18.64 69.8,19.86 69.8,21 70.05,21.26 v2(70.16,21.26)
  BOTTOM w0.089: UH1.M1 214.21,35.2 214.12,35.11 214.12,35.03 214.24,34.91 214.46,34.91 214.71,35.16 214.71,35.65 215.37,36.31 215.56,36.31 215.94,36.69 216.92,36.69 216.99,36.76 216.99,37.28 216.9,37.37 216.76,37.37 216.54,37.14 v2(216.54,37.13)
  BOTTOM w0.127: L1.1 68.59,22.65 68.59,22.55 68.81,22.33 69.22,22.33 69.85,21.7 69.85,21.47 70.07,21.26 v2(70.16,21.26)
USB20_N5_R: length 11.9
  BOTTOM w0.127: L1.2 68.57,23.51 68.57,25.77 69.4,26.6 69.4,27.03 69.53,27.15 D507.3 69.4,27.99 69.4,28.29 68.88,28.82 v4(68.39,28.82) 67.8,28.82 67.56,29.06 66.65,29.06 66.35,29.35 65.56,29.35 65.43,29.48 65.43,29.66 65.55,29.78 JEDP1.10
USB20_N6: length 1.7
  TOP w0.127: v2(211.3,36.47) 211.3,37.01 TH146.1
  BOTTOM w0.089: UH1.K7 v2(211.3,36.47)
USB20_N9: length 2.1
  TOP w0.127: v2(211.8,35.3) 213.2,35.3 TH148.1
  BOTTOM w0.089: UH1.M6 v2(211.8,35.3)
USB20_N14: length 119.5
  IN1 w0.076: v2(211.63,38.35) 211.61,37.94 211.48,37.82 211.48,37.46 211.7,37.25 212.47,37.25 212.62,37.4 213.17,37.4 213.21,37.35 213.23,37.35
  IN1 w0.135: v2(309.47,28.5) 309.31,28.66 308.96,28.66 308.58,29.04 308.58,31.85 308.02,32.41 303.83,32.41 301.51,34.73 299.63,34.73 298.6,33.69 294.54,33.69 292.04,31.19 279.89,31.19 279.8,31.28 275.73,31.28 274.82,30.36 267.85,30.36 266.03,32.18 258.67,32.18 254.7,36.16 251.83,36.16 251.4,36.59 234.57,36.59 233.71,35.74 229.93,35.74 229.43,35.23 218.56,35.23 218.06,35.74 215.16,35.74 213.54,37.35 213.23,37.35
  BOTTOM w0.089: v2(211.63,38.35) UH1.E5
  BOTTOM w0.127: v2(309.47,28.5) 309.3,28.68 308.92,28.68 308.82,28.57 308.82,27.83 308.15,27.16 307.14,27.16 305.42,25.44 305.42,24.59 304.5,23.67 303.61,23.67 303.54,23.6 JWLAN1.5
USB20_P1: length 269.9
  IN3 w0.127: v2(215.37,37.67) 215.24,37.55 215.24,34.69 215.63,34.3 215.63,32.26 216.26,31.63 216.26,27.75 215.73,27.23 214.67,27.23 214.06,26.61 214.06,23.06 213.81,22.8 213.81,20.84 214.3,20.35 214.3,19.01 212.54,17.25 212.24,17.25 210.99,15.99 210.99,15.14 208.89,13.05 205.38,13.05 203.69,11.36 203.06,11.36 202.05,10.34 191.35,10.34 191.03,10.67 179.05,10.67 177.37,12.34 173.79,12.34 171.82,14.32 155.31,14.32 153.52,12.53 152.51,12.53 150.25,10.27 135.22,10.27 134.87,10.62 117.76,10.62 117.48,10.33 114.63,10.33 114.51,10.45 109.29,10.45 108.54,9.7 99.85,9.7 98.99,10.57 95.03,10.57 89.21,16.38 83.06,16.38 80.36,19.08 73.09,19.08 69.97,22.2 67.63,22.2 66.69,23.13 66.69,24.78 64.2,27.27 63.54,27.27 61.09,29.73 58.45,29.73 57.12,31.06 57.12,35.57 55.93,36.76 55.93,41.2 55.65,41.48 55.65,43.4 54.32,44.72 53.12,44.72 48.88,48.96 47.95,48.96 47.09,49.83 44.12,49.83 40.25,53.69 40.12,53.69 39.09,54.72 38.49,54.72 36.81,56.4 33.71,56.4 32.64,57.47 32.64,58.61 30.29,60.96 30.29,63.57 27.98,65.88 27.98,67.9 25.12,70.76 25.12,73.3 24.8,73.62 24.54,73.62 v2(24.52,73.61)
  BOTTOM w0.089: v2(215.37,37.67) 215.29,37.67 215.05,37.43 215.05,37.15 214.35,36.44 213.65,36.44 213.6,36.4 UH1.J2
  BOTTOM w0.127: v2(24.52,73.61) 23.95,73.61 23.57,73.22 20.78,73.22 v4(20.13,73.88) 19.53,74.48 US2.3
USB20_P1_C: length 11.7
  TOP w0.127: JUSB3.3 14.7,88.45 14.92,88.68 15.08,88.68 15.54,88.21 v4(15.97,88.21) 16.39,88.21 16.64,88.46 16.64,88.95 16.39,89.2 16.39,89.33 16.81,89.75 16.96,89.75 17.1,89.61 17.1,88.9 17.32,88.68 17.59,88.68 DS5.3 18.44,88.72 18.56,88.84 18.81,88.84 19.76,87.89 19.76,87.58 20.13,87.21 20.13,86.66 19.96,86.49 LS9.2
USB20_P2: length 111.3
  IN1 w0.076: 210.65,34.31 210.63,34.31 210.57,34.37 210.27,34.37 210.16,34.47 208.1,34.47 208.08,34.45 207.89,34.26 v2(207.84,34.21)
  IN1 w0.135: v2(300.7,34.24) 300.85,34.09 301.26,34.09 301.58,33.77 301.58,33.13 301.24,32.79 294.66,32.79 291.11,29.25 276.47,29.25 276.18,29.53 266.9,29.53 264.97,31.47 258.37,31.47 254.81,35.03 254.06,35.03 253.65,35.44 251.53,35.44 251.1,35.87 234.86,35.87 234.01,35.02 230.23,35.02 229.6,34.38 223.05,34.38 222.07,33.41 222.07,32.39 220.49,30.81 217.2,30.81 215.58,32.43 214.16,32.43 212.93,33.65 212.58,33.65 211.92,34.31 210.65,34.31
  BOTTOM w0.089: v2(207.84,34.21) 207.82,34.4 207.61,34.56 UH1.N15
  BOTTOM w0.127: JIO1.22 306.15,35.25 306.04,35.15 303.29,35.15 302.21,34.07 300.88,34.07 v2(300.7,34.24)
USB20_P3: length 103.3
  IN1 w0.135: v2(216.51,37.9) 216.49,37.9 216.34,38.05 216.34,38.19 216.53,38.38 217.49,38.38 218.09,37.78 218.09,37.58 218.37,37.29 218.58,37.29 218.86,37.01 218.86,36.8 219.15,36.52 219.35,36.52 219.71,36.16 220.11,36.16 220.26,36.02 220.66,36.02 220.81,36.16 221.21,36.16 221.35,36.02 221.76,36.02 221.9,36.16 222.31,36.16 222.45,36.02 222.86,36.02 223,36.16 223.4,36.16 223.55,36.02 223.95,36.02 224.1,36.16 224.5,36.16 224.65,36.02 225.05,36.02 225.19,36.16 229.34,36.16 229.63,36.45 233.42,36.45 234.27,37.31 244.18,37.31 244.76,37.89 245.54,37.89 246.02,37.41 251.59,37.41 252.12,36.88 255.01,36.88 255.47,36.41 257.5,36.41 258.09,35.82 267.97,35.82 268.31,36.15 273.27,36.15 273.69,35.73 279.23,35.73 279.71,36.21 288.55,36.21 289.26,36.93 300.76,36.93 303.11,34.58 304.81,34.58 305.01,34.38 305.01,33.77 304.89,33.64 304.4,33.64 304.3,33.74 304.3,33.88 v2(304.46,34.05)
  BOTTOM w0.089: UH1.K3 213.12,35.66 213.16,35.61 213.31,35.61 213.49,35.79 214.25,35.79 215.08,36.61 215.41,36.61 216.26,37.47 216.26,37.77 216.4,37.9 v2(216.51,37.9)
  BOTTOM w0.127: JIO1.25 304.6,33.75 304.46,33.88 v2(304.46,34.05)
USB20_P4: length 279.7
  TOP w0.127: v2(45.57,48.37) 45.64,48.44 46.25,48.44 46.74,47.94 UU4.50 ; ML11.1 18.14,48.96 18.26,49.08 20.08,49.08 20.51,49.52 20.76,49.52 v2(20.98,49.29)
  IN1 w0.135: v2(45.57,48.37) 45.43,48.23 45.43,47.93 45.15,47.65 44.54,47.65 42.19,49.99 39.59,51.76 37.25,52.56 36.55,52.56 34.26,54.86 25.13,54.86 24.19,53.91 23.47,53.91 21.78,52.23 21.78,49.81 21.48,49.51 21.2,49.51 v2(20.98,49.29)
  IN3 w0.127: v2(210.14,35.98) 210.29,35.83 211.13,35.83 211.32,36.03 212.73,36.03 213.77,37.07 213.77,37.86 214.81,38.9 217.52,38.9 218.35,38.07 218.35,32.15 217.64,31.44 217.64,23.05 216.49,21.9 216.49,20.92 217.69,19.72 217.69,17.98 218.31,17.36 218.31,15.84 215.48,13.01 211.77,13.01 207.86,9.1 205.8,9.1 205.54,9.37 203.02,9.37 202.18,8.53 198.13,8.53 197.8,8.2 192.95,8.2 192.23,8.92 190.83,8.92 190.46,9.29 178.47,9.29 176.91,10.86 171.53,10.86 169.44,12.94 155.88,12.94 151.38,8.44 133.74,8.44 133.37,8.82 124.86,8.82 124.51,9.17 122.95,9.17 122.11,8.32 95.17,8.32 92.85,10.64 92.74,10.75 92.01,11.48 89.17,11.48 88.58,12.07 88.58,12.87 86.48,14.96 82.49,14.96 79.78,17.67 67.3,17.67 65.42,19.55 65.42,19.84 63.7,21.56 63.7,22.69 63.96,22.96 63.96,25.75 61.08,28.63 57.58,28.63 56.42,29.79 56.42,31 56.01,31.41 56.01,34.33 55.91,34.43 55.91,35.8 54.69,37.02 54.69,38.26 54.44,38.52 54.44,42.43 48.93,47.94 47.18,47.94 46.24,48.88 45.51,48.88 45.4,48.76 45.4,48.54 v2(45.57,48.37)
  BOTTOM w0.089: UH1.L9 v2(210.14,35.98)
USB20_P4_L: length 20.6
  TOP w0.127: ML11.2 17.14,49.07 16.28,49.07 16.15,48.94 DU3.4 DU3.7 14.33,48.94 14.22,49.05 13.58,49.05 v2(13.36,48.83) ; JUSBC1.A6 7.8,52.69 7.91,52.58 10.07,52.58 10.42,52.23 10.42,52.01 v2(10.55,51.87)
  IN1 w0.135: v2(13.36,48.83) 13.43,48.9 13.43,48.99 13.3,49.12 12.69,49.12 11.74,50.07 11.74,51.75 11.12,52.37 10.44,52.37 10.26,52.19 10.26,51.97 10.35,51.87 v2(10.55,51.87) 10.55,51.05 9.77,50.26 8.39,50.26 7.68,50.97 7.68,51.75 7.28,52.15 6.5,52.15 JUSBC1.B6
USB20_P5: length 191.1
  IN3 w0.127: v2(69.45,21.26) 69.54,21.17 69.54,20.82 69.54,19.76 70.91,18.39 80.07,18.39 82.76,15.69 88.9,15.69 94.77,9.82 98.57,9.82 99.37,9.01 108.83,9.01 109.58,9.76 111.37,9.76 112.12,9.01 114.44,9.01 115,9.58 118.07,9.58 118.42,9.93 125.27,9.93 125.7,9.5 133.69,9.5 134.07,9.13 150.2,9.13 152.9,11.83 153.8,11.83 155.6,13.63 171.53,13.63 173.57,11.6 177.15,11.6 178.76,9.98 190.74,9.98 191.1,9.63 202.3,9.63 203.3,10.63 206.46,10.63 208.19,12.36 209.18,12.36 210.92,14.11 214.97,14.11 217,16.14 217,16.84 215.76,18.08 215.76,24.43 216.95,25.62 216.95,31.73 217.36,32.14 217.36,35.34 217.23,35.48 217.23,36.96 v2(217.4,37.13)
  BOTTOM w0.089: UH1.L2 213.93,35.25 213.93,35.25 213.93,34.95 214.16,34.72 214.54,34.72 214.9,35.08 214.9,35.57 215.45,36.12 215.64,36.12 216.02,36.5 217,36.5 217.18,36.68 217.18,36.92 v2(217.4,37.13)
  BOTTOM w0.127: L1.4 68.34,22.65 68.34,22.44 68.71,22.07 69.11,22.07 69.6,21.59 69.6,21.4 v2(69.45,21.26)
USB20_P5_R: length 11.9
  BOTTOM w0.127: JEDP1.9 65.05,29.76 65.17,29.63 65.17,29.37 65.45,29.09 66.25,29.09 66.54,28.8 v4(67.05,28.8) 67.46,28.8 67.7,28.56 68.77,28.56 69.15,28.19 69.15,27.99 D507.2 69.02,27.15 69.15,27.03 69.15,26.71 68.32,25.88 68.32,23.47 L1.3
USB20_P6: length 1.2
  TOP w0.127: TH145.1 211.93,36.4 v2(211.93,36.64)
  BOTTOM w0.089: UH1.K6 v2(211.93,36.64)
USB20_P9: length 1.1
  TOP w0.127: v2(211.01,35.11) 211.03,35.13 211.03,35.57 211.02,35.58 TH147.1
  BOTTOM w0.089: UH1.N8 v2(211.01,35.11)
USB20_P14: length 119.5
  IN1 w0.076: v2(212.13,37.81) 212.01,37.93 211.84,37.93 211.64,37.75 211.64,37.53 211.76,37.41 212.4,37.41 212.55,37.56 213.17,37.56 213.21,37.61 213.23,37.61
  IN1 w0.135: v2(309.47,29.21) 309.47,29.08 309.33,28.94 309.08,28.94 308.86,29.16 308.86,31.97 308.14,32.69 303.95,32.69 301.63,35.01 299.52,35.01 298.48,33.97 294.43,33.97 291.92,31.47 280,31.47 279.91,31.56 275.62,31.56 274.7,30.64 267.96,30.64 266.14,32.46 258.79,32.46 254.81,36.44 251.94,36.44 251.51,36.87 234.45,36.87 233.6,36.01 229.82,36.01 229.31,35.51 218.68,35.51 218.17,36.01 215.28,36.01 213.68,37.61 213.23,37.61
  BOTTOM w0.089: v2(212.13,37.81) UH1.F6
  BOTTOM w0.127: JWLAN1.3 303.54,24.1 303.72,23.92 304.39,23.92 305.16,24.7 305.16,25.55 307.03,27.42 308.05,27.42 308.56,27.93 308.56,28.68 308.82,28.93 309.35,28.93 309.47,29.06 v2(309.47,29.21)
USB_CHARGE_EN: length 189.9
  TOP w0.127: UK1.36 150.35,11.02 149.77,11.59 v2(149.77,11.86)
  IN2 w0.127: v2(149.77,11.86) 149.36,12.28 146.23,12.28 145.64,11.69 135.61,11.69 135.1,12.2 132.24,12.2 131.83,12.61 126.67,12.61 125.28,11.23 117.26,11.23 116.7,11.78 109.38,11.78 109.15,12.01 101.46,12.01 98.31,15.16 90.8,15.16 90.45,14.82 76.48,14.82 74.38,16.91 65.72,16.91 59.76,22.87 58.74,22.87 58.3,23.31 58.3,23.46 53.2,28.55 53.2,34.71 52.01,35.9 52.01,37 51.45,37.55 46.84,37.55 46.15,38.25 42.27,38.25 41.74,38.78 39.75,38.78 38.08,40.44 38.08,42.96 35.46,45.58 34.33,45.58 33.12,46.79 31.58,46.79 29.91,48.46 24.03,48.46 19.32,53.16 16.42,53.16 12.48,57.11 12.48,60.9 15.59,64.01 15.59,66.72 15.79,66.92 15.79,69.06 15.59,69.25 15.59,74.91 14.89,75.61 v2(14.89,77.62)
  BOTTOM w0.127: v2(14.89,77.62) 15.23,77.62 v1(15.63,78.01) 15.96,78.34 RS16.1
USB_CHARGE_EN_R: length 4.1
  BOTTOM w0.127: v3(16.27,76.64) 16.87,77.24 RS16.2 17.42,79.44 US2.5
USB_CTL1: length 186.1
  TOP w0.127: v2(141.71,21.11) 142.3,21.69 142.3,22.65 142.04,22.91 UK1.84 ; v2(59.57,25.09) v3(59.57,24.52)
  IN1 w0.127: v2(15.27,79.14) 16.1,78.3 16.1,75.01 17.02,74.1 17.02,64.6 19.68,61.94 19.68,48.75 21.22,47.21 26.79,47.21 27.53,46.46 27.92,46.46 28.39,46 31.56,46 31.71,46.15 34.77,46.15 37.65,43.27 37.65,37.47 39.38,35.74 42.38,35.74 42.97,35.15 47.67,35.15 48.18,35.66 48.95,35.66 49.28,35.32 49.28,34.4 49.69,34 49.69,32.3 51.4,30.59 51.4,29.5 56.37,24.53 59.33,24.53 59.59,24.79 59.59,25.06 v2(59.57,25.09)
  IN2 w0.127: v2(59.57,25.09) 60.41,25.09 60.63,25.3 62.07,25.3 64.03,27.26 81.57,27.26 81.97,26.85 81.97,25.88 83.72,24.13 87.6,24.13 90.78,20.94 94.7,20.94 95.01,21.26 95.58,21.26 95.9,20.94 97.58,20.94 99.88,23.24 109.17,23.24 112.24,20.17 117.05,20.17 117.32,19.9 119.25,19.9 119.91,20.56 123.54,20.56 123.82,20.84 129.97,20.84 130.21,21.08 132.02,21.08 132.99,20.11 135.75,20.11 136.56,20.91 138.34,20.91 138.96,21.53 141.28,21.53 v2(141.71,21.11)
  BOTTOM w0.127: US2.6 17.38,79.94 17.22,79.78 RS41.2 16.44,79.35 16.33,79.35 16.31,79.33 15.5,79.33 15.31,79.14 v2(15.27,79.14)
USB_CTL2: length 212.2
  TOP w0.127: v2(115.52,11.07) 115.52,11.52 v3(114.79,12.25) 114.28,12.76 114.28,13.87 115.1,14.68 115.1,15.87 114.28,16.68 114.28,19.1 115.66,20.48 115.66,23.53 v2(115.18,24.01) ; v2(146.84,22.45) UK1.72
  IN2 w0.127: v2(115.52,11.07) 115.4,10.95 109,10.95 108.19,10.14 105.86,10.14 104.78,11.22 101.4,11.22 98.06,14.56 95.59,14.56 94.57,13.55 92.7,13.55 92.22,14.03 81.81,14.03 81.61,14.22 76.22,14.22 74.14,16.31 65.18,16.31 61.22,20.27 58.47,20.27 57.89,20.85 57.89,21.27 57.04,22.12 56.04,22.12 55.33,22.83 55.33,25.66 52.46,28.53 52.46,31.64 52.66,31.85 52.66,34.49 51.41,35.74 51.41,35.95 50.85,36.51 49.83,36.51 49.51,36.19 48.85,36.19 48.02,37.02 46.62,37.02 46.14,37.49 42.27,37.49 41.52,38.24 39.53,38.24 37.54,40.22 37.54,42.73 35.19,45.08 34.03,45.08 32.9,46.21 31.14,46.21 30.87,46.48 28.02,46.48 27.25,47.24 22.4,47.24 18.48,51.16 18.48,52.27 18.13,52.62 16.2,52.62 11.94,56.89 11.94,61.12 15.03,64.21 15.03,74.11 13.9,75.24 v2(13.9,75.74)
  BOTTOM w0.127: v2(13.9,75.74) 14.47,76.31 14.47,78.84 14.86,79.23 14.86,80.71 15.45,81.3 16.11,81.3 RS42.2 17.31,80.54 17.42,80.44 US2.7 ; v2(115.18,24.01) 115.23,24.01 116.47,22.77 124.59,22.77 125.47,21.89 127.46,21.89 128.2,22.63 134.68,22.63 135.58,21.72 138.43,21.72 138.81,22.1 141.8,22.1 142.23,22.53 146.25,22.53 146.34,22.45 v2(146.84,22.45)
USB_CTL3: length 200.6
  TOP w0.127: v2(148.45,11.86) 148.45,12.02 148.81,12.38 149.87,12.38 150.44,11.82 UK1.38 152.92,11.82 RK28.2 ; v2(13.97,79.13) v3(13.55,79.56)
  IN2 w0.127: v2(148.45,11.86) 148.35,11.96 146.29,11.96 145.75,11.42 135.5,11.42 135.06,11.86 132.2,11.86 131.86,12.2 126.64,12.2 125.18,10.75 117.36,10.75 116.59,11.51 114.75,11.51 114.59,11.36 109.42,11.36 109.04,11.74 101.35,11.74 98.2,14.89 90.91,14.89 90.56,14.55 76.37,14.55 74.27,16.64 65.61,16.64 61.65,20.6 58.61,20.6 58.25,20.96 58.25,21.29 57.03,22.52 56.1,22.52 55.94,22.67 55.94,25.43 52.93,28.44 52.93,34.6 51.74,35.79 51.74,36.88 51.34,37.29 46.73,37.29 46.03,37.98 42.16,37.98 41.63,38.51 39.64,38.51 37.81,40.33 37.81,42.85 35.35,45.31 34.22,45.31 33,46.53 31.21,46.53 30.98,46.75 28.13,46.75 26.69,48.19 23.89,48.19 19.19,52.89 16.31,52.89 12.21,57 12.21,61.01 15.29,64.1 15.29,74.82 14.47,75.64 14.47,75.98 13.97,76.47 v2(13.97,79.13)
  BOTTOM w0.127: US2.8 17.28,80.94 16.65,81.56 15.34,81.56 14.6,80.82 14.6,79.56 14.17,79.13 v2(13.97,79.13)
USB_IN_STATUS#: length 182.6
  TOP w0.127: v2(137.37,18.11) 137.08,17.82 UK1.108
  IN2 w0.127: v2(79.26,46.39) 79.17,46.49 68.35,46.49 67.63,45.77 59.26,45.77 59.21,45.71 56.65,45.71 56.21,45.27 52.65,45.27 50.22,47.7 49.73,47.7 49.08,48.35 47.25,48.35 45.82,49.78 45.06,49.78 38.37,54.36 36.85,54.93 36.66,55.12 36.58,55.12 34.19,57.52 34.19,58.25 32.88,59.57 32.64,59.57 31.57,60.63 31.57,62.04 27.04,66.57 27.04,69.53 25.39,71.19 25.39,74.04 24.95,74.48 24.95,75.55 24.62,75.88 24.62,76.59 23.47,77.75 23.47,80.65 22.84,81.28 22.84,84.83 23.39,85.37 23.39,86.43 v2(23.21,86.61)
  IN3 w0.127: v2(108.37,22.76) 107.98,22.36 100.86,22.36 99.07,24.14 99.07,24.95 98.3,25.72 v2(98.3,26.16)
  BOTTOM w0.127: v2(98.3,26.16) 98.59,26.16 99.14,26.71 99.14,27.27 99.74,27.87 99.74,28.42 97.62,30.53 97.62,39.51 98.23,40.12 98.99,40.12 99.58,40.71 99.58,45.15 97.75,46.98 83.44,46.98 83.23,46.77 82.8,46.34 79.32,46.34 v2(79.26,46.39) ; v2(137.37,18.11) 137.27,18.21 137.27,18.51 136.85,18.93 132.72,18.93 131.84,19.81 124.61,19.81 123.72,20.69 120.04,20.69 119.54,20.19 117.38,20.19 116.88,20.69 114.3,20.69 113.12,21.87 110.5,21.87 109.61,22.76 v2(108.37,22.76) ; v2(23.21,86.61) 22.27,86.61 22.01,86.34 19.72,86.34 v1(19.44,86.06) 18.24,84.86 18.24,83.55 RS43.2 18.52,82.68 19.03,82.17 US2.9
USB_OC0#: length 240
  TOP w0.127: v2(186.34,27.94) 187.07,27.94 v1(188.51,26.49) 189.05,25.95 190.86,25.95 191.39,25.42 195.69,25.42 196.2,25.93 196.42,25.93 196.84,26.35 v2(196.99,26.35)
  TOP w0.135: RH217.1 185.67,28.6 v2(186.34,27.94)
  IN2 w0.127: v2(80.08,46.79) 80.03,46.84 79.06,46.84 78.98,46.76 68.24,46.76 67.51,46.04 59.15,46.04 59.09,45.98 56.54,45.98 56.1,45.54 52.76,45.54 50.33,47.97 49.84,47.97 49.19,48.62 48.25,48.62 47.59,49.28 47.3,49.51 47.14,49.58 46.47,49.58 45.96,50.08 45.09,50.08 38.19,54.81 36.81,55.39 36.7,55.39 34.46,57.63 34.46,58.36 32.99,59.83 32.76,59.83 31.84,60.75 31.84,62.2 27.35,66.69 27.35,69.61 25.66,71.3 25.66,74.16 25.22,74.59 25.22,75.66 24.89,75.99 24.89,76.7 23.74,77.86 23.74,79.85 v2(24.05,80.16) ; v2(186.34,27.94) 185.16,29.12 182.66,29.12 180.11,26.56 179.57,26.56 175.37,22.36 161.27,22.36 160.66,22.98 152.54,22.98 151,21.44 146.49,21.44 145.81,22.12 142.6,22.12 142.28,21.8 138.85,21.8 138.23,21.18 136.44,21.18 135.64,20.38 133.1,20.38 132.13,21.35 130.1,21.35 129.86,21.11 123.71,21.11 123.43,20.83 119.79,20.83 119.14,20.17 117.43,20.17 117.16,20.44 112.35,20.44 109.28,23.51 99.77,23.51 97.62,21.36 v2(96.21,21.36)
  BOTTOM w0.127: UH1.AH36 196.94,26.4 v2(196.99,26.35) ; RS10.1 23.7,80.51 v2(24.05,80.16) ; v2(96.21,21.36) 96.21,23.14 96.45,23.39 97.39,23.39 98.09,24.09 98.09,24.96 99.4,26.28 99.4,27.17 100,27.76 100,28.53 97.88,30.64 97.88,39.4 98.34,39.85 99.1,39.85 99.84,40.6 99.84,45.26 97.86,47.24 83.34,47.24 82.69,46.6 80.27,46.6 v2(80.08,46.79)
